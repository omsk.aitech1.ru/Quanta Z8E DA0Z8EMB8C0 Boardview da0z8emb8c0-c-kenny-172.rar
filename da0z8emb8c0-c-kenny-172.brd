# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ43: length 52.3
  TOP w0.102: v1(81.49,44.56) 80.1,43.17 74.04,43.17 71.52,40.64 71.52,40.5 72.2,39.81 72.2,39.67 72.06,39.53 71.92,39.53 71.23,40.21 71.09,40.21 70.94,40.07 70.94,39.92 71.46,39.41 71.46,39.26 71.32,39.12 71.17,39.12 70.65,39.64 70.51,39.64 70.01,39.14 69.68,39.14 69.58,39.24 69.58,39.61 69.48,39.71 69.28,39.71 69.18,39.61 69.18,39.17 69.05,39.05 68.89,39.05 68.77,39.17 68.77,39.61 68.67,39.71 68.47,39.71 68.36,39.61 68.36,38.63 68.24,38.5 68.06,38.5 67.96,38.6 67.96,39.61 67.86,39.71 67.65,39.71 67.55,39.61 67.55,38.6 67.42,38.47 67.14,38.47 67.04,38.57 67.04,39.61 66.94,39.71 66.74,39.71 66.64,39.61 66.64,38.62 66.48,38.47 66.28,38.47 66.18,38.57 66.18,39.38 66.07,39.49 65.87,39.49 65.77,39.39 65.77,38.57 65.67,38.47 65.47,38.47 65.37,38.57 65.37,38.98 65.26,39.08 65.06,39.08 64.96,38.98 64.96,38.57 64.86,38.47 58.2,38.47 57.92,38.75 57.92,42.96 57.59,43.29 55.38,43.29 55.18,43.09 v2(55.18,42.47)
  BOTTOM w0.102: CN2019.203 55.34,43.71 55.18,43.55 v2(55.18,42.47) ; v1(81.49,44.56) 81.81,44.88 U2030.AU27
M_A_DQ44: length 52.6
  TOP w0.102: v2(53.17,46.45) 54.08,47.36 62.93,47.36 63.51,46.77 63.84,46.77 63.94,46.67 63.94,44.92 64.04,44.82 64.25,44.82 64.35,44.92 64.35,46.67 64.45,46.77 64.65,46.77 64.76,46.67 64.76,44.92 64.86,44.82 65.06,44.82 65.16,44.92 65.16,46.67 65.26,46.77 65.47,46.77 65.57,46.67 65.57,44.92 65.67,44.82 65.87,44.82 65.97,44.92 65.97,46.67 66.08,46.77 66.28,46.77 66.38,46.67 66.38,44.92 66.48,44.82 66.69,44.82 66.79,44.92 66.79,46.67 66.89,46.77 72.72,46.77 74.72,48.77 79.46,48.77 80.61,49.92 84.94,49.92 v1(85.3,49.56)
  BOTTOM w0.102: CN2019.190 52.67,46.96 v2(53.17,46.45) ; U2030.AL22 85.71,49.97 v1(85.3,49.56)
M_A_DQ45: length 52
  TOP w0.102: v2(52.5,46.46) 53.95,47.92 57.6,47.92 57.7,48.02 57.7,49.54 57.8,49.64 58.01,49.64 58.11,49.54 58.11,48.02 58.21,47.92 58.41,47.92 58.51,48.02 58.51,49.54 58.62,49.64 58.82,49.64 58.92,49.54 58.92,48.02 59.02,47.92 59.22,47.92 59.33,48.02 59.33,49.54 59.43,49.64 59.63,49.64 59.73,49.54 59.73,48.02 59.83,47.92 60.04,47.92 60.14,48.02 60.14,49.54 60.24,49.64 60.44,49.64 60.55,49.54 60.55,48.02 60.65,47.92 v2(61.53,47.92) 62.86,47.92 63.67,47.1 72.58,47.1 74.58,49.1 79.28,49.1 80.35,50.18 85.45,50.18 v1(86.07,49.56)
  BOTTOM w0.102: CN2019.194 51.99,45.96 v2(52.5,46.46) ; U2030.AL21 86.51,50.01 v1(86.07,49.56)
M_A_DQ46: length 53
  TOP w0.102: v2(51.61,42.48) 52.17,43.04 53.78,43.04 54.7,43.95 57.95,43.95 58.71,43.19 58.71,40.07 58.84,39.94 59.04,39.94 59.17,40.07 59.17,41.85 59.29,41.97 59.55,41.97 59.68,41.85 59.68,41.36 59.75,41.29 60.06,41.29 60.13,41.36 60.13,41.77 60.26,41.9 60.68,41.9 61.02,41.56 61.02,40.75 61.15,40.63 63.15,40.63 63.28,40.49 63.28,39.84 63.38,39.74 63.56,39.74 63.66,39.84 63.66,40.52 63.76,40.63 63.96,40.63 64.06,40.52 64.06,39.84 64.17,39.74 64.37,39.74 64.47,39.84 64.47,40.52 64.57,40.63 64.78,40.63 64.88,40.52 64.88,39.84 64.98,39.74 65.18,39.74 65.28,39.84 65.28,40.19 65.59,40.5 66.83,40.5 67.06,40.73 67.06,41.03 67.16,41.13 67.37,41.13 67.47,41.03 67.47,40.47 67.57,40.37 67.77,40.37 67.87,40.47 67.87,41.03 67.98,41.13 68.18,41.13 68.28,41.03 68.28,40.47 68.38,40.37 68.59,40.37 68.69,40.47 68.69,41.03 68.79,41.13 68.99,41.13 69.09,41.03 69.09,40.47 69.2,40.37 69.4,40.37 69.5,40.47 69.5,41.03 69.6,41.13 70.9,41.13 74.02,44.25 74.02,44.25 74.41,44.64 78.46,44.64 79.9,46.09 83.18,46.09 v1(83.65,46.56)
  BOTTOM w0.102: U2030.AP24 84.1,47.01 v1(83.65,46.56) ; v2(51.61,42.48) 51.58,42.46 CN2019.208
M_A_DQ47: length 52.4
  TOP w0.102: v1(84.91,46.34) 84.26,46.34 83.5,45.58 83.5,44.56 83.04,44.11 81.72,44.11 80.4,42.79 74.13,42.79 72.54,41.2 72.54,38.94 72.38,38.77 69.23,38.77 68.6,38.14 57.8,38.14 57.59,37.93 56.53,37.93 56.4,38.06 56.4,38.37 56.5,38.47 57.31,38.47 57.52,38.67 57.52,39.64 57.42,39.74 53.45,39.74 53.35,39.84 53.35,40.21 53.45,40.31 57.42,40.31 57.52,40.41 57.52,41.26 57.39,41.39 55.94,41.39 55.81,41.52 55.81,41.79 55.94,41.92 56.32,41.92 56.45,42.05 v2(56.45,42.47)
  BOTTOM w0.102: v1(84.91,46.34) U2030.AP23 ; CN2019.207 57.55,42.71 57.34,42.91 56.79,42.91 56.45,42.58 v2(56.45,42.47)
M_A_DQ48: length 51.8
  IN1 w0.089: v1(82.03,43.05) 81.55,42.57 81.37,42.57 80.96,42.99 80.67,42.99 80.58,42.9 80.58,42.49 80.49,42.4 80.33,42.4 80.12,42.61 79.99,42.61 79.56,42.18 77.13,42.18 76.79,41.83 76.28,41.83 76.01,41.56 75.51,41.56 75.42,41.47 75.42,41.13 75.33,41.05 75.15,41.05 75.06,41.13 75.06,41.47 74.97,41.56 70.36,41.56 70.27,41.65 70.27,42.47 70.18,42.56 70,42.56 69.91,42.47 69.91,41.65 69.82,41.56 69.65,41.56 69.56,41.65 69.56,42.47 69.47,42.56 69.29,42.56 69.2,42.47 69.2,41.65 69.11,41.56 68.93,41.56 68.85,41.65 68.85,42.47 68.76,42.56 68.58,42.56 68.45,42.43 68.45,41.69 68.36,41.6 68.18,41.6 68.09,41.69 68.09,42.43 67.97,42.56 64.25,42.56 64.12,42.43 64.12,41.69 63.99,41.56 60.4,41.56 60.27,41.43 60.27,40.9 60.12,40.75 57.49,40.75 57.29,40.55 55.87,40.55 55.43,40.12 50.89,40.12 50.8,40.21 50.8,40.87 50.89,40.96 51.07,40.96 51.24,40.79 51.24,40.59 51.33,40.5 54.96,40.5 55.05,40.59 v2(55.05,40.95)
  BOTTOM w0.102: CN2019.215 57.55,40.71 57.36,40.52 55.69,40.52 55.43,40.27 55.18,40.27 55.05,40.4 v2(55.05,40.95) ; v1(82.03,43.05) 82.29,43.31 U2030.AW26
M_A_DQ49: length 52.5
  IN1 w0.089: v2(53.64,40.95) 53.64,41.58 53.55,41.67 51.47,41.67 51.36,41.78 51.36,42.01 51.42,42.07 53.61,42.07 53.7,42.16 53.7,42.57 53.83,42.7 53.97,42.7 54.06,42.61 54.06,42.16 54.14,42.07 57.45,42.07 57.54,42.16 57.54,42.61 57.63,42.7 57.8,42.7 57.89,42.61 57.89,42.16 57.98,42.07 58.16,42.07 58.25,42.16 58.25,42.61 58.34,42.7 58.51,42.7 58.6,42.61 58.6,42.16 58.69,42.07 58.87,42.07 58.96,42.16 58.96,42.61 59.05,42.7 59.23,42.7 59.31,42.61 59.31,42.16 59.4,42.07 59.92,42.07 60.15,42.31 60.15,42.58 60.28,42.7 60.46,42.7 60.55,42.61 60.55,42.28 60.64,42.19 60.82,42.19 60.9,42.28 60.9,42.61 60.99,42.7 61.17,42.7 61.26,42.61 61.26,42.28 61.35,42.19 61.53,42.19 61.62,42.28 61.62,42.61 61.71,42.7 62.25,42.7 62.76,43.22 62.88,43.22 62.98,43.11 62.98,42.85 63.11,42.72 63.29,42.72 63.37,42.81 63.37,44.2 63.52,44.34 64.93,44.34 65.06,44.21 65.06,44.08 64.96,43.98 63.98,43.98 63.86,43.85 63.86,43.72 63.98,43.6 65.04,43.6 65.45,43.19 73.95,43.19 74.28,42.86 79.31,42.86 80.14,43.69 82.03,43.69 82.12,43.78 82.12,44.08 82.21,44.17 82.39,44.17 82.48,44.08 82.48,43.51 82.57,43.42 82.7,43.42 v1(82.94,43.66)
  BOTTOM w0.102: U2030.AV25 83.29,44.23 83.1,44.23 82.94,44.07 v1(82.94,43.66) ; v2(53.64,40.95) 53.14,41.46 CN2019.212
M_A_DQ50: length 52.6
  IN1 w0.089: v2(55.56,36.94) 55.81,37.2 55.81,37.83 55.94,37.96 56.23,37.96 56.32,37.87 56.32,37.42 56.41,37.33 56.59,37.33 56.67,37.42 56.67,37.87 56.76,37.96 56.94,37.96 57.03,37.87 57.03,37.6 57.12,37.51 57.3,37.51 57.39,37.6 57.39,37.89 57.48,37.99 57.65,37.99 57.74,37.9 57.74,37.6 57.83,37.51 58,37.51 58.1,37.61 58.1,38.57 58.22,38.7 58.36,38.7 58.46,38.6 58.46,37.6 58.55,37.51 58.71,37.51 58.82,37.63 58.82,38.31 58.93,38.42 59.09,38.42 59.18,38.33 59.18,37.93 59.27,37.84 59.44,37.84 59.53,37.94 59.53,38.22 59.64,38.33 59.8,38.33 59.89,38.24 59.89,37.79 59.98,37.7 60.16,37.7 60.29,37.83 60.29,38.21 60.41,38.33 61.66,38.33 61.89,38.11 62.08,38.11 62.31,38.33 62.49,38.33 62.71,38.11 62.89,38.11 62.98,38.2 62.98,38.36 63.07,38.45 63.25,38.45 63.34,38.36 63.34,38.2 63.43,38.11 63.6,38.11 63.69,38.2 63.69,38.36 63.78,38.45 63.96,38.45 64.05,38.36 64.05,38.2 64.14,38.11 64.31,38.11 64.4,38.2 64.4,38.31 64.53,38.44 70.4,38.44 70.49,38.35 70.49,37.06 70.61,36.94 70.75,36.94 70.84,37.04 70.84,38.33 70.96,38.44 71.14,38.44 71.27,38.31 71.27,36.66 71.39,36.53 71.53,36.53 71.62,36.62 71.62,38.31 71.75,38.44 81.36,38.44 84.58,41.66 84.58,42.73 84.52,42.79 84.52,43.12 84.96,43.56 v1(84.96,43.68)
  BOTTOM w0.102: v1(84.96,43.68) 85.19,43.68 U2030.AV22 ; v2(55.56,36.94) 55.56,37.81 55.96,38.21 CN2019.225
M_A_DQ51: length 51.8
  IN1 w0.089: v2(57.08,36.95) 57.33,37.2 58.86,37.2 59.19,37.53 59.37,37.53 59.45,37.44 59.45,37.28 59.09,36.91 59.09,36.7 59.43,36.35 59.97,36.35 60.18,36.56 60.18,37.3 60.31,37.42 60.49,37.42 60.59,37.32 60.59,37.11 60.72,36.98 61.2,36.98 61.32,37.11 61.32,37.19 61.41,37.28 61.59,37.28 61.68,37.19 61.68,37.07 61.77,36.98 61.94,36.98 62.03,37.07 62.03,37.19 62.12,37.28 62.3,37.28 62.39,37.19 62.39,37.07 62.48,36.98 62.66,36.98 62.74,37.07 62.74,37.19 62.83,37.28 63.01,37.28 63.1,37.19 63.1,37.07 63.19,36.98 63.37,36.98 63.46,37.07 63.46,37.19 63.54,37.28 63.72,37.28 63.81,37.19 63.81,37.07 63.9,36.98 64.08,36.98 64.17,37.07 64.17,37.19 64.26,37.28 64.43,37.28 64.52,37.19 64.52,37.07 64.61,36.98 64.93,36.98 65.02,37.07 65.02,38.04 65.11,38.12 65.28,38.12 65.37,38.04 65.37,37.07 65.46,36.98 65.71,36.98 65.82,36.87 66.58,36.87 66.65,36.94 66.65,37.17 66.53,37.3 66.04,37.3 65.91,37.42 65.91,37.97 66.04,38.1 69.33,38.1 69.45,37.97 69.45,37.56 69.58,37.43 69.68,37.43 69.81,37.56 69.81,37.98 69.86,38.04 70.04,38.04 70.17,37.91 70.17,36.79 70.35,36.6 70.67,36.6 71.07,36.2 71.81,36.2 71.94,36.32 71.94,38 72.07,38.12 72.23,38.12 72.32,38.04 72.32,36.41 72.41,36.32 72.59,36.32 72.68,36.41 72.68,38 72.78,38.11 72.92,38.11 73.03,38 73.03,37.06 73.11,36.97 73.24,36.97 73.37,37.1 73.37,37.91 73.46,38 81.37,38 84.91,41.54 v1(84.91,42.95)
  BOTTOM w0.102: CN2019.229 57.33,37.21 v2(57.08,36.95) ; U2030.AW22 85.27,43.31 v1(84.91,42.95)
M_A_DQ52: length 52
  IN1 w0.089: v1(82.15,44.56) 81.72,44.13 80.02,44.13 79.08,43.19 74.4,43.19 74.08,43.51 65.58,43.51 65.37,43.72 65.37,44.53 65.25,44.66 63.18,44.66 63.06,44.53 63.06,43.96 62.12,43.02 50.32,43.02 50.1,42.8 50.1,37.34 50.19,37.26 50.39,37.26 50.48,37.34 50.48,42.44 50.67,42.63 50.9,42.63 50.99,42.54 50.99,41.44 51.08,41.35 51.94,41.35 v2(52.34,40.95)
  BOTTOM w0.102: v2(52.34,40.95) 51.84,40.46 CN2019.216 ; U2030.AU26 82.51,44.92 v1(82.15,44.56)
M_A_DQ53: length 52
  IN1 w0.089: v1(81.49,43.31) 80.21,43.31 79.44,42.54 76.82,42.54 76.72,42.44 76.72,42.21 76.66,42.15 76.53,42.15 76.34,42.34 76.34,42.42 76.22,42.54 75.86,42.54 75.71,42.39 75.48,42.39 75.32,42.54 74.06,42.54 73.98,42.45 73.98,42.02 73.84,41.88 73.66,41.88 73.57,41.97 73.57,42.79 73.48,42.88 73.28,42.88 73.19,42.79 73.19,41.97 73.1,41.88 72.9,41.88 72.81,41.97 72.81,42.79 72.72,42.88 72.54,42.88 72.45,42.79 72.45,41.97 72.36,41.88 72.19,41.88 72.1,41.97 72.1,42.79 72.01,42.88 71.83,42.88 71.74,42.79 71.74,41.97 71.65,41.88 71.47,41.88 71.39,41.97 71.39,42.79 71.3,42.88 71.12,42.88 71.03,42.79 71.03,41.97 70.94,41.88 70.76,41.88 70.67,41.97 70.67,42.79 70.59,42.88 65.02,42.88 64.9,42.99 64.9,43.16 64.78,43.28 64.55,43.28 64.45,43.18 64.45,42.96 64.37,42.89 64.2,42.89 64.1,42.99 64.1,43.18 63.99,43.28 63.82,43.28 63.69,43.15 63.69,42 63.57,41.88 63.41,41.88 63.31,41.98 63.31,42.25 63.18,42.38 63,42.38 62.94,42.32 62.94,42 62.81,41.88 62.63,41.88 62.5,42 62.5,42.3 62.42,42.39 62.25,42.39 62.15,42.29 62.15,41.97 62.06,41.88 60.17,41.88 59.96,41.66 59.96,41.22 59.83,41.1 59.69,41.1 59.6,41.18 59.6,41.63 59.47,41.76 59.31,41.76 59.22,41.67 59.22,41.21 59.11,41.09 58.96,41.09 58.87,41.18 58.87,41.67 58.78,41.76 58.6,41.76 58.51,41.67 58.51,41.18 58.42,41.09 58.27,41.09 58.16,41.21 58.16,41.67 58.07,41.76 57.89,41.76 57.8,41.67 57.8,41.2 57.71,41.11 57.57,41.11 57.45,41.24 57.45,41.67 57.36,41.76 57.18,41.76 57.09,41.67 57.09,41.43 57,41.35 56.84,41.35 56.73,41.45 56.73,41.67 56.65,41.76 54.05,41.76 53.96,41.67 53.96,41.48 54.05,41.39 56.23,41.39 56.32,41.3 v2(56.32,40.95)
  BOTTOM w0.102: CN2019.211 57.07,41.71 v2(56.32,40.95) ; U2030.AV27 81.81,43.62 v1(81.49,43.31)
M_A_DQ54: length 52.1
  IN1 w0.089: v2(52.17,39.01) 52.17,39.34 52.25,39.43 53.08,39.43 53.19,39.55 53.19,39.71 53.11,39.8 51.8,39.8 51.71,39.71 51.71,39.51 51.62,39.42 51.45,39.42 51.36,39.51 51.36,39.71 51.27,39.8 50.95,39.8 50.86,39.71 50.86,38.72 50.99,38.59 57.22,38.59 58.08,39.46 59,39.46 59.09,39.37 59.09,39.17 59.17,39.08 59.35,39.08 59.44,39.17 59.44,39.37 59.53,39.46 61.13,39.46 61.31,39.64 62.14,39.64 62.27,39.51 62.27,39.2 62.43,39.04 62.58,39.04 62.65,39.1 62.65,39.53 62.75,39.64 62.89,39.64 63.03,39.49 63.03,39.2 63.15,39.08 74.15,39.08 74.32,39.26 74.5,39.26 74.68,39.08 74.86,39.08 75.04,39.26 75.21,39.26 75.39,39.08 75.57,39.08 75.75,39.26 75.93,39.26 76.1,39.08 76.28,39.08 76.46,39.26 76.64,39.26 76.81,39.08 78.9,39.08 79.03,39.21 79.03,39.53 79.12,39.62 79.32,39.62 79.41,39.53 79.41,39.17 79.5,39.08 79.67,39.08 79.78,39.2 79.78,39.79 79.87,39.87 80.04,39.87 80.14,39.77 80.14,39.17 80.23,39.08 80.42,39.08 80.51,39.17 80.51,40.54 80.6,40.63 80.78,40.63 80.86,40.54 80.86,39.17 80.95,39.08 81.1,39.08 81.37,39.35 81.37,40.13 82.32,41.08 82.99,41.08 83.93,42.02 v1(83.93,42.95)
  BOTTOM w0.102: v1(83.93,42.95) 84.3,43.31 U2030.AW23 ; v2(52.17,39.01) 51.61,38.46 CN2019.224
M_A_DQ55: length 52.3
  IN1 w0.089: v2(52.22,36.99) 51.69,36.46 51.19,36.46 50.96,36.23 50.33,36.23 50.2,36.35 50.2,36.69 50.33,36.82 50.63,36.82 50.8,36.98 50.8,38.19 50.89,38.28 51.2,38.28 51.29,38.19 51.29,37.48 51.38,37.39 51.56,37.39 51.65,37.48 51.65,38.19 51.74,38.28 51.92,38.28 52,38.19 52,37.48 52.09,37.39 52.27,37.39 52.36,37.48 52.36,38.19 52.45,38.28 52.63,38.28 52.72,38.19 52.72,37.69 52.81,37.6 52.98,37.6 53.07,37.69 53.07,38.19 53.16,38.28 53.34,38.28 53.43,38.19 53.43,38.05 53.52,37.96 53.69,37.96 53.78,38.05 53.78,38.19 53.87,38.28 54.05,38.28 54.14,38.19 54.14,38.05 54.23,37.96 54.41,37.96 54.49,38.05 54.49,38.19 54.58,38.28 57.35,38.28 58.18,39.1 58.7,39.1 59.06,38.74 59.68,38.74 59.77,38.65 62.63,38.65 62.75,38.77 81.24,38.77 81.68,39.21 81.68,40 82.4,40.71 83.08,40.71 84.25,41.88 84.25,42.72 84.31,42.79 84.31,43.45 84.52,43.65 84.52,44.72 v1(84.96,45.16)
  BOTTOM w0.102: CN2019.228 52.09,37.46 52.22,37.33 v2(52.22,36.99) ; v1(84.96,45.16) 85.06,45.16 U2030.AT22
M_A_DQ56: length 52.6
  IN1 w0.089: v1(86,43) 86,42.03 86.14,41.89 86.14,40.79 85.04,39.68 85.04,38.59 83.13,36.67 74.95,36.67 73.15,34.86 69.43,34.86 68.88,35.41 64.95,35.41 64.72,35.65 61.28,35.65 61.14,35.51 61.14,35.1 61.05,35.01 54.51,35.01 54.42,35.1 54.42,35.4 54.34,35.49 54.16,35.49 54.07,35.4 54.07,35.1 53.98,35.01 53.8,35.01 53.71,35.1 53.71,35.4 53.62,35.49 53.45,35.49 53.36,35.4 53.36,35.1 53.27,35.01 53.09,35.01 53,35.1 53,35.4 52.91,35.49 52.74,35.49 52.65,35.4 52.65,35.1 52.56,35.01 50.99,35.01 50.86,34.89 50.86,33.46 50.77,33.38 50.53,33.38 50.44,33.46 50.44,35.38 50.59,35.53 52.15,35.53 52.24,35.62 v2(52.24,35.93)
  BOTTOM w0.102: v2(52.24,35.93) 51.77,35.46 CN2019.236 ; U2030.AW21 86.31,43.31 v1(86,43)
M_A_DQ57: length 53.3
  IN1 w0.089: v1(86,44.39) 86.31,44.39 86.4,44.31 86.4,42.08 86.46,42.02 86.46,40.65 85.36,39.55 85.36,38.45 83.26,36.35 75.08,36.35 73.28,34.55 69.3,34.55 68.75,35.1 64.82,35.1 64.58,35.33 61.55,35.33 61.46,35.24 61.46,34.78 61.37,34.7 57.4,34.7 57.31,34.61 57.31,34.03 57.22,33.95 57.05,33.95 56.96,34.03 56.96,34.61 56.87,34.7 51.46,34.7 51.37,34.61 51.37,34.41 51.46,34.32 54.74,34.32 v2(55.14,33.92)
  BOTTOM w0.102: v1(86,44.39) 86.03,44.39 86.45,44.81 U2030.AU21 ; v2(55.14,33.92) 55.14,33.94 56.28,35.08 57.29,35.08 57.42,35.21 CN2019.237
M_A_DQ58: length 53.2
  IN1 w0.089: v2(53.56,32.23) 54.16,31.99 55.07,31.62 57.25,31.62 59.01,31.48 60.13,31.43 60.26,31.42 60.39,31.42 64.45,31.24 68.18,31.24 68.26,31.16 69.06,31.16 73.8,32.51 74.01,32.57 75.88,34.43 84.87,34.43 85.84,35.4 86.72,35.4 87.69,36.37 87.69,38.9 88.85,40.05 88.85,40.49 88.63,40.7 88.63,45.4 88.3,45.73 87.87,45.73 87.18,46.42 86.34,46.42 v1(86,46.76)
  BOTTOM w0.102: CN2019.246 52.84,32.96 v2(53.56,32.23) ; U2030.AP21 86.06,46.76 v1(86,46.76)
M_A_DQ59: length 53.6
  IN1 w0.089: v1(87.01,47.44) 87.56,46.89 87.56,46.75 87.77,46.54 88.25,46.54 88.61,46.19 88.61,45.99 89.01,45.58 89.19,45.58 89.46,45.3 89.46,43.7 89.45,43.42 89.38,41.67 89.3,39.5 89,37.96 88.68,36.31 88.65,36.14 88.54,36.03 88.19,35.78 84.95,34.12 77.61,34.12 74.13,32.27 68.5,30.58 68.07,30.47 65.87,30.47 60.26,30.96 59.83,31 55.27,31.25 52.71,31.86 52.56,31.99 v2(52.18,32.29)
  BOTTOM w0.102: U2030.AN20 v1(87.01,47.44) ; v2(52.18,32.29) 51.77,31.88 51.28,31.88 51.21,31.96 CN2019.250
M_A_DQ60: length 52.9
  IN1 w0.089: v2(53.51,35.93) 53.02,36.42 53.02,36.8 53.14,36.92 53.31,36.92 53.4,36.83 53.4,36.65 53.55,36.5 53.74,36.5 53.83,36.59 53.83,37.17 53.92,37.26 54.1,37.26 54.19,37.17 54.19,36.59 54.28,36.5 54.46,36.5 54.55,36.59 54.55,37.2 54.64,37.3 54.81,37.3 54.9,37.21 54.9,36.59 54.99,36.5 58.25,36.5 59.11,35.65 60.38,35.65 61.01,36.28 64.98,36.28 65.14,36.12 67.15,36.12 67.24,36.21 67.24,36.56 67.35,36.67 67.35,37.1 67.48,37.22 67.8,37.22 67.89,37.13 67.89,36.78 67.97,36.69 68.11,36.69 68.24,36.82 68.24,37.13 68.33,37.22 68.8,37.22 68.9,37.12 68.9,36.89 69.03,36.77 69.36,36.77 69.49,36.64 69.49,35.7 69.63,35.57 69.75,35.57 69.86,35.67 69.86,35.83 69.95,35.92 70.12,35.92 70.24,35.79 70.24,35.63 70.37,35.5 72.75,35.5 74.12,36.86 74.12,37.18 74.24,37.3 81.76,37.3 85.51,41.05 85.51,41.62 85.36,41.78 85.36,45.63 85.23,45.76 v1(84.94,45.76)
  BOTTOM w0.102: CN2019.232 52.98,36.46 v2(53.51,35.93) ; v1(84.94,45.76) 85.51,46.33 U2030.AR22
M_A_DQ61: length 52.7
  IN1 w0.089: v1(86.04,47.48) 85.41,46.85 85.41,46.26 85.61,46.06 85.61,42.73 85.68,42.66 85.68,41.9 85.83,41.76 85.83,40.92 81.89,36.99 74.56,36.99 74.43,36.86 74.43,36.6 73.01,35.18 69.56,35.18 68.94,35.8 65.01,35.8 64.85,35.97 61.14,35.97 60.51,35.33 58.68,35.33 58.59,35.42 58.59,35.71 58.5,35.8 58.33,35.8 58.24,35.71 58.24,35.42 58.15,35.33 57.97,35.33 57.88,35.42 57.88,36.09 57.79,36.18 57.61,36.18 57.53,36.09 57.53,35.42 57.44,35.33 57.26,35.33 57.17,35.42 57.17,36.09 57.08,36.18 56.9,36.18 56.81,36.09 56.81,35.42 56.73,35.33 56.55,35.33 56.46,35.42 56.46,36.09 56.37,36.18 56.19,36.18 56.1,36.09 56.1,35.42 56.01,35.33 55.84,35.33 55.75,35.42 55.75,36.09 55.66,36.18 55.48,36.18 55.39,36.09 55.39,35.42 55.3,35.33 54.99,35.33 54.9,35.42 v2(54.9,35.88)
  BOTTOM w0.102: U2030.AN22 85.71,47.81 v1(86.04,47.48) ; v2(54.9,35.88) 55.06,35.72 57.06,35.72 57.55,36.21 CN2019.233
M_A_DQ62: length 52.9
  IN1 w0.089: v2(56.24,32.35) 56.55,32.66 57.28,32.66 57.37,32.57 57.37,32.35 57.46,32.26 57.64,32.26 57.73,32.35 57.73,32.57 57.81,32.66 57.99,32.66 58.08,32.57 58.08,32.35 58.17,32.26 58.35,32.26 58.44,32.35 58.44,32.57 58.53,32.66 58.7,32.66 58.79,32.57 58.79,32.35 58.88,32.26 59.06,32.26 59.15,32.35 59.15,32.57 59.24,32.66 59.41,32.66 59.5,32.57 59.5,32.35 59.59,32.26 59.77,32.26 59.86,32.35 59.86,32.57 59.95,32.66 60.13,32.66 60.21,32.57 60.21,32.35 60.3,32.26 60.48,32.26 60.57,32.35 60.57,32.57 60.66,32.66 60.84,32.66 60.93,32.57 60.93,32.35 61.01,32.26 61.19,32.26 61.28,32.35 61.28,32.57 61.37,32.66 61.55,32.66 61.64,32.57 61.64,32.35 61.73,32.26 61.9,32.26 61.99,32.35 61.99,32.57 62.08,32.66 62.26,32.66 62.35,32.57 62.35,32.35 62.44,32.26 62.62,32.26 62.7,32.35 62.7,32.57 62.79,32.66 62.97,32.66 63.06,32.57 63.06,32.35 63.15,32.26 63.33,32.26 63.42,32.35 63.42,32.57 63.5,32.66 63.68,32.66 63.77,32.57 63.77,32.35 63.86,32.26 64.04,32.26 64.13,32.35 64.13,32.57 64.22,32.66 64.41,32.66 65.21,31.87 67.89,31.87 68.26,32.24 68.9,32.24 69.21,32.56 69.21,32.87 69.51,33.17 73.71,33.17 75.62,35.07 84.52,35.07 85.49,36.03 86.46,36.03 87.06,36.63 87.06,39.36 87.76,40.05 87.76,41.39 87.97,41.6 87.97,43.52 87.44,44.06 87.44,44.65 87.04,45.04 v1(87.04,45.18)
  BOTTOM w0.102: v1(87.04,45.18) 87.08,45.18 U2030.AT20 ; CN2019.245 57.35,33.21 56.89,32.75 56.58,32.75 56.32,33.01 56.07,33.01 55.94,32.88 55.94,32.65 v2(56.24,32.35)
M_A_DQ63: length 52.9
  IN1 w0.089: v2(54.95,32.32) 55.33,31.94 64.07,31.94 64.46,31.55 68.34,31.55 68.42,31.47 69.01,31.47 69.53,31.99 69.53,32.59 69.62,32.67 69.83,32.67 69.92,32.59 69.92,32 70.01,31.91 70.21,31.91 70.3,32 70.3,32.76 70.39,32.85 71.24,32.85 71.33,32.76 71.33,32.3 71.42,32.21 71.59,32.21 71.68,32.3 71.68,32.76 71.77,32.85 73.84,32.85 75.75,34.75 84.74,34.75 85.7,35.72 86.59,35.72 87.37,36.5 87.37,39.22 88.07,39.92 88.07,41.26 88.3,41.49 88.3,43.64 87.69,44.25 87.69,45.34 v1(87.04,45.99)
  BOTTOM w0.102: U2030.AR20 87.45,46.41 v1(87.04,45.99) ; CN2019.249 57.36,32.21 56.64,31.48 55.79,31.48 v2(54.95,32.32)
M_A_DQSN0: length 52.1
  IN1 w0.089: v1(85.02,70.23) 85.02,70.38 85.13,70.49 85.39,70.49 85.61,70.71 85.61,72.23 84.11,73.73 84.11,75.43 81.64,77.89 80,77.89 79.74,77.63 76.08,77.63 75.03,78.69 74.75,78.69 73.75,77.68 73.62,77.68 73.37,77.93 73.37,78.06 74.38,79.07 74.38,79.34 74.02,79.7 73.75,79.7 72.74,78.69 72.61,78.69 72.36,78.94 72.36,79.07 73.21,79.91 73.21,80.29 62.3,91.19 60.41,91.19 59.03,92.57 58.74,92.57 57.95,93.35 56.21,93.35 56.12,93.44 56.12,93.64 v2(56.33,93.84)
  BOTTOM w0.102: U2030.G22 85.24,70.01 v1(85.02,70.23) ; CN2019.11 57.5,93.71 57.21,93.41 56.12,93.41 55.97,93.56 55.97,93.74 56.07,93.84 v2(56.33,93.84)
M_A_DQSN1: length 53
  IN1 w0.089: v2(52.37,88.92) 52.51,89.06 52.51,89.39 52.8,89.67 54.14,89.67 55.31,88.51 57.45,88.51 63.43,82.52 63.43,80.64 63.94,80.14 63.94,77.87 64.47,77.33 65.59,77.33 66.23,77.96 66.86,77.96 67.8,77.02 67.8,76.49 67.07,75.76 67.07,73.52 67.16,73.44 67.52,73.44 67.61,73.52 67.61,75.38 67.8,75.58 68.3,75.58 68.49,75.38 68.49,73.52 68.58,73.44 72.65,73.44 73.46,72.63 78.93,72.63 79.05,72.5 79.71,72.5 80.2,72.02 80.2,71.28 80.53,70.95 80.53,70.32 80.76,70.09 81.71,70.09 81.9,69.9 81.9,69.67 v1(82.08,69.49)
  BOTTOM w0.102: U2030.H26 82.51,69.06 v1(82.08,69.49) ; v2(52.37,88.92) 52.48,88.81 52.48,88.48 52.29,88.29 51.33,88.29 51.17,88.46 CN2019.32
M_A_DQSN2: length 53
  IN1 w0.089: v2(55.13,82.41) 55.42,82.41 55.51,82.33 55.51,82.02 55.7,81.82 57.29,81.82 57.88,81.24 57.88,79.39 57.56,79.08 57.56,78.6 57.23,78.27 55.36,78.27 55.05,77.96 55.05,75.68 55.31,75.42 57.47,75.42 57.56,75.33 57.56,74.63 57.34,74.41 55.82,74.41 55.43,74.02 55.43,73.33 55.75,73.01 58.02,73.01 58.39,72.64 60.74,72.64 62.11,71.27 62.11,70.32 63.11,69.32 71.01,69.32 73.22,67.12 78.09,67.12 80.28,64.93 81.73,64.93 81.91,65.11 81.91,65.26 v1(82.16,65.5)
  BOTTOM w0.102: v2(55.13,82.41) 55.18,82.41 55.84,83.07 57.41,83.07 57.55,83.21 CN2019.53 ; U2030.N26 82.51,65.14 v1(82.16,65.5)
M_A_DQSN3: length 52.7
  TOP w0.102: v1(85.91,64.51) 85.91,64.22 85.81,64.12 85.16,64.12 84.77,64.5 84.77,64.88 84.39,65.26 84.39,65.65 83.91,66.13 80.75,66.13 79.88,66.99 79.88,67.46 78.42,68.92 75.08,68.92 72.22,71.78 71.92,71.78 71.29,71.16 71.15,71.16 70.86,71.45 70.86,71.59 72.52,73.25 72.52,73.6 72.14,73.97 71.84,73.97 70.34,72.47 70.2,72.47 69.91,72.76 69.91,72.9 71.41,74.4 71.41,74.7 70.23,75.88 69.67,76.44 52.91,76.44 52.79,76.56 52.79,76.67 v2(53.08,76.96)
  BOTTOM w0.102: CN2019.74 51.16,77.96 51.33,77.78 52.5,77.78 52.79,77.49 52.79,77.25 v2(53.08,76.96) ; v1(85.91,64.51) 86.01,64.51 U2030.P21
M_A_DQSN4: length 52.9
  IN1 w0.089: v1(81.52,48.51) 81.7,48.51 81.79,48.42 81.79,48.2 81.7,48.11 80.69,48.11 78.85,46.26 74.97,46.26 74.67,46.56 67.78,46.56 67.47,46.88 61.71,46.88 61.48,46.65 61.48,46.57 61.35,46.44 61.15,46.44 61.02,46.57 61.02,47.29 60.76,47.55 60.28,47.55 60.08,47.36 60.08,45.8 59.99,45.71 59.62,45.71 59.52,45.81 59.52,48.79 59.21,49.1 58.82,49.1 58.63,48.91 58.63,45.33 58.54,45.24 58.17,45.24 58.08,45.33 58.08,46.94 57.89,47.13 55.8,47.13 55.62,47.31 55.62,47.57 55.71,47.66 57.89,47.66 58.08,47.85 58.08,50.14 57.89,50.33 57.48,50.33 57.16,50.01 57.16,49.34 57.04,49.21 56.63,49.21 56.52,49.31 56.09,49.31 55.9,49.5 55.9,50.22 56.04,50.36 v2(56.28,50.36)
  BOTTOM w0.102: U2030.AM27 81.6,49.01 81.39,48.81 81.39,48.64 v1(81.52,48.51) ; CN2019.177 57.53,50.21 57.24,49.91 56.03,49.91 55.93,50.01 55.93,50.29 56.03,50.39 56.26,50.39 v2(56.28,50.36)
M_A_DQSN5: length 52.4
  TOP w0.102: v2(52.26,45.1) 52.45,44.9 52.45,44.35 53.04,43.76 53.62,43.76 54.67,44.82 54.67,45.33 54.93,45.58 57.52,45.58 57.62,45.48 57.62,45.06 57.84,44.84 58.4,44.84 58.61,45.06 58.61,45.48 58.71,45.58 59.03,45.58 59.13,45.47 59.13,44.66 60.24,43.55 60.86,43.55 60.96,43.45 60.96,42.77 61.17,42.56 61.74,42.56 61.95,42.77 61.95,43.45 62.05,43.55 62.46,43.55 62.56,43.45 62.56,42.77 62.77,42.56 63.34,42.56 63.55,42.77 63.55,43.45 63.65,43.55 64.06,43.55 64.16,43.45 64.16,42.77 64.37,42.56 64.94,42.56 65.15,42.77 65.15,43.45 65.25,43.55 65.66,43.55 65.76,43.45 65.76,42.77 65.97,42.56 66.54,42.56 66.75,42.77 66.75,43.45 66.85,43.55 67.26,43.55 67.36,43.45 67.36,42.77 67.58,42.56 68.14,42.56 68.35,42.77 68.35,43.45 68.45,43.55 68.86,43.55 68.96,43.45 68.96,42.77 69.18,42.56 69.74,42.56 69.95,42.77 69.95,43.45 70.05,43.55 70.46,43.55 70.56,43.45 70.56,42.88 70.83,42.61 71.34,42.61 71.55,42.83 71.55,43.45 71.65,43.55 72.28,43.55 74.94,46.21 78.8,46.21 80.52,47.93 82.89,47.93 83.12,47.69 83.16,47.55 83.08,47.43 v1(82.89,47.38)
  BOTTOM w0.102: v1(82.89,47.38) 83.31,47.8 U2030.AN25 ; CN2019.198 51.1,44.96 51.4,44.66 52.39,44.66 52.48,44.75 52.48,44.87 v2(52.26,45.1)
M_A_DQSN6: length 52
  IN1 w0.089: v1(84.01,45.46) 84.01,45.33 83.88,45.19 83.63,45.19 83.32,44.89 83.32,42.23 82.76,41.67 82.1,41.67 81.53,41.1 81.35,41.1 80.79,41.67 80.32,41.67 79.89,41.24 79.71,41.24 79.51,41.44 77.93,41.44 77.74,41.25 77.74,40.82 78.53,40.03 78.53,39.83 78.44,39.74 77.66,39.74 77.13,40.27 73.6,40.27 73.4,40.08 73.4,39.74 73.32,39.65 72.35,39.65 72.27,39.74 72.27,40.66 72.07,40.85 71.59,40.85 71.38,40.64 71.38,39.74 71.29,39.65 70.93,39.65 70.84,39.74 70.84,40.66 70.65,40.85 70.15,40.85 69.95,40.66 69.95,39.74 69.86,39.65 69.51,39.65 69.42,39.74 69.42,40.66 69.23,40.85 68.72,40.85 68.53,40.66 68.53,39.74 68.44,39.65 68.09,39.65 68,39.74 68,40.66 67.8,40.85 67.3,40.85 67.11,40.66 67.11,39.74 67.02,39.65 66.66,39.65 66.58,39.74 66.58,40.61 66.33,40.85 65.88,40.85 65.69,40.66 65.69,39.74 65.6,39.65 64.81,39.65 64.54,39.93 64.21,39.93 63.94,39.65 63.66,39.65 63.54,39.78 63.54,40.62 63.31,40.85 61.25,40.85 61,40.59 61,40.17 60.87,40.04 57.85,40.04 57.65,39.84 56.24,39.84 55.92,39.52 55.92,39.27 v2(55.69,39.05)
  BOTTOM w0.102: v2(55.69,39.05) 55.95,39.31 55.95,39.55 56.17,39.76 57.29,39.76 57.35,39.71 CN2019.219 ; v1(84.01,45.46) 84.41,45.86 U2030.AT23
M_A_DQSN7: length 52.9
  IN1 w0.089: v1(87.04,43.02) 87.04,43.15 87.1,43.21 87.35,43.21 87.44,43.12 87.44,41.89 87.18,41.64 87.18,40.37 86.07,39.26 86.07,37.42 84.29,35.64 75.38,35.64 73.57,33.83 69.37,33.83 68.77,33.23 67.35,33.23 67.07,32.96 67.07,32.66 66.85,32.44 66.03,32.44 65.9,32.57 65.9,32.88 65.54,33.23 64.57,33.23 64.48,33.32 64.48,34.43 64.29,34.62 63.79,34.62 63.59,34.43 63.59,33.32 63.5,33.23 63.15,33.23 63.06,33.32 63.06,34.43 62.87,34.62 62.36,34.62 62.17,34.43 62.17,33.32 62.08,33.23 53.47,33.23 53.11,33.59 53.11,33.79 53.2,33.88 v2(53.63,33.88)
  BOTTOM w0.102: CN2019.240 51.09,34.46 51.25,34.29 51.39,34.29 51.68,34.57 52.81,34.57 53.02,34.36 53.02,34.15 53.29,33.88 v2(53.63,33.88) ; U2030.AW20 87.23,43.02 v1(87.04,43.02)
M_A_DQSP0: length 52.1
  IN1 w0.089: v2(55.56,93.84) 55.82,93.84 55.95,93.71 55.95,93.37 56.14,93.17 57.88,93.17 58.66,92.39 58.95,92.39 60.33,91.01 62.23,91.01 73.03,80.21 73.03,79.98 72.18,79.14 72.18,78.87 72.54,78.51 72.81,78.51 73.82,79.52 73.95,79.52 74.2,79.27 74.2,79.14 73.19,78.13 73.19,77.86 73.55,77.5 73.82,77.5 74.83,78.51 74.95,78.51 76.01,77.46 79.82,77.46 80.08,77.72 81.57,77.72 83.93,75.35 83.93,73.65 85.43,72.16 85.43,70.78 85.32,70.67 85.11,70.67 85.02,70.76 v1(85.02,70.99)
  BOTTOM w0.102: U2030.F22 85.3,70.71 v1(85.02,70.99) ; CN2019.13 56.04,93.21 55.76,93.48 55.76,93.64 v2(55.56,93.84)
M_A_DQSP1: length 53
  IN1 w0.089: v1(81.5,69.49) 81.6,69.49 81.72,69.61 81.72,69.82 81.64,69.91 80.68,69.91 80.35,70.24 80.35,70.88 80.02,71.21 80.02,71.94 79.64,72.33 78.98,72.33 78.85,72.45 73.38,72.45 72.58,73.26 68.51,73.26 68.32,73.45 68.32,75.31 68.23,75.4 67.87,75.4 67.78,75.31 67.78,73.45 67.59,73.26 67.09,73.26 66.89,73.45 66.89,75.83 67.63,76.56 67.63,76.95 66.79,77.79 66.3,77.79 65.67,77.15 64.4,77.15 63.76,77.79 63.76,80.07 63.26,80.57 63.26,82.45 57.38,88.33 55.23,88.33 54.06,89.5 52.87,89.5 52.69,89.32 52.69,89.16 52.93,88.92 v2(53.02,88.92)
  BOTTOM w0.102: U2030.H27 81.81,69.17 v1(81.5,69.49) ; v2(53.02,88.92) 52.68,88.58 52.68,88.39 52.37,88.09 51.3,88.09 51.17,87.96 CN2019.34
M_A_DQSP2: length 53
  IN1 w0.089: v1(81.52,65.5) 81.74,65.28 81.74,65.18 81.66,65.11 80.35,65.11 78.16,67.3 73.29,67.3 71.09,69.5 63.18,69.5 62.29,70.39 62.29,71.35 60.82,72.82 58.46,72.82 58.1,73.19 55.83,73.19 55.61,73.4 55.61,73.95 55.89,74.23 57.41,74.23 57.74,74.56 57.74,75.4 57.54,75.6 55.38,75.6 55.23,75.75 55.23,77.89 55.43,78.09 57.3,78.09 57.74,78.53 57.74,79 58.06,79.32 58.06,81.31 57.36,82 55.78,82 55.69,82.09 55.69,82.33 55.78,82.41 v2(56.4,82.41)
  BOTTOM w0.102: U2030.N27 81.81,65.32 81.63,65.5 v1(81.52,65.5) ; CN2019.55 57.55,82.71 57.39,82.87 55.92,82.87 55.67,82.62 55.67,82.49 55.77,82.39 56.37,82.39 v2(56.4,82.41)
M_A_DQSP3: length 52.6
  TOP w0.102: v1(85.93,63.52) 85.91,63.52 85.91,63.81 85.81,63.91 85.07,63.91 84.57,64.42 84.57,64.8 84.19,65.18 84.19,65.56 83.82,65.92 80.68,65.92 79.69,66.91 79.69,67.38 78.34,68.73 75,68.73 72.14,71.59 71.99,71.59 71.37,70.97 71.07,70.97 70.67,71.37 70.67,71.67 72.32,73.32 72.32,73.52 72.06,73.78 71.92,73.78 70.64,72.5 70.42,72.28 70.12,72.28 69.72,72.68 69.72,72.98 71.22,74.48 71.22,74.63 70.15,75.69 69.59,76.25 52.83,76.25 52.6,76.48 52.6,76.67 v2(52.32,76.96)
  BOTTOM w0.102: U2030.R21 86,63.52 v1(85.93,63.52) ; CN2019.76 51.14,77.46 51.26,77.58 52.42,77.58 52.59,77.41 52.59,77.23 v2(52.32,76.96)
M_A_DQSP4: length 52.9
  IN1 w0.089: v1(82.18,48.51) 81.97,48.3 81.97,48.12 81.77,47.93 80.77,47.93 78.93,46.09 74.89,46.09 74.59,46.39 67.71,46.39 67.39,46.7 61.78,46.7 61.66,46.58 61.66,46.5 61.43,46.26 61.08,46.26 60.84,46.5 60.84,47.22 60.69,47.37 60.35,47.37 60.26,47.28 60.26,45.73 60.07,45.53 59.55,45.53 59.34,45.74 59.34,48.72 59.14,48.92 58.89,48.92 58.81,48.83 58.81,45.26 58.61,45.07 58.1,45.07 57.9,45.26 57.9,46.86 57.82,46.95 55.73,46.95 55.45,47.23 55.45,47.65 55.64,47.84 57.82,47.84 57.9,47.93 57.9,50.06 57.82,50.15 57.56,50.15 57.34,49.93 57.34,49.26 57.11,49.03 56.55,49.03 56.45,49.14 56.01,49.14 55.72,49.43 55.72,50.16 v2(55.52,50.36)
  BOTTOM w0.102: v2(55.52,50.36) 55.73,50.16 55.73,49.93 55.95,49.71 CN2019.179 ; v1(82.18,48.51) 82.51,48.84 U2030.AM26
M_A_DQSP5: length 52.4
  TOP w0.102: v1(83.65,47.56) 83.46,47.52 83.34,47.59 83.31,47.71 83.31,47.77 82.96,48.12 80.44,48.12 78.72,46.4 74.86,46.4 72.2,43.74 71.58,43.74 71.36,43.53 71.36,42.9 71.26,42.8 70.91,42.8 70.75,42.96 70.75,43.53 70.54,43.74 69.98,43.74 69.76,43.53 69.76,42.85 69.66,42.75 69.25,42.75 69.15,42.85 69.15,43.53 68.94,43.74 68.38,43.74 68.16,43.53 68.16,42.85 68.06,42.75 67.65,42.75 67.55,42.85 67.55,43.53 67.34,43.74 66.78,43.74 66.56,43.53 66.56,42.85 66.46,42.75 66.05,42.75 65.95,42.85 65.95,43.53 65.74,43.74 65.17,43.74 64.96,43.53 64.96,42.85 64.86,42.75 64.45,42.75 64.35,42.85 64.35,43.53 64.14,43.74 63.57,43.74 63.36,43.53 63.36,42.85 63.26,42.75 62.85,42.75 62.75,42.85 62.75,43.53 62.54,43.74 61.97,43.74 61.76,43.53 61.76,42.85 61.66,42.75 61.25,42.75 61.15,42.85 61.15,43.53 60.94,43.74 60.32,43.74 59.32,44.74 59.32,45.55 59.1,45.77 58.63,45.77 58.42,45.56 58.42,45.14 58.32,45.03 57.92,45.03 57.81,45.14 57.81,45.56 57.6,45.77 54.85,45.77 54.48,45.4 54.48,44.9 53.54,43.95 53.12,43.95 52.64,44.43 52.64,44.85 v2(52.89,45.1)
  BOTTOM w0.102: CN2019.200 52.47,44.46 52.69,44.67 52.69,44.89 v2(52.89,45.1) ; v1(83.65,47.56) 84.1,48.01 U2030.AN24
M_A_DQSP6: length 52
  IN1 w0.089: v1(84.01,44.47) 84.01,44.92 83.91,45.02 83.7,45.02 83.5,44.82 83.5,42.15 82.84,41.49 82.17,41.49 81.61,40.92 81.28,40.92 80.71,41.49 80.4,41.49 79.97,41.06 79.64,41.06 79.44,41.26 78,41.26 77.91,41.17 77.91,40.9 78.71,40.1 78.71,39.75 78.51,39.56 77.59,39.56 77.05,40.09 73.67,40.09 73.58,40 73.58,39.67 73.39,39.48 72.28,39.48 72.09,39.67 72.09,40.58 72,40.67 71.66,40.67 71.55,40.56 71.55,39.67 71.36,39.48 70.86,39.48 70.66,39.67 70.66,40.58 70.58,40.67 70.22,40.67 70.13,40.58 70.13,39.67 69.94,39.48 69.44,39.48 69.24,39.67 69.24,40.58 69.15,40.67 68.8,40.67 68.71,40.58 68.71,39.67 68.52,39.48 68.01,39.48 67.82,39.67 67.82,40.58 67.73,40.67 67.38,40.67 67.29,40.58 67.29,39.67 67.09,39.48 66.59,39.48 66.4,39.67 66.4,40.53 66.26,40.67 65.95,40.67 65.86,40.58 65.86,39.67 65.67,39.48 64.74,39.48 64.47,39.75 64.29,39.75 64.01,39.48 63.59,39.48 63.36,39.71 63.36,40.54 63.23,40.67 61.33,40.67 61.17,40.52 61.17,40.1 60.94,39.86 57.92,39.86 57.72,39.67 56.31,39.67 56.09,39.45 56.09,39.12 56.18,39.03 v2(56.41,39.03)
  BOTTOM w0.102: v2(56.41,39.03) 56.16,39.28 56.16,39.46 56.25,39.56 57.21,39.56 57.56,39.21 CN2019.221 ; U2030.AU23 84.17,44.47 v1(84.01,44.47)
M_A_DQSP7: length 52.9
  IN1 w0.089: v1(87.04,43.73) 87.04,43.48 87.13,43.39 87.42,43.39 87.62,43.2 87.62,41.82 87.36,41.57 87.36,40.3 86.25,39.18 86.25,37.35 84.36,35.46 75.45,35.46 73.65,33.66 69.44,33.66 68.84,33.06 67.42,33.06 67.24,32.88 67.24,32.58 66.92,32.26 65.96,32.26 65.72,32.5 65.72,32.81 65.47,33.06 64.5,33.06 64.3,33.25 64.3,34.35 64.22,34.44 63.86,34.44 63.77,34.35 63.77,33.25 63.58,33.06 63.08,33.06 62.88,33.25 62.88,34.35 62.79,34.44 62.44,34.44 62.35,34.35 62.35,33.25 62.16,33.06 53.4,33.06 v2(52.56,33.89)
  BOTTOM w0.102: CN2019.242 51.12,33.96 51.25,34.09 51.48,34.09 51.76,34.37 52.72,34.37 52.82,34.28 52.82,34.14 v2(52.56,33.89) ; v1(87.04,43.73) 87.24,43.73 U2030.AV20
M_A_EVENT#: length 43.4
  TOP w0.102: v1(48.37,63.59) 48.37,63.31 48.42,63.26 R2284.1 48.42,62.63 49.21,61.84 v2(54.93,61.84) 56.99,61.84 62.96,55.87 78.42,55.87 78.57,56.02 79.54,56.02 80.1,55.46 82.38,55.46 82.74,55.1 84.14,55.1 84.54,54.7 v1(84.54,54.56)
  BOTTOM w0.102: v1(48.37,63.59) 49.01,62.96 CN2019.134 ; v1(84.54,54.56) 84.11,54.99 U2030.AE24
M_A_ODT0: length 35.5
  IN1 w0.14: v1(84.5,53.56) 84.29,53.56 83.7,52.97 79.21,52.97 78.74,52.5 74.53,52.5 73.32,53.72 62.51,53.72 60.75,55.49 55.65,55.49 v1(55.18,55.96)
  BOTTOM w0.165: v1(55.18,55.96) 55.18,55.87 55.56,55.49 57.34,55.49 57.56,55.71 CN2019.155 ; v1(84.5,53.56) 84.11,53.17 U2030.AG24
M_A_ODT1: length 36.7
  IN1 w0.14: v1(55.69,54.47) 56.07,54.09 59.5,54.09 61.26,52.32 73.2,52.32 74.28,51.24 79.03,51.24 79.7,51.91 81.37,51.91 81.62,52.16 83.83,52.16 84.06,52.39 84.06,52.74 84.34,53.02 85.53,53.02 v1(86.14,52.41)
  BOTTOM w0.165: v1(55.69,54.47) 56.2,53.96 57.24,53.96 57.48,54.21 CN2019.161 ; U2030.AJ22 85.84,52.01 86.14,52.31 v1(86.14,52.41)
M_A_PARITY: length 36.8
  TOP w0.165: v1(83.7,53.56) 83.2,54.06 82.08,54.06 81.89,54.25 81.89,54.77 81.68,54.98 80.71,54.98 79.98,54.25 63.52,54.25 60.13,57.64 v2(58.61,57.64) 55.97,57.64 v1(55.39,58.22) 55.41,58.23 R2283.2
  BOTTOM w0.165: CN2019.143 57.5,60.71 55.39,58.6 v1(55.39,58.22) ; U2030.AF24 84.11,53.97 v1(83.7,53.56)
M_A_RAS#: length 37.5
  TOP w0.165: v1(82.15,52.57) 81.7,53.02 80.53,53.02 80.43,52.92 73.95,52.92 73.72,52.69 67.12,52.69 66.96,52.86 66.96,53.3 66.79,53.47 66.46,53.47 66.3,53.3 66.3,52.86 66.13,52.69 65.8,52.69 65.64,52.86 65.64,53.3 65.47,53.47 65.14,53.47 64.97,53.3 64.97,52.86 64.81,52.69 63.82,52.69 61,55.51 55,55.51 54.67,55.84 54.67,56.25 54.29,56.63 53.28,56.63 52.58,55.94 v1(52.22,55.94)
  BOTTOM w0.165: CN2019.152 51.7,56.46 v1(52.22,55.94) ; U2030.AG26 82.51,52.93 v1(82.15,52.57)
M_A_RST#: length 38.4
  TOP w0.102: v1(83.64,59.52) 83.4,59.52 82.61,60.31 80.96,60.31 80.68,60.59 64.16,60.59 58.11,66.64 v2(57.34,66.64) 54.44,66.64 54.16,66.92 54.16,67.17 53.88,67.45 53.76,67.45 52.89,68.31 52.89,68.44 52.51,68.82 52.3,68.82 v2(51.67,69.46)
  BOTTOM w0.102: CN2019.108 v2(51.67,69.46) ; v1(83.64,59.52) 84.11,59.05 U2030.Y24
M_A_WE#: length 31.9
  IN1 w0.14: v1(81.47,53.55) 81.25,53.34 78.81,53.34 78.44,52.97 74.59,52.97 73.47,54.09 62.67,54.09 60.13,56.63 59.87,56.63 59.73,56.49 59.73,56.13 59.59,55.99 59.31,55.99 59.17,56.13 59.17,56.49 59.03,56.63 58.75,56.63 58.61,56.49 58.61,56.13 58.47,55.99 58.2,55.99 58.06,56.13 58.06,56.49 57.92,56.63 57.12,56.63 v1(56.45,55.96)
  BOTTOM w0.165: U2030.AG27 81.47,53.35 v1(81.47,53.55) ; v1(56.45,55.96) 57.2,56.71 CN2019.151
M_B1_UZQ0: length 3.2
  TOP w0.102: R2339.2 44.79,78.64 v2(44.55,78.89) U2018.E9
M_B1_UZQ1: length 4.2
  TOP w0.102: R2301.2 43.48,65.89 43.72,66.13 v2(43.72,67.04) 43.72,68.33 U2017.E9
M_B1_UZQ2: length 2.6
  TOP w0.102: U2014.E9 42.86,45.46 42.86,44.31 43.14,44.03 R2690.2
M_B1_UZQ3: length 4
  TOP w0.102: R2694.2 41.24,31.76 v2(42.1,32.63) 42.74,33.27 42.74,33.97 U2013.E9
M_B1_ZQ0: length 1.8
  TOP w0.102: R2338.1 43.11,79.52 U2018.F9
M_B1_ZQ1: length 3.4
  TOP w0.102: U2017.F9 42.35,68.9 42.35,66.92 v2(42.23,66.79) 42.1,66.66 R2300.1
M_B1_ZQ2: length 3.2
  TOP w0.102: U2014.F9 42.21,45.44 v2(42.21,43.8) 42.21,43.25 42.01,43.04 R2689.1
M_B1_ZQ3: length 4.1
  TOP w0.102: U2013.F9 42.31,33.97 42.31,33.55 v2(40.85,32.09) 40.67,31.92 R2693.1
M_B_A0: length 152.1
  TOP w0.102: v2(34.31,84.51) 33.52,84.51 32.07,85.96 32.07,86.85 v2(31.6,87.32) 30.92,88 R2313.2
  TOP w0.165: U2013.P3 35.14,38.37 v2(35.14,38.34) ; v2(33.65,72.48) 34.28,72.48 U2017.P3 ; U2018.P3 34.93,84.51 v2(34.31,84.51) ; v1(34.2,48.88) 34.28,48.88 U2014.P3
  IN1 w0.089: v2(34.31,84.51) 33.97,84.17 33.97,80.5 34.1,80.38 34.61,80.38 34.73,80.25 34.73,80 34.61,79.87 33.97,79.87 33.84,79.74 33.84,75.93 33.21,75.3 33.21,75.02 33.84,74.38 33.84,72.68 v2(33.65,72.48) 33.21,72.04 33.21,71.11 33.46,70.85 33.84,70.85 34.99,69.71 34.99,65.01 35.75,64.25 35.75,55.83 35.84,55.74 36.51,55.74 36.64,55.61 36.64,55.36 36.51,55.23 35.88,55.23 35.75,55.1 35.75,54.85 35.88,54.72 36.51,54.72 36.64,54.6 36.64,54.34 36.51,54.22 35.88,54.22 35.75,54.09 35.75,53.2 34.73,52.18 34.22,52.18 33.84,51.8 33.84,49.24 v1(34.2,48.88) 34.07,48.75 33.17,48.75 33.08,48.67 33.08,48.33 33.17,48.25 33.5,48.25 33.59,48.16 33.59,47.83 33.5,47.74 33.17,47.74 33.08,47.65 33.08,47.32 33.17,47.23 34.1,47.23 34.99,46.34 34.99,40.88 34.61,40.5 34.61,38.98 35.14,38.44 v2(35.14,38.34)
  IN3 w0.133: v2(76.62,54.72) 76.5,54.84 76.5,55.05 76.62,55.18 77.21,55.18 77.33,55.3 77.33,55.48 77.23,55.59 76.11,55.59 76.01,55.49 76.01,55.24 75.91,55.14 75.46,55.14 75.31,55.29 75.31,55.47 75.6,55.76 75.6,56.6 74.9,57.3 74.9,57.78 73.43,59.26 69.9,59.26 69.77,59.38 69.77,59.54 69.61,59.7 69.42,59.7 69.33,59.6 69.33,59.52 69.2,59.39 68.97,59.39 68.85,59.51 68.85,59.86 68.73,59.98 68.57,59.98 68.45,59.86 68.45,59.33 68.33,59.21 68.17,59.21 68.05,59.33 68.05,59.94 67.93,60.06 67.77,60.06 67.65,59.94 67.65,59.33 67.53,59.21 67.35,59.21 67.25,59.32 67.25,59.64 67.12,59.76 66.86,59.76 66.78,59.68 66.53,59.68 65.89,60.32 59.2,60.32 58.47,61.04 56.92,61.69 51.09,61.69 49.54,60.14 40.22,60.14 36.01,58.39 35.63,58.01 35.1,58.01 34.9,57.81 34.9,57.63 35.01,57.52 35.01,57.39 34.87,57.25 34.69,57.25 34.5,57.44 34.33,57.44 34.21,57.32 34.21,57.16 34.54,56.83 34.54,56.49 34.02,55.97 32.86,55.97 32.06,55.17 32.06,53.71 31.11,52.77 30.43,51.12 30.43,48.86 30.78,48.51 30.78,44.68 31.97,43.48 31.97,42.96 33.98,40.96 33.98,39.7 35.14,38.54 v2(35.14,38.34)
  BOTTOM w0.102: 78.17,53.83 78.42,53.83 78.93,53.33 79.35,53.33 79.53,53.14 79.88,53.14 U2030.AG30
  BOTTOM w0.165: 78.17,53.83 77.4,53.83 76.62,54.62 v2(76.62,54.72)
M_B_A1: length 148.3
  TOP w0.102: v2(35.49,83.17) 35.11,83.55 33.34,83.55 31.18,85.71 R2328.2
  TOP w0.165: v2(35.72,72) 35.24,71.51 35.24,71.21 U2017.P7 ; v1(35.77,47.74) 35.73,47.69 U2014.P7 ; U2013.P7 35.14,36.34 v2(35.14,36.82) ; v2(35.49,83.17) 35.73,82.94 U2018.P7
  IN2 w0.089: v2(35.14,36.82) 35.24,36.71 35.24,36.27 35.15,36.18 34.82,36.18 34.73,36.27 34.73,38.61 34.86,38.74 35.79,38.74 35.88,38.83 35.88,40.37 35.37,40.88 35.37,46.98 35.77,47.38 v1(35.77,47.74) 34.98,48.53 34.98,51.92 35.11,52.06 36.51,52.06 37.02,52.56 37.02,52.95 37.27,53.2 37.27,56.25 35.88,57.64 35.88,63.99 35.11,64.76 35.11,65.26 35.24,65.39 35.75,65.39 35.88,65.52 35.88,65.77 35.75,65.9 35.24,65.9 35.11,66.03 35.11,66.88 35.37,67.13 35.37,70.73 35.11,70.98 35.11,71.87 35.24,72 v2(35.72,72) 36.26,72 36.38,72.12 36.38,72.38 36.26,72.5 34.73,72.5 34.61,72.63 34.61,72.88 34.73,73.01 35.11,73.01 35.24,73.14 35.24,77.08 35.62,77.46 35.62,83.04 v2(35.49,83.17)
  IN3 w0.133: v2(78.29,56.4) 78.8,56.4 78.95,56.55 78.95,57.44 78.8,57.59 77.99,57.59 77.87,57.48 77.87,57 77.75,56.88 77.59,56.88 77.47,57 77.47,57.5 77.35,57.62 77.13,57.62 76.9,57.39 76.62,57.39 76.01,58 76.01,58.21 73.88,60.34 73.46,60.34 72.76,61.04 71.72,61.47 69.13,61.99 67.95,62.48 66.34,62.8 60.01,62.8 57.15,63.98 52.23,63.98 51.75,63.5 49.99,63.5 48.93,62.44 41.06,62.44 33.74,59.41 29.8,55.47 29.09,53.76 28.63,51.44 28.35,48.67 28.35,44.95 28.61,43.65 28.66,43.54 28.8,43.4 32.13,38.41 32.51,38.04 33.89,38.04 35.11,36.82 v2(35.14,36.82)
  BOTTOM w0.102: U2030.AC32 79.08,56.88 78.55,56.88 78.43,56.76
  BOTTOM w0.165: 78.43,56.76 78.29,56.63 v2(78.29,56.4)
M_B_A2: length 147.2
  TOP w0.102: R2304.2 31.05,88.76 32.32,87.49 32.32,86.39 v2(33.57,85.14)
  TOP w0.165: U2013.R3 34.31,38.34 v2(34.2,38.34) ; v2(34.5,73.5) U2017.R3 ; v2(34.56,49.93) 34.56,49.96 U2014.R3 ; v2(33.57,85.14) 33.77,84.94 34.56,84.94 U2018.R3
  IN2 w0.089: v2(34.2,38.34) 34.09,38.45 34.09,38.84 34.22,38.98 34.61,38.98 34.73,39.1 34.73,39.36 34.61,39.48 33.97,39.48 33.84,39.61 33.84,39.86 33.97,39.99 34.61,39.99 34.73,40.12 34.73,40.37 35.11,40.75 35.11,47.1 35.24,47.23 35.24,47.87 34.73,48.37 34.73,49.76 v2(34.56,49.93) 33.97,50.52 33.97,51.68 35.62,53.33 36.9,53.33 37.03,53.45 37.03,53.69 36.89,53.83 36,53.83 35.88,53.96 35.88,54.22 36,54.34 36.9,54.34 37.03,54.47 37.03,56.11 35.62,57.52 35.62,63.87 34.86,64.63 34.86,67.04 35.11,67.3 35.11,70.6 34.35,71.36 34.35,73.35 v2(34.5,73.5) 34.99,73.99 34.99,77.2 35.37,77.58 35.37,82.54 34.86,83.04 34.86,85.22 34.77,85.31 34.35,85.31 34.08,85.58 33.72,85.58 33.57,85.44 v2(33.57,85.14)
  IN3 w0.133: v2(77.02,56.37) 77.02,56.46 75.63,57.86 75.63,58.08 73.73,59.98 73.31,59.98 72.55,60.73 71.62,61.12 65.01,62.43 64.7,62.43 64.58,62.31 64.58,61.89 64.45,61.77 64.25,61.77 64.15,61.86 64.15,62.31 64.02,62.43 63.84,62.43 63.71,62.31 63.71,61.88 63.6,61.77 63.43,61.77 63.31,61.88 63.31,62.32 63.2,62.43 63.02,62.43 62.9,62.32 62.9,61.88 62.78,61.77 62.62,61.77 62.5,61.88 62.5,62.32 62.38,62.43 62.15,62.43 62.03,62.32 62.03,61.88 61.91,61.77 61.75,61.77 61.63,61.88 61.63,62.32 61.51,62.43 61.35,62.43 61.23,62.32 61.23,61.88 61.11,61.77 60.95,61.77 60.83,61.88 60.83,62.32 60.71,62.43 60.35,62.43 59.94,62.02 59.57,62.02 59.33,62.26 57.21,63.13 50.14,63.13 49.08,62.08 41.13,62.08 33.94,59.1 30.1,55.26 29.44,53.65 28.99,51.39 28.72,48.64 28.72,45.51 29.33,44.9 29.33,44.08 30.37,43.04 30.37,41.81 30.44,41.66 32.27,39.83 32.27,39.03 32.44,38.61 32.64,38.42 34.12,38.42 v2(34.2,38.34)
  BOTTOM w0.089: U2030.AC30 79.69,57.01 79.38,57.31 79.08,57.31 78.98,57.21
  BOTTOM w0.102: 78.18,57 78.39,57.21 78.98,57.21
  BOTTOM w0.165: v2(77.02,56.37) 77.53,56.88 78.06,56.88 78.18,57
M_B_A3: length 150.3
  TOP w0.102: R2342.2 31.18,86.47 31.56,86.09 31.56,85.71 33.46,83.81 v2(35.49,83.81)
  TOP w0.165: v2(35.98,36.82) 36,36.79 36,36.28 U2013.N7 ; U2017.N7 35.89,71.36 v2(35.72,71.36) ; v2(35.49,83.81) 36.13,83.17 36.13,82.5 U2018.N7 ; v2(35.77,48.37) 36.38,47.76 36.38,47.27 U2014.N7
  IN2 w0.089: v2(35.49,83.81) 35.75,83.81 35.9,83.65 35.9,77.35 35.49,76.95 35.49,74.15 36.38,73.27 36.51,73.27 36.64,73.14 36.64,72 36,71.36 v2(35.72,71.36) 35.62,71.26 35.62,68.19 36.13,67.68 36.13,57.77 37.53,56.37 37.53,52.95 37.27,52.69 37.27,52.45 36.63,51.8 35.62,51.8 35.49,51.68 35.49,51.42 35.62,51.29 36.38,51.29 36.51,51.17 36.51,50.91 36.38,50.79 35.37,50.79 35.24,50.66 35.24,50.41 35.37,50.28 36.13,50.28 36.26,50.15 36.26,49.9 36.13,49.77 35.37,49.77 35.22,49.62 35.22,48.9 35.75,48.37 v2(35.77,48.37) 36.15,48 36.15,47.38 35.62,46.85 35.62,41.01 36.64,39.99 36.64,39.36 36.51,39.23 36.26,39.23 36.13,39.1 36.13,38.85 36.26,38.72 36.51,38.72 36.64,38.59 36.64,38.3 36.55,38.21 35.88,38.21 35.54,37.88 35.54,37.25 v2(35.98,36.82)
  IN3 w0.133: v2(76.57,58.05) 76.57,58.17 76.13,58.61 76.13,58.77 76.25,58.89 76.25,59.06 76.13,59.17 75.96,59.17 75.84,59.05 75.68,59.05 74.03,60.7 73.61,60.7 72.96,61.35 71.83,61.82 69.24,62.33 68.05,62.83 66.38,63.16 60.08,63.16 57.23,64.34 52.08,64.34 51.6,63.86 49.84,63.86 48.78,62.8 40.98,62.8 33.53,59.72 29.49,55.67 28.74,53.87 28.27,51.5 27.99,48.68 27.99,44.91 28.26,43.55 28.35,43.33 28.51,43.17 29.86,41.15 29.86,41.15 31.85,38.18 32.37,37.65 33.79,37.65 34.7,36.75 34.7,36.47 34.86,36.31 35.47,36.31 v2(35.98,36.82)
  BOTTOM w0.089: U2030.AB29 80.06,57.51 79.71,57.86 79.52,57.86 79.37,57.71 78.88,57.71
  BOTTOM w0.102: 77.78,57.61 78.78,57.61 78.88,57.71
  BOTTOM w0.165: v2(76.57,58.05) 77.03,57.59 77.75,57.59 77.78,57.61
M_B_A4: length 151.4
  TOP w0.102: R2315.2 31.05,87.24 31.81,86.47 31.81,85.84 33.59,84.06 35.11,84.06 v2(35.49,84.44)
  TOP w0.165: v1(35.6,49.19) 35.62,49.21 35.62,49.42 U2014.N3 ; U2018.N3 35.66,84.44 v2(35.49,84.44) ; U2017.N3 35.86,73.27 v2(35.72,73.27) ; v2(35.14,37.71) 35.28,37.71 U2013.N3
  IN1 w0.089: v2(35.49,84.44) 35.24,84.7 35.24,85.1 35.35,85.2 35.88,85.2 36,85.08 36,77.2 35.37,76.57 35.37,75.29 36,74.66 36,73.54 v2(35.72,73.27) 35.72,72.99 34.99,72.25 34.99,70.85 35.75,70.09 35.75,68.57 36.76,67.55 36.76,58.28 36.89,58.15 38.07,58.15 38.16,58.06 38.16,56.76 38.03,56.63 37.49,56.63 37.4,56.54 37.4,55.7 37.49,55.61 38.07,55.61 38.16,55.52 38.16,53.33 37.4,52.56 37.4,52.18 37.27,52.06 36.64,52.06 35.62,51.04 35.62,49.21 v1(35.6,49.19) 35.11,48.7 35.11,47.36 35.75,46.72 35.75,41.01 36.51,40.25 36.51,37.65 36.17,37.3 35.54,37.3 v2(35.14,37.71)
  IN3 w0.133: v2(35.14,37.71) 34.71,38.14 34.71,38.46 33.62,39.55 33.62,40.81 31.61,42.81 31.61,43.33 30.41,44.53 30.41,48.36 30.07,48.71 30.07,51.12 arc(30.08,51.19) 30.09,51.25 30.78,52.91 arc(30.81,52.97) 30.85,53.02 31.21,53.38 31.21,54.14 31.54,54.46 31.54,55.16 34.51,58.13 arc(34.56,58.18) 34.62,58.21 40.09,60.47 arc(40.15,60.49) 40.22,60.5 49.39,60.5 50.94,62.05 56.93,62.05 arc(56.99,62.04) 57.06,62.02 58.62,61.38 arc(58.68,61.34) 58.73,61.3 59.35,60.68 66.04,60.68 66.59,60.13 67.32,60.13 67.62,60.42 68.59,60.42 arc(68.62,60.42) 68.65,60.41 69.24,60.16 v2(69.24,60.16)
  BOTTOM w0.089: U2030.AB31 79.61,57.5 79.06,57.5 arc(78.98,57.49) 78.92,57.44
  BOTTOM w0.102: 77.92,57.26 78.04,57.26 arc(78.08,57.27) 78.12,57.3 78.2,57.38 arc(78.24,57.4) 78.28,57.41 78.84,57.41 arc(78.88,57.42) 78.92,57.44
  BOTTOM w0.165: 77.92,57.26 77.28,57.26 76.9,56.88 76.63,56.88 76.47,57.05 76.47,57.35 76.3,57.52 75.97,57.52 75.8,57.35 75.8,57.05 75.64,56.88 75.31,56.88 75.14,57.05 75.14,57.35 74.98,57.52 74.65,57.52 74.48,57.35 74.48,57.05 74.32,56.88 73.99,56.88 73.82,57.05 73.82,57.35 73.66,57.52 73.33,57.52 73.16,57.35 73.16,57.05 73,56.88 72.67,56.88 72.5,57.05 72.5,57.35 72.34,57.52 72.01,57.52 71.84,57.35 71.84,57.05 71.68,56.88 71.31,56.88 71.13,57.06 71.13,57.55 70.97,57.71 70.64,57.71 70.47,57.55 70.47,57.22 70.31,57.06 69.98,57.06 69.81,57.22 69.81,57.55 69.65,57.71 69.32,57.71 69.15,57.55 69.15,57.22 68.99,57.06 68.21,57.06 68.04,57.23 68.04,59.01 69.19,60.16 v2(69.24,60.16)
M_B_A5: length 150.2
  TOP w0.102: v2(33.46,82.03) 32.78,82.03 31.81,82.99 31.81,83.68 31.3,84.19 R2347.2
  TOP w0.165: v2(33.75,46.75) 33.75,46.75 35.3,46.75 U2014.P8 ; U2013.P8 35.33,35.35 v2(35.3,35.35) ; U2018.P8 35.33,81.71 33.79,81.71 v2(33.46,82.03) ; U2017.P8 35.3,70.35 v2(33.65,70.35)
  IN1 w0.089: v2(33.46,82.03) 33.59,81.9 33.59,77.08 33.46,76.95 33.08,76.95 32.95,76.82 32.95,76.57 33.08,76.44 33.46,76.44 33.59,76.31 33.59,76.06 33.46,75.93 33.08,75.93 32.95,75.81 32.95,74.92 33.59,74.28 33.59,73.14 32.95,72.5 32.95,70.98 33.58,70.35 v2(33.65,70.35) 34.1,69.9 34.1,69.33 34.73,68.69 34.73,64.88 35.49,64.12 35.49,53.71 35.24,53.45 33.72,53.45 33.59,53.33 33.59,53.07 33.72,52.95 34.61,52.95 34.73,52.82 34.73,52.56 34.61,52.44 33.72,52.44 33.59,52.31 33.59,49.64 32.83,48.88 32.83,47.1 33.18,46.75 v2(33.75,46.75) 34.15,46.35 34.15,45.54 34.24,45.45 34.61,45.45 34.73,45.33 34.73,45.07 34.61,44.94 33.97,44.94 33.84,44.82 33.84,44.56 33.97,44.44 34.61,44.44 34.73,44.31 34.73,41.01 34.35,40.63 34.35,38.85 34.61,38.59 34.61,36.05 v2(35.3,35.35)
  IN3 w0.133: v2(35.3,35.35) 34.34,36.31 34.34,36.65 33.74,37.25 32.27,37.25 31.56,37.95 29.54,40.98 29.54,40.98 28.23,42.94 28.05,43.13 27.91,43.44 27.63,44.87 27.63,48.7 27.91,51.56 28.39,53.96 29.18,55.88 33.33,60.02 40.91,63.17 47.61,63.17 47.94,63.5 47.94,63.74 48.42,64.22 51.45,64.22 51.91,64.68 57.36,64.68 60.15,63.52 66.41,63.52 68.15,63.18 69.34,62.68 71.94,62.17 73.17,61.65 73.76,61.07 74.18,61.07 75.54,59.7 76.19,59.7 76.44,59.44 76.61,59.44 76.85,59.69 77.01,59.69 77.13,59.57 77.13,59.4 76.89,59.16 76.89,59 v2(77.84,58.05)
  BOTTOM w0.089: 78.88,58.31 79.34,58.31 79.49,58.16 79.86,58.16 U2030.AA30
  BOTTOM w0.102: 78.88,58.31 78.87,58.31 78.72,58.45 78.24,58.45 v2(77.84,58.05)
M_B_A6: length 149.5
  TOP w0.102: R2314.2 32.57,89.01 34.24,87.34 v2(34.54,87.34)
  TOP w0.165: v2(34.56,51.52) 35.33,51.52 U2014.P2 ; v2(34.54,87.34) 35,87.34 35.35,87 35.35,86.48 U2018.P2 ; U2017.P2 35.34,75.11 v2(34.54,75.11) ; v2(35.31,40.17) U2013.P2
  IN1 w0.089: v2(35.31,40.17) 35.31,39.92 35.49,39.74 36.13,39.74 36.26,39.86 36.26,40.12 35.49,40.88 35.49,46.6 34.86,47.23 34.86,49.14 35.37,49.64 35.37,50.72 v2(34.56,51.52) 35.72,51.52 37.91,53.71 37.91,55.23 37.78,55.36 37.27,55.36 37.15,55.49 37.15,56.76 37.27,56.88 37.78,56.88 37.91,57.01 37.91,57.77 37.78,57.9 36.64,57.9 36.51,58.03 36.51,67.42 35.49,68.44 35.49,69.96 34.73,70.73 34.73,72.38 35.14,72.78 35.14,74.51 v2(34.54,75.11) 34.35,75.3 34.35,75.93 35.75,77.33 35.75,82.28 34.99,83.04 34.99,85.97 35.24,86.22 35.41,86.22 35.49,86.31 35.49,86.64 35.41,86.73 35.15,86.73 v2(34.54,87.34)
  IN3 w0.133: v2(72.71,58.1) 72.71,57.89 72.83,57.76 73.09,57.76 73.24,57.61 73.24,57.41 73.14,57.32 69.51,57.32 68.79,58.04 67.9,58.04 67.45,58.49 66.7,58.49 65.59,59.6 58.9,59.6 58.07,60.42 50.85,60.42 49.84,59.41 40.37,59.41 36.42,57.78 35.26,56.62 35.26,55.89 31.73,52.36 31.15,50.97 31.15,49.16 31.5,48.81 31.5,44.98 32.7,43.78 32.7,43.26 34.76,41.2 34.76,40.72 v2(35.31,40.17)
  BOTTOM w0.089: 78.93,58.86 79.08,58.71 79.37,58.71 79.52,58.86 79.71,58.86 80.07,58.51 U2030.AA29
  BOTTOM w0.102: 76.34,58.91 76.52,58.91 76.69,58.74 77.76,58.74 77.88,58.86 78.93,58.86
  BOTTOM w0.165: 76.34,58.91 74.64,58.91 74.48,59.08 74.48,59.26 74.31,59.42 73.98,59.42 73.82,59.26 73.82,58.83 73.65,58.66 73.26,58.66 73.09,58.83 73.09,59.51 72.93,59.68 72.6,59.68 72.43,59.51 72.43,59.08 72.27,58.91 71.94,58.91 71.77,59.08 71.77,59.51 71.61,59.68 71.28,59.68 71.11,59.51 71.11,59.08 70.95,58.91 70.55,58.91 70.38,59.08 70.38,59.51 70.21,59.68 69.88,59.68 69.72,59.51 69.72,59.08 69.55,58.91 68.62,58.91 68.49,58.79 68.49,58.23 68.62,58.1 v2(72.71,58.1)
