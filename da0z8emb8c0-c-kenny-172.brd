# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN3 (solid shape): 73.23,30.62 73.3,30.59 73.33,30.52 73.33,30.32 73.51,30.15 75.37,30.15 75.37,30.14 75.37,29.78 75.31,29.68 75.2,29.71 75.03,29.87 72.37,29.87 72.16,29.66 72.16,28.65 72.63,28.18 72.62,28.15 72.61,28.1 72.6,28.05 72.61,27.99 72.63,27.93 72.61,27.84 72.53,27.79 72.12,27.79 72.04,27.84 72.02,27.93 72.04,27.99 72.05,28.05 71.94,28.3 71.69,28.41 71.56,28.38 71.44,28.31 71.37,28.28 71.3,28.31 71.22,28.37 71.12,28.4 71.05,28.46 71.06,28.56 71.06,29.02 71.1,29.1 71.19,29.11 71.25,29.1 71.31,29.09 71.67,29.45 71.31,29.81 71.25,29.8 71.19,29.79 71.1,29.8 71.06,29.88 71.06,30.02 71.1,30.07 72.96,30.07 73.18,30.28 73.18,30.57 73.19,30.6
GND on IN3 (solid shape): 97.04,66.78 97.12,66.74 97.13,66.64 97.12,66.59 97.11,66.53 97.12,66.48 97.13,66.43 97.12,66.34 97.03,66.3 96.79,66.3 96.46,65.97 96.46,65.89 96.45,65.86 96.19,65.74 96.11,65.51 96.11,65.45 96.13,65.39 96.12,65.3 96.03,65.26 94.51,65.26 94.18,64.92 94.18,64.84 94.13,64.83 94.09,64.82 94.05,64.81 93.95,64.82 93.91,64.9 93.91,65.18 94.8,66.07 94.8,66.57 94.85,66.66 94.96,66.65 95.05,66.6 95.16,66.58 95.22,66.59 95.3,66.57 95.34,66.5 95.45,66.29 95.67,66.2 95.82,66.24 95.94,66.35 96.02,66.39 96.11,66.35 96.23,66.24 96.38,66.2 96.61,66.3 96.71,66.53 96.7,66.59 96.69,66.64 96.7,66.74 96.79,66.78
GND on IN3 (solid shape): 102.33,110.81 102.31,110.72 102.23,110.69 100.83,110.69 99.96,109.82 99.96,109.43 100.03,109.27 100.2,109.23 100.24,109.23 100.42,109.16 100.49,108.98 100.48,108.88 100.42,108.8 100.37,108.66 100.42,108.52 100.48,108.44 100.49,108.34 100.42,108.16 100.24,108.09 100.2,108.09 100.03,108.05 99.96,107.89 99.96,104.88 100.05,104.72 100.23,104.69 100.26,104.7 100.3,104.7 100.48,104.63 100.56,104.45 100.48,104.27 100.3,104.19 100.26,104.19 100.23,104.2 100.05,104.17 99.96,104.01 99.96,103.06 99.9,102.97 99.79,102.99 99.47,103.32 99.47,110.78 99.45,110.8 99.44,110.85 99.49,110.89 102.32,110.89
GND on IN3 (solid shape): 86.82,63.02 86.88,63.12 86.99,63.09 87.22,62.87 88.28,62.87 88.35,62.79 88.35,62.21 88.31,62.13 88.22,62.11 88.16,62.13 88.11,62.13 87.96,62.1 87.84,62 87.76,61.96 87.68,62.01 87.56,62.11 87.41,62.14 87.08,61.81 87.41,61.48 87.56,61.51 87.68,61.61 87.76,61.65 87.84,61.61 87.96,61.51 88.11,61.47 88.16,61.48 88.22,61.49 88.31,61.48 88.35,61.4 88.35,60.58 88.31,60.49 88.21,60.49 88.14,60.51 88.07,60.51 87.94,60.49 87.82,60.4 87.75,60.37 87.67,60.4 87.56,60.49 87.42,60.52 87.25,60.48 87.12,60.35 87.05,60.3 86.96,60.32 86.82,60.47
GND on IN3 (solid shape): outline of 135 points within 135.68,17.65 150.01,20.18
GND on IN3 (solid shape): 185.59,24.14 188.34,24.14 188.93,24.73 189.55,24.73 189.64,24.68 189.65,24.59 189.63,24.54 189,24.54 186.81,22.36 183.26,22.36 183,22.62 180.53,22.62 180.45,22.66 180.43,22.75 180.45,22.81 180.45,22.87 180.35,23.12 180.1,23.23 179.94,23.19 179.82,23.1 179.74,23.06 179.66,23.1 179.6,23.15 179.53,23.2 179.53,23.59 179.51,23.61 179.5,23.67 179.54,23.7 182.9,23.7 184.04,22.55 186.54,22.55 186.84,22.85 186.87,22.84 186.92,22.83 186.98,22.83 187.31,23.16 186.98,23.49 186.86,23.46 186.76,23.4 186.69,23.37 186.62,23.4 186.51,23.46 186.4,23.48 186.26,23.45 186.15,23.37 186.09,23.34 186.01,23.36 185.92,23.41 185.81,23.43 185.72,23.42 185.26,23.88 184.91,23.88 184.4,24.39 181.35,24.39 181.19,24.55 181.17,24.66 181.26,24.73 185,24.73
GND on IN3 (solid shape): 106.27,100.07 106.31,100.05 106.59,99.91 106.87,100.05 106.9,100.07 106.94,100.06 106.99,100.04 107.05,100.03 109.88,100.03 109.97,99.97 109.95,99.86 109.69,99.6 109.69,98.04 109.8,97.92 109.82,97.81 109.73,97.75 109.72,97.75 109.61,97.78 109.53,97.84 109.45,97.89 109.36,97.89 109.28,97.88 109.19,97.89 109.17,97.9 108.34,97.9 108.17,97.8 107.98,97.85 107.88,97.88 107.78,97.84 107.53,97.59 107.53,93.98 108.04,93.47 110.71,93.47 112.26,91.93 112.34,91.91 112.38,91.92 112.42,91.93 112.46,91.93 112.64,91.86 112.71,91.68 112.71,91.64 112.7,91.6 112.69,91.56 112.71,91.48 114.78,89.41 114.78,89.23 114.72,89.14 114.6,89.16 110.6,93.17 107.54,93.17 106.66,94.05 106.66,98.01 105.09,99.58 104.32,99.58 104.23,99.62 104.22,99.72 104.24,99.78 104.24,99.84 104.24,99.87 104.23,99.91 104.26,100 104.33,100.03 106.13,100.03 106.19,100.04 106.24,100.06
GND on IN3 (solid shape): 124.01,110.87 124.09,110.82 124.1,110.73 124.08,110.66 124.07,110.6 124.18,110.34 124.43,110.24 124.6,110.28 124.73,110.4 124.81,110.44 124.9,110.4 125.02,110.28 125.19,110.24 125.44,110.34 125.55,110.6 125.54,110.66 125.52,110.73 125.53,110.82 125.62,110.87 126.32,110.87 126.4,110.82 126.41,110.73 126.39,110.66 126.39,110.59 126.4,110.51 126.42,110.43 126.42,110.33 126.33,110.28 125.57,110.28 124.76,109.47 124.2,109.47 124.12,109.52 124.11,109.62 124.13,109.69 124.14,109.76 123.79,110.12 123.43,109.76 123.44,109.69 123.46,109.62 123.45,109.52 123.37,109.47 123.29,109.47 122.18,110.58 122.16,110.69 122.26,110.75 122.97,110.75 123.08,110.87
GND on IN3 (solid shape): 155.73,27.11 155.82,27.09 155.93,26.98 158.53,26.98 159.02,26.49 162.85,26.49 163.51,25.82 164.76,25.82 166.61,23.98 167.98,23.98 168.22,23.73 172.27,23.73 173.55,22.45 177.65,22.45 178.21,21.89 182.19,21.89 183.15,20.94 187.62,20.94 190.27,23.59 190.41,23.59 190.46,23.53 187.69,20.76 183.07,20.76 182.12,21.72 178.14,21.72 177.72,22.14 172.33,22.14 172.25,22.18 172.24,22.28 172.27,22.36 172.27,22.44 172.22,22.65 172.06,22.8 172.01,22.86 172.02,22.95 172.08,23.06 172.1,23.18 171.69,23.58 171.28,23.18 171.34,22.97 171.5,22.82 171.55,22.75 171.53,22.67 171.49,22.6 171.47,22.52 171.4,22.44 171.3,22.47 170.21,23.56 168.09,23.56 167.89,23.75 166.58,23.75 164.93,25.41 163.68,25.41 162.77,26.31 158.95,26.31 158.46,26.8 156.59,26.8 156.19,26.4 155.4,26.4 154.92,26.88 154.96,26.93 155,26.95 155.04,26.93 155.16,26.83 155.31,26.8 155.52,26.87 155.65,27.05
GND on IN3 (solid shape): 158.61,30.56 158.69,30.52 158.7,30.42 158.69,30.37 158.68,30.31 159.04,29.95 159.4,30.31 159.39,30.37 159.38,30.42 159.39,30.52 159.47,30.56 160.03,30.56 160.11,30.52 160.13,30.42 160.11,30.37 160.11,30.31 160.46,29.95 160.82,30.31 160.81,30.37 160.8,30.42 160.81,30.52 160.89,30.56 161.67,30.56 162.64,29.59 162.66,29.48 162.57,29.42 158.94,29.42 158.57,29.78 158.2,29.78 158.12,29.83 158.11,29.92 158.14,30 158.15,30.09 157.8,30.44 157.44,30.09 157.45,30 157.48,29.92 157.47,29.83 157.39,29.78 156.12,29.78 156.02,29.84 156.04,29.95 156.65,30.56
GND on IN3 (solid shape): 132.85,115.3 132.93,115.26 132.94,115.16 132.93,115.11 132.92,115.05 133.28,114.69 133.63,115.05 133.63,115.11 133.61,115.16 133.63,115.26 133.71,115.3 133.98,115.3 134.06,115.25 134.07,115.15 134.03,115.07 134.02,114.98 134.07,114.8 134.21,114.67 134.26,114.58 134.21,114.49 134.07,114.36 134.02,114.18 134.38,113.83 134.74,114.18 134.69,114.36 134.55,114.49 134.5,114.58 134.55,114.67 134.69,114.8 134.74,114.98 134.71,115.11 134.65,115.21 134.64,115.23 134.64,115.3 134.71,115.3 135.67,114.35 135.67,113.8 135.74,113.73 135.76,113.62 135.67,113.56 133.68,113.56 132.12,115.13 132.09,115.24 132.19,115.3
GND on IN3 (solid shape): 37.06,49.51 37.1,49.43 37.1,48.56 37.78,47.88 37.78,46.32 37.77,46.29 37.48,46.17 37.38,45.92 37.48,45.66 37.74,45.56 37.8,45.56 37.85,45.58 37.95,45.57 37.99,45.48 37.99,44.89 37.44,44.34 37.44,44.32 37.38,44.29 36.65,45.02 36.65,45.51 36.7,45.59 36.79,45.6 36.85,45.58 36.92,45.58 37.17,45.68 37.27,45.93 37.23,46.11 37.1,46.24 37.05,46.33 37.1,46.42 37.23,46.55 37.27,46.72 37.23,46.9 37.09,47.03 37.04,47.12 37.09,47.21 37.23,47.34 37.27,47.52 37.17,47.77 36.92,47.87 36.85,47.87 36.79,47.85 36.7,47.86 36.65,47.95 36.65,49.4 36.69,49.47 36.77,49.5 36.82,49.49 36.9,49.5 36.96,49.52
GND on IN3 (solid shape): 104.23,90.94 104.29,91.04 104.4,91.02 107.01,88.4 110.47,88.4 110.6,88.53 110.63,88.53 110.88,88.64 110.99,88.89 110.94,89.06 110.81,89.19 110.77,89.25 110.78,89.33 110.8,89.38 110.87,89.44 110.96,89.42 111.59,89.42 111.72,89.33 111.87,89.29 112.22,89.65 111.87,90 111.73,89.98 111.61,89.89 111.59,89.88 111.52,89.88 111.52,89.94 111.53,89.96 111.57,90.05 111.59,90.16 111.54,90.33 111.41,90.46 111.36,90.54 111.4,90.63 111.47,90.7 111.52,90.79 111.59,90.86 111.69,90.83 113.31,89.21 113.31,88.8 113.61,88.51 113.6,88.48 113.59,88.43 113.58,88.38 113.69,88.13 113.94,88.02 113.98,88.02 114.05,88 114.09,87.92 114.09,82.54 114.03,82.44 113.92,82.47 112.39,83.99 110.83,83.99 104.23,90.59
GND on IN3 (solid shape): 111.44,64.65 111.52,64.61 111.65,64.51 111.82,64.48 111.94,64.49 112.05,64.54 112.15,64.55 112.2,64.46 112.2,62.93 111.99,62.72 111.9,62.69 111.82,62.76 111.75,62.89 111.63,62.98 111.57,63.05 111.59,63.14 111.65,63.24 111.67,63.36 111.64,63.49 111.57,63.61 111.54,63.68 111.57,63.75 111.64,63.86 111.67,63.99 111.31,64.35 110.96,63.99 110.96,63.94 110.97,63.9 110.98,63.87 110.84,63.72 110.84,63.7 110.56,63.43 110.56,62.19 109.14,60.76 109.14,54.92 108.09,53.87 108.09,50.07 106.77,48.75 106.77,45.97 106.73,45.88 106.63,45.88 106.56,45.9 106.49,45.91 106.42,45.9 106.35,45.88 106.25,45.88 106.2,45.97 106.2,48.43 107.91,50.14 107.91,53.94 108.96,55 108.96,60.84 110.39,62.26 110.39,63.84 110.7,64.15 110.7,64.45 110.75,64.53 110.85,64.53 110.95,64.49 111.06,64.48 111.23,64.51 111.36,64.61
GND on IN3 (solid shape): 85.7,82.88 85.81,82.9 85.88,82.8 85.88,82.41 86.07,82.22 86.33,82.22 86.41,82.3 86.52,82.33 86.59,82.23 86.59,80.98 86.55,80.97 86.38,80.83 86.32,80.63 86.37,80.44 86.52,80.31 86.58,80.24 86.55,80.15 85.78,79.38 85.68,79.38 85.64,79.41 85.64,79.46 85.69,79.56 85.71,79.67 85.61,79.9 85.38,80 85.21,79.95 85.08,79.81 84.91,79.81 84.65,80.07 84.62,80.16 84.67,80.24 84.77,80.31 84.83,80.42 84.9,80.48 85,80.45 85.27,80.18 85.54,80.18 85.73,80.37 85.73,80.64 84.91,81.45 84.89,81.56 84.98,81.63 85.14,81.63 85.18,81.67 85.21,81.66 85.25,81.65 85.3,81.65 85.38,81.62 85.51,81.29 85.76,81.19 86,81.28 86.11,81.5 86.12,81.52 86.19,81.59 86.19,81.89 85.46,82.62 85.43,82.73 85.53,82.8 85.62,82.8
GND on IN3 (solid shape): 50.77,36.77 50.88,36.79 50.94,36.7 50.94,36.61 51.16,36.4 52.45,36.4 52.69,36.63 52.87,36.63 53.11,36.4 55.53,36.4 55.62,36.33 55.6,36.22 55.38,36 55.29,35.98 55.22,36.03 55.09,36.18 54.9,36.23 54.64,36.13 54.54,35.88 54.55,35.82 54.56,35.76 54.55,35.67 54.46,35.62 53.92,35.62 53.84,35.67 53.83,35.77 53.86,35.85 53.87,35.93 53.51,36.28 53.16,35.93 53.17,35.85 53.19,35.77 53.19,35.67 53.1,35.62 52.65,35.62 52.57,35.67 52.56,35.77 52.59,35.85 52.6,35.93 52.24,36.28 51.89,35.93 51.9,35.85 51.92,35.77 51.92,35.67 51.83,35.62 51.32,35.62 50.46,36.48 50.44,36.59 50.53,36.66 50.66,36.66
GND on IN3 (solid shape): outline of 150 points within 159.1,17.66 164.72,20.66
GND on IN3 (solid shape): 137.85,108.64 137.85,108.21 137.81,108.12 137.71,108.11 137.65,108.13 137.58,108.14 137.4,108.09 137.27,107.95 137.18,107.9 137.09,107.95 137.03,108.03 136.96,108.09 136.9,108.18 136.96,108.27 137.09,108.4 137.14,108.58 137.03,108.83 136.78,108.93 136.6,108.88 136.47,108.75 136.38,108.7 136.29,108.75 136.16,108.88 135.98,108.93 135.62,108.58 135.98,108.22 136.16,108.27 136.29,108.4 136.38,108.46 136.47,108.4 136.53,108.33 136.6,108.27 136.65,108.18 136.6,108.09 136.47,107.96 136.42,107.78 136.43,107.69 136.46,107.61 136.46,107.51 136.38,107.46 135,107.46 134.94,107.52 134.94,108.8 134.29,109.44 134.27,109.55 134.37,109.62 136.87,109.62
GND on IN3 (solid shape): 171.11,18.95 171.13,18.84 171.03,18.78 171,18.78 170.86,18.76 170.75,18.68 170.68,18.65 170.61,18.68 170.49,18.76 170.36,18.78 170.25,18.77 170.15,18.72 170.08,18.7 170.01,18.74 169.89,18.85 169.73,18.88 169.6,18.86 169.49,18.79 169.42,18.76 169.35,18.79 169.23,18.87 169.09,18.9 168.98,18.88 168.87,18.83 168.8,18.8 168.73,18.84 168.68,18.89 168.61,18.93 168.61,19.31 167.99,19.93 167.97,20.03 168.04,20.1 168.16,20.14 168.25,20.22 168.32,20.25 168.4,20.22 168.51,20.15 168.64,20.13 169,20.48 168.64,20.84 168.49,20.81 168.37,20.72 168.3,20.68 168.23,20.71 168.11,20.78 167.98,20.8 167.73,20.7 167.63,20.45 167.63,20.39 167.58,20.34 167.47,20.44 167.47,20.62 167.3,20.79 167.28,20.9 167.37,20.97 169.1,20.97
GND on IN3 (solid shape): outline of 157 points within 150.66,46.76 152.24,55.73
GND on IN3 (solid shape): 48.2,99.72 51.2,99.72 51.6,100.11 60.95,100.11 61.25,99.81 64.64,99.81 66.95,97.5 67.82,97.5 70.47,94.85 73.92,94.85 74.69,94.08 81.55,94.08 82.58,93.05 86.96,93.05 88.75,91.26 91.45,91.26 92.33,90.38 93.87,90.38 95.57,88.68 95.57,84.04 96.74,82.86 96.74,82.69 96.73,82.65 96.69,82.64 96.46,82.54 96.35,82.32 96.29,82.23 96.18,82.25 94.95,83.49 94.95,88.95 93.7,90.2 90.26,90.2 90.17,90.26 90.18,90.37 90.24,90.47 90.26,90.59 89.9,90.94 89.55,90.59 89.57,90.47 89.62,90.37 89.64,90.26 89.54,90.2 89.14,90.2 89.05,90.26 89.06,90.37 89.12,90.47 89.14,90.59 88.78,90.94 88.43,90.59 88.45,90.47 88.51,90.37 88.52,90.26 88.43,90.2 88.17,90.2 85.49,92.88 82.51,92.88 81.48,93.9 74.62,93.9 73.85,94.68 70.09,94.68 67.55,97.22 66.23,97.22 63.93,99.52 61.26,99.52 60.85,99.93 51.66,99.93 51.26,99.52 47.23,99.52 47.14,99.57 47.14,99.67 47.16,99.73 47.17,99.81 47.16,99.89 47.13,99.97 47.13,100.07 47.22,100.12 47.8,100.12
GND on IN3 (solid shape): outline of 85 points within 92.52,74.32 113.52,98.05
GND on IN3 (solid shape): outline of 168 points within 179.74,24.85 188.54,26.48
GND on IN3 (solid shape): outline of 156 points within 189.42,14.11 197.47,16.83
GND on IN3 (solid shape): 120.14,46.51 120.25,46.49 121.43,45.31 127.64,45.31 129.46,43.49 129.46,39.93 130.47,38.92 147.72,38.92 147.82,38.85 147.79,38.74 147.77,38.72 147.41,38.36 147.41,35.35 147.34,35.25 147.23,35.28 147.11,35.37 146.96,35.4 146.83,35.38 146.71,35.3 146.63,35.27 146.56,35.31 146.44,35.4 146.29,35.44 146.21,35.43 146.13,35.4 146.04,35.41 145.99,35.5 145.99,37.41 144.77,38.63 130.49,38.63 129.55,37.69 124.72,37.69 124.5,37.91 124.5,39.03 123.68,39.84 123.66,39.95 123.75,40.02 123.88,40.04 123.99,40.12 124.06,40.14 124.13,40.12 124.25,40.04 124.38,40.02 124.73,40.37 124.38,40.73 124.25,40.7 124.13,40.63 124.06,40.6 123.99,40.63 123.88,40.7 123.74,40.73 123.49,40.63 123.39,40.38 123.32,40.29 123.21,40.31 121.81,41.71 121.81,43.24 119.47,45.58 119.47,46.07 119.51,46.16 119.61,46.17 119.68,46.14 119.75,46.14 119.97,46.22 120.08,46.43
GND on IN3 (solid shape): 89.27,115.3 94.88,115.3 94.96,115.26 94.98,115.17 94.96,115.11 94.96,115.05 95.01,114.86 95.15,114.73 95.2,114.64 95.15,114.55 95.01,114.42 94.96,114.24 95.31,113.88 95.67,114.24 95.62,114.42 95.48,114.55 95.42,114.64 95.48,114.73 95.57,114.8 95.63,114.89 95.71,114.95 95.8,114.92 95.92,114.8 95.92,113.84 95.87,113.76 95.77,113.76 95.68,113.79 95.59,113.8 95.34,113.7 95.24,113.45 95.26,113.31 95.33,113.2 95.36,113.13 95.33,113.06 95.26,112.95 95.24,112.81 95.59,112.46 95.95,112.81 95.91,112.97 95.81,113.09 95.8,113.13 95.81,113.17 95.85,113.2 95.92,113.2 95.92,113.15 96.66,112.41 96.66,111.85 96.6,111.76 96.48,111.78 96.11,112.15 94.87,112.15 92.51,114.52 86.79,114.52 86.17,115.13 86.15,115.24 86.24,115.3 87.02,115.3 87.69,115.96 88.61,115.96
GND on IN3 (solid shape): outline of 85 points within 103.08,31.44 111.01,67.68
GND on IN3 (solid shape): outline of 98 points within 121.94,36.29 151.48,50.45
GND on IN3 (solid shape): 108.57,64.66 108.65,64.63 108.67,64.55 108.67,64.5 108.78,64.25 109.03,64.15 109.11,64.16 109.19,64.18 109.27,64.19 109.33,64.13 109.46,63.96 109.66,63.89 109.71,63.9 109.76,63.91 109.85,63.89 109.89,63.81 109.89,62.47 109.56,62.13 109.45,62.11 109.38,62.21 109.38,62.22 109.36,62.35 109.28,62.46 109.26,62.53 109.28,62.6 109.36,62.72 109.38,62.85 109.03,63.21 108.67,62.85 108.7,62.72 108.77,62.6 108.8,62.53 108.77,62.46 108.7,62.35 108.67,62.22 108.78,61.96 109.03,61.86 109.04,61.86 109.13,61.8 109.11,61.69 108.47,61.04 108.47,55.2 107.41,54.15 107.41,50.35 105.71,48.64 105.71,43.64 105.46,43.39 105.46,41.07 105.12,40.74 105.12,36.72 105.07,36.63 104.97,36.64 104.88,36.68 104.79,36.69 104.66,36.66 104.55,36.59 104.48,36.56 104.41,36.59 104.32,36.64 104.2,36.66 104.15,36.66 104.11,36.65 104.02,36.67 103.97,36.75 103.97,36.86 104.63,37.52 104.63,41.87 105.28,42.51 105.28,43.94 105.53,44.19 105.53,48.71 107.24,50.42 107.24,54.22 108.29,55.28 108.29,64.41 108.54,64.66
GND on IN3 (solid shape): outline of 175 points within 96.35,74.56 104.82,82.05
GND on IN3 (solid shape): 123.76,114.22 123.85,114.16 123.85,114.06 123.8,113.96 123.78,113.85 124.14,113.5 124.5,113.85 124.48,113.96 124.43,114.06 124.43,114.16 124.52,114.22 125.17,114.22 125.25,114.17 125.26,114.07 125.24,114 125.23,113.93 125.59,113.57 125.94,113.93 125.94,114 125.91,114.07 125.92,114.17 126.01,114.22 126.72,114.22 126.82,114.16 126.8,114.05 126.74,113.94 126.71,113.81 126.75,113.66 126.84,113.54 126.87,113.43 126.78,113.36 120.77,113.36 120.42,113.01 120.35,113.03 120.31,113.03 120.06,112.92 119.95,112.67 119.98,112.54 120.05,112.42 120.08,112.35 120.05,112.28 119.98,112.16 119.95,112.03 119.97,111.91 120.02,111.81 120.03,111.71 119.94,111.65 119.56,111.65 119.47,111.74 119.49,111.81 119.49,111.85 119.45,112.01 119.35,112.14 119.31,112.2 119.33,112.28 119.38,112.38 119.4,112.5 119.4,112.54 119.39,112.61 119.73,112.95 119.73,113.33 120.22,113.82 121.91,113.82 122.3,114.22
GND on IN3 (solid shape): 156.31,27.88 158.9,27.88 159.39,27.39 163.22,27.39 163.89,26.72 166.1,26.72 166.65,26.17 167.05,26.17 167.15,26.11 167.12,26 167.04,25.88 167.01,25.74 167.02,25.63 167.07,25.53 167.08,25.42 166.99,25.37 166.74,25.37 165.56,26.55 163.81,26.55 163.15,27.22 159.32,27.22 158.83,27.7 156.23,27.7 155.8,28.13 153.41,28.13 153.03,27.75 146.05,27.75 144.79,26.48 122.07,26.48 120.78,25.19 116.58,25.19 115.39,26.38 115.37,26.38 115.33,26.4 115.33,26.45 115.35,26.48 115.42,26.54 115.51,26.51 116.66,25.37 120.7,25.37 122,26.66 140.28,26.66 140.7,27.08 140.78,27.11 140.86,27.05 140.99,26.9 141.18,26.85 141.43,26.95 141.54,27.2 141.48,27.39 141.33,27.52 141.28,27.6 141.31,27.69 141.54,27.92 142.17,27.92 142.26,27.87 142.26,27.76 142.21,27.67 142.2,27.57 142.3,27.32 142.56,27.21 142.64,27.22 142.72,27.25 142.81,27.25 142.86,27.18 142.99,26.98 143.21,26.9 143.57,27.26 143.21,27.62 143.13,27.61 143.05,27.58 142.96,27.58 142.9,27.65 142.88,27.71 142.85,27.76 142.85,27.87 142.94,27.92 152.95,27.92 153.51,28.48 155.71,28.48
GND on IN3 (solid shape): outline of 99 points within 65.92,24.85 94.68,32.2
GND on IN3 (solid shape): outline of 200 points within 105.24,18.42 112.66,29.69
GND on IN3 (solid shape): outline of 97 points within 47.39,82.57 97.71,102.09
GND on IN3 (solid shape): 60.47,106.54 60.56,106.49 60.55,106.38 60.51,106.27 60.49,106.16 60.52,105.99 60.63,105.85 60.66,105.78 60.63,105.7 60.52,105.56 60.49,105.4 60.61,105.11 60.89,104.99 61.07,105.03 61.22,105.15 61.29,105.19 61.37,105.16 61.5,105.07 61.66,105.04 61.94,105.16 62.06,105.45 62.06,105.5 62.05,105.55 62.07,105.64 62.15,105.67 63.2,105.67 63.28,105.63 63.29,105.53 63.27,105.45 63.26,105.37 63.38,105.08 63.66,104.96 63.76,104.98 63.86,105.01 63.94,105.02 64,104.96 64.01,104.93 64.01,104.89 63.97,104.86 63.72,104.73 63.61,104.46 64.02,104.05 64.43,104.46 64.42,104.52 64.4,104.59 64.41,104.67 64.47,104.72 64.7,104.87 64.78,105.12 64.78,105.15 64.84,105.25 64.95,105.23 66.55,103.64 66.57,103.53 66.47,103.47 60.47,103.47 59.09,104.84 58.59,104.84 58.5,104.89 58.5,104.99 58.52,105.06 58.53,105.14 58.53,105.19 58.52,105.24 58.51,105.27 59.78,106.54
GND on IN3 (solid shape): 104.56,77.01 104.64,76.98 105.83,75.79 105.83,74.6 106.51,73.92 106.51,73.83 106.48,73.79 106.43,73.8 106.31,73.87 106.18,73.89 105.93,73.79 105.83,73.54 105.86,73.39 105.94,73.27 105.98,73.2 105.95,73.13 105.88,73.02 105.85,72.88 106.21,72.53 106.56,72.88 106.53,73.03 106.45,73.15 106.41,73.22 106.44,73.29 106.48,73.34 106.51,73.4 106.58,73.46 106.68,73.43 107.86,72.25 108.98,72.25 109.06,72.21 109.07,72.11 109.06,72.06 109.05,72 109.08,71.86 109.15,71.75 109.18,71.68 109.15,71.61 109.08,71.49 109.05,71.36 109.41,71 109.77,71.36 109.74,71.49 109.67,71.61 109.64,71.68 109.67,71.75 109.74,71.86 109.77,72 109.76,72.06 109.74,72.11 109.76,72.21 109.84,72.25 109.96,72.25 111.05,71.16 111.06,71.13 111.05,71.09 110.98,70.98 110.96,70.85 110.98,70.72 111.06,70.6 111.09,70.53 111.06,70.46 111.02,70.41 110.98,70.35 110.91,70.29 110.82,70.32 110.52,70.62 105.95,70.62 105.31,71.25 105.31,75.7 104.31,76.7 104.28,76.79 104.34,76.87 104.42,76.91 104.48,76.97
GND on IN3 (solid shape): 116.27,47.29 116.27,45.25 116.22,45.17 116.13,45.15 116.07,45.17 116.01,45.17 115.76,45.07 115.66,44.82 115.68,44.68 115.76,44.57 115.78,44.5 115.76,44.43 115.68,44.32 115.66,44.18 115.68,44.05 115.76,43.93 115.78,43.86 115.76,43.79 115.68,43.68 115.66,43.55 115.76,43.3 116.01,43.19 116.07,43.2 116.13,43.21 116.22,43.2 116.27,43.12 116.27,43 115.95,42.68 115.94,42.68 115.74,42.55 115.66,42.33 115.68,42.2 115.76,42.08 115.78,42.01 115.76,41.94 115.68,41.83 115.66,41.7 115.68,41.56 115.76,41.45 115.78,41.38 115.76,41.31 115.68,41.19 115.66,41.06 115.68,40.93 115.76,40.81 115.78,40.74 115.76,40.67 115.68,40.56 115.66,40.43 115.66,40.39 115.64,40.32 115.58,40.28 115.52,40.26 115.46,40.23 115.43,40.21 115.36,40.28 115.4,40.31 115.4,45.7 115.45,45.79 115.56,45.78 115.65,45.73 115.76,45.72 116.12,46.07 115.76,46.43 115.65,46.41 115.56,46.37 115.45,46.36 115.4,46.45 115.4,47 115.45,47.09 115.56,47.08 115.65,47.03 115.76,47.02 116,47.11 116.11,47.33 116.11,47.35 116.16,47.4
GND on IN3 (solid shape): outline of 221 points within 119.83,116.63 142.33,119.59
GND on IN3 (solid shape): outline of 214 points within 168.04,18.52 179.25,22.32
GND on IN3 (solid shape): outline of 96 points within 125.06,86.87 134.19,101.52
GND on IN3 (solid shape): outline of 221 points within 11.13,77.02 14.52,81.37
GND on IN3 (solid shape): 21.2,39.8 21.27,39.62 21.25,39.52 21.15,39.38 21.14,39.32 21.14,37.63 21.15,37.57 21.19,37.51 21.27,37.32 21.19,37.13 21.15,37.08 21.14,37.02 21.14,35.9 21.77,35.27 21.8,35.18 21.75,35.1 21.6,34.97 21.55,34.78 21.91,34.43 22.26,34.78 22.26,34.82 22.25,34.86 22.26,34.9 22.29,34.92 22.33,34.94 22.36,34.97 22.45,35.02 22.54,35.04 22.79,34.78 22.54,34.53 22.53,34.53 22.42,34.49 22.38,34.38 22.38,34.33 22.42,34.26 22.45,34.24 22.57,34.02 22.45,33.81 22.4,33.75 22.38,33.68 22.38,33.36 22.38,33.32 22.4,33.28 22.42,33.25 22.36,33.18 21,34.54 21,34.74 20.89,34.92 20.67,34.9 20.59,34.85 20.25,35.09 20.59,35.33 20.67,35.29 20.89,35.26 21,35.45 21,37 20.95,37.07 20.91,37.09 20.76,37.32 20.91,37.56 20.95,37.57 21,37.65 21,39.25 20.98,39.33 20.8,39.48 20.76,39.62 20.77,39.66 20.78,39.7 20.78,39.75 20.78,39.79 20.77,39.81 20.79,39.87 20.89,39.85 20.93,39.86 20.98,39.87 21.02,39.87
GND on IN3 (solid shape): outline of 227 points within 34.35,7.96 77.05,17.16
GND on IN3 (solid shape): outline of 248 points within 139.32,62.49 148.41,73.91
GND on IN3 (solid shape): outline of 83 points within 42.98,16.68 71.02,20.97
GND on IN3 (solid shape): outline of 109 points within 86.64,32.02 92.24,48.82
GND on IN3 (solid shape): outline of 139 points within 145.69,19.6 197.22,44.45
GND on IN3 (solid shape): outline of 115 points within 66.53,83.64 103.7,108.94
GND on IN3 (solid shape): outline of 248 points within 88.99,62.66 92.32,65.3
GND on IN3 (solid shape): outline of 87 points within 0.5,103.64 45.31,120.15
GND on IN3 (solid shape): outline of 300 points within 199.09,19.96 205.4,29.47
GND on IN3 (solid shape): outline of 277 points within 119.26,63.1 149.01,76.4
GND on IN3 (solid shape): outline of 101 points within 86.7,44.61 89.45,52.12
GND on IN3 (solid shape): outline of 115 points within 108.36,46.43 113.52,62.29
GND on IN3 (solid shape): outline of 322 points within 109.26,57.75 113.9,70.12
GND on IN3 (solid shape): outline of 351 points within 173.25,16.64 192.26,20.38
GND on IN3 (solid shape): outline of 330 points within 136,29.78 147.48,37.02
GND on IN3 (solid shape): outline of 98 points within 123.81,81.59 139.79,89.51
GND on IN3 (solid shape): outline of 111 points within 87.1,49.26 89.96,59.7
GND on IN3 (solid shape): outline of 356 points within 148.12,25.87 177.54,38.24
GND on IN3 (solid shape): outline of 371 points within 125.77,86.87 132.9,99.04
GND on IN3 (solid shape): outline of 217 points within 53.86,49.54 77.56,55.08
GND on IN3 (solid shape): outline of 395 points within 84.66,65.85 89.08,79.03
GND on IN3 (solid shape): outline of 415 points within 106.69,32.74 112.36,47.68
GND on IN3 (solid shape): outline of 425 points within 114.38,74.75 122.58,88.03
GND on IN3 (solid shape): outline of 414 points within 86.84,68.2 98.33,89.38
GND on IN3 (solid shape): outline of 487 points within 25.95,97.21 40.48,104.06
GND on IN3 (solid shape): outline of 479 points within 99.77,45.95 105.4,67.8
GND on IN3 (solid shape): outline of 475 points within 122.71,21.45 167.62,25.83
GND on IN3 (solid shape): outline of 153 points within 95.88,38.06 98.34,50.58
GND on IN3 (solid shape): outline of 191 points within 39.95,46.86 48.41,53.6
GND on IN3 (solid shape): outline of 508 points within 47.52,112.86 66.79,119.78
GND on IN3 (solid shape): outline of 603 points within 91.04,53.22 93.18,63.79
GND on IN3 (solid shape): outline of 584 points within 73.15,96.43 99.29,116.34
GND on IN3 (solid shape): outline of 578 points within 98.35,32.73 101.52,65.8
GND on IN3 (solid shape): outline of 232 points within 113.12,15.65 195.94,26.55
GND on IN3 (solid shape): outline of 660 points within 119.74,26.81 192.17,67.14
GND on IN3 (solid shape): outline of 687 points within 88.81,65.33 93.45,81.63
GND on IN3 (solid shape): outline of 1115 points within 29.23,12.61 100.46,45.46
GND on IN3 (solid shape): outline of 1388 points within 90.38,31.67 97.96,51.21
GND on IN3 (solid shape): outline of 1483 points within 116.28,26.14 148.39,40.67
GND on IN3 (solid shape): outline of 1515 points within 92.69,49.71 99.28,67.83
GND on IN3 (solid shape): outline of 1922 points within 42.65,97.66 93.52,117.87
GND on IN3 (solid shape): outline of 1920 points within 94.8,37.06 109.94,78.21
GND on IN3 (solid shape): outline of 2506 points within 40.21,77.72 103.55,110.36
GND on IN3 (solid shape): outline of 2998 points within 120.12,43.56 150.17,71.34
GND on IN3 (solid shape): outline of 5787 points within 23.18,24.27 94.53,93.72
GND on IN3 (solid shape): outline of 6011 points within 0.5,11.84 36.12,104
GND on IN3 (solid shape): outline of 7326 points within 46.05,34.58 91.69,95.09
GND on IN3 (solid shape): outline of 13343 points within 0.5,0.5 224.67,127.5
GND on SGND1 (solid shape): outline of 2620 points within 0.51,0.51 224.66,127.49
VDDBT_RTC on TOP (solid shape): outline of 281 points within 95.7,27.34 102.32,34.53
VDDP on TOP (solid shape): 116.5,42.5 116.53,42.41 116.62,42.37 117.44,42.37 117.52,42.4 117.56,42.48 117.56,42.5 117.61,42.54 117.71,42.45 117.71,40.99 117.68,40.98 117.65,40.95 117.61,40.92 117.54,40.89 117.46,40.92 117.38,40.98 117.29,41 117.01,41 116.86,40.95 116.78,40.81 116.78,40.8 116.76,40.76 116.75,40.75 116.2,40.21 115.88,40.21 115.77,40.28 115.63,40.31 115.51,40.28 115.4,40.22 115.15,40.22 114.82,40.56 114.82,42.37 115.63,42.37 115.72,42.41 115.76,42.5 115.76,42.61 116.5,42.61
VDDP on BOTTOM (solid shape): 129.53,37.73 129.53,36.49 129.4,36.36 125.85,36.36 125.73,36.48 125.73,37 125.93,37.2 125.93,37.82 126.17,38.05 129.2,38.05
VDDP on IN2 (solid shape): outline of 411 points within 115.57,36.23 130.41,46.99
VDDP_S5 on TOP (solid shape): outline of 196 points within 102.99,33.76 111.8,38.64
VDDP_S5 on BOTTOM (solid shape): 127.95,47.84 127.95,44.08 127.99,43.98 128.08,43.95 128.36,43.95 128.36,43.93 128.68,43.61 129.11,43.61 129.49,43.24 129.49,38.95 129.36,38.82 124.78,38.82 124.78,38.83 124.31,38.83 123.36,39.78 123.36,42.5 123.49,42.64 124.32,42.64 124.78,43.1 124.78,45.37 125.55,46.14 125.55,47.77 125.76,47.99 127.8,47.99
VDDP_S5 on IN2 (solid shape): outline of 471 points within 111.03,31.85 124.71,40.62
VDDQ_BOOT on TOP (solid shape): 64.41,120.66 64.41,120.4 64.35,120.33 63.78,120.33 63.11,119.66 62.42,119.66 62.38,119.69 62.38,120.45 62.41,120.48 63.56,120.48 63.78,120.7 64.38,120.7
VDDQ_PVIN on TOP (solid shape): 71.71,121.81 71.97,121.71 72.23,121.81 73.11,121.81 73.11,121.12 72.58,120.6 72.54,120.62 72.43,120.69 72.3,120.71 72.03,120.6 71.92,120.33 71.94,120.21 72,120.09 72.02,120.06 72.49,119.58 72.49,118.35 72.46,118.32 70.95,118.32 70.73,118.55 70.73,118.8 70.74,118.81 70.88,119.07 70.93,119.37 70.81,119.8 70.5,120.13 70.49,120.13 70.27,120.23 70.02,120.26 70,120.25 69.74,120.21 69.51,120.08 69.5,120.07 69.42,120.07 68.18,120.07 67.83,120.43 64.98,120.43 64.93,120.47 64.93,120.84 64.99,120.9 67.54,120.9 67.63,120.89 67.95,120.9 67.96,120.9 68.22,120.9 68.43,121.11 68.43,121.71 68.54,121.81
VDDQ_SW on TOP (solid shape): 59.91,124.04 59.91,122.35 60.83,121.43 66.01,121.43 66.07,121.37 66.07,121.13 65.98,121.04 64.89,121.04 64.68,120.83 63.69,120.83 63.51,120.66 60.5,120.66 59.8,119.96 59.8,119.56 59.74,119.5 59.37,119.5 59.3,119.57 59.3,120.49 59.16,120.63 57.43,120.63 57.35,120.71 57.35,124.07 57.47,124.19 59.76,124.19
VDDQ_SW_VPP on TOP (solid shape): 64.63,125.67 64.63,123.64 64.39,123.4 64.39,122.4 64.33,122.35 63.83,122.35 63.37,122.81 63.37,125.45 63.7,125.77 64.53,125.77
VDDQ_VCC on TOP (solid shape): 70.11,125.25 70.11,124.75 69.91,124.75 69.88,124.75 69.62,124.65 69.5,124.4 68.29,124.4 68.03,124.14 66.22,124.14 66,123.92 65.7,123.92 65.42,123.63 65.41,123.48 65.41,123.45 65.41,123.41 65.42,123.37 65.42,122.97 65.39,122.94 65.39,122.4 65.37,122.36 65.34,122.34 65.19,122.34 65.16,122.36 65.14,122.4 65.14,122.94 64.89,122.94 64.89,122.4 64.87,122.36 64.84,122.34 64.69,122.34 64.66,122.36 64.64,122.4 64.64,122.94 64.51,123.07 64.51,123.35 64.75,123.59 64.75,124.94 64.88,125.06 67.04,125.06 67.08,125.11 69.39,125.11 69.54,125.26 69.59,125.3 69.63,125.35 70.01,125.35
VDDQ_VLDOIN on TOP (solid shape): 64.38,120.03 64.38,119.57 64.31,119.51 64.3,119.5 64.07,119.37 63.97,119.13 63.98,119.06 64,118.98 64,118.46 63.79,118.25 62.41,118.25 62.37,118.29 62.37,119.06 62.82,119.51 63.14,119.51 63.77,120.13 64.28,120.13
VDDQ_VTTREF on TOP (solid shape): 67.22,120.07 67.22,119.78 67.28,119.71 67.28,119.71 67.86,119.13 67.86,119.13 68.01,118.99 68.28,118.99 68.33,118.94 68.33,118.53 68.3,118.5 68.05,118.5 67.01,119.54 66.73,119.54 66.65,119.62 66.65,120.05 66.72,120.11 67.18,120.11
3662AC_CPU_LG1 on BOTTOM (solid shape): 134.44,62.58 135.46,62.58 135.66,62.37 135.66,61.98 135.48,61.8 134.57,61.8 134.49,61.79 134.4,61.71 134.4,61.23 134.12,60.95 132.54,60.95 132.4,61.09 132.4,61.78 133.34,62.72 134.3,62.72
3662AC_CPU_LG2 on BOTTOM (solid shape): 135.48,54.95 135.55,54.95 136.12,54.39 137.24,54.39 137.31,54.32 137.31,53.7 137.25,53.64 135.53,53.64 135.16,54.01 135.16,54.87 135.25,54.95 135.36,54.95
3662AC_CPU_LX1 on TOP (solid shape): 132.33,58.91 132.33,57.65 132.19,57.52 131.7,57.52 131.41,57.81 131.41,58.92 131.47,58.97 132.26,58.97
3662AC_CPU_LX1 on BOTTOM (solid shape): 132.27,61.75 132.27,60.99 132.49,60.77 133.13,60.77 133.25,60.65 133.25,57.32 133.12,57.19 129.68,57.19 128.67,58.2 128.67,59.3 129.07,59.7 129.45,59.7 129.45,60.26 128.92,60.26 128.67,60.51 128.67,61.78 128.84,61.95 132.07,61.95
3662AC_CPU_LX2 on BOTTOM (solid shape): 135.02,54.58 135.02,53.92 135.47,53.47 136.16,53.47 136.41,53.23 136.41,49.93 135.49,49.01 135.49,48.41 135.35,48.27 134.62,48.27 134.56,48.33 134.56,48.91 131.91,51.57 131.91,52.48 132.01,52.59 132.6,52.59 132.6,53.07 131.95,53.07 131.91,53.12 131.91,54.47 132.27,54.82 134.78,54.82
3662AC_HG1 on BOTTOM (solid shape): 140.24,60.43 140.24,59.69 139.85,59.3 139.04,59.3 139.01,59.33 139.01,60.08 139.14,60.22 139.57,60.22 139.86,60.51 139.9,60.51 139.94,60.55 140.12,60.55
3662AC_HG2 on BOTTOM (solid shape): 143.77,51.72 143.77,50.81 143.61,50.65 143.26,50.65 142.76,51.15 142.64,51.15 142.53,51.26 142.53,52.04 142.6,52.1 143.38,52.1
3662AC_NB_HG1 on BOTTOM (solid shape): 134.56,70.99 134.56,70.14 134.4,69.98 134.12,69.98 133.68,70.42 133.68,71.25 133.72,71.29 134.26,71.29
3662AC_NB_LG1 on BOTTOM (solid shape): 136.26,66.36 136.26,65.42 135.98,65.14 135.49,65.14 135.36,65.26 135.36,66.41 135.43,66.48 136.15,66.48
3662AC_NB_LX1 on BOTTOM (solid shape): 138.02,76.92 138.02,73.17 138.35,72.84 138.35,71.97 138.79,71.54 139.64,71.54 140.13,71.04 140.13,66.72 140.03,66.61 134.93,66.61 134.7,66.84 134.7,71.05 134.26,71.48 133.63,71.48 133.52,71.37 133.52,70.17 133.33,69.99 130.09,69.99 129.87,70.21 129.87,72.87 130.19,73.19 131.99,73.19 133.17,74.36 133.17,74.6 133.44,74.87 135.65,74.87 135.65,76.77 135.83,76.95 137.99,76.95
3662AM_HG1_GPU on BOTTOM (solid shape): 79.51,106.49 79.51,105.89 79.48,105.87 78.41,105.87 78.38,105.84 77.56,105.84 77.48,105.91 77.48,106.51 77.59,106.62 79.38,106.62
3662AM_HG1_VDDCI on BOTTOM (solid shape): 79.59,122.36 79.59,121.64 79.39,121.45 77.4,121.45 77.34,121.51 77.34,122.36 77.43,122.45 79.5,122.45
3662AM_HG2_GPU on BOTTOM (solid shape): 77.79,99.96 77.81,99.96 77.82,99.95 77.92,99.85 77.92,99.21 77.69,98.98 76.12,98.98 76.03,99.07 76.03,99.85 76.15,99.96
3662AM_LG1_GPU on BOTTOM (solid shape): 85.69,106.18 85.69,105.84 85.51,105.66 83.47,105.66 83.3,105.83 83.3,106.48 85.39,106.48
3662AM_LG1_VDDCI on BOTTOM (solid shape): 79.66,116.59 79.66,116.22 79.66,116.22 79.66,115.5 79.51,115.35 79.29,115.35 79.06,115.57 79.06,115.82 78.85,116.03 78.85,116.67 78.95,116.76 79.49,116.76
3662AM_LG2_GPU on BOTTOM (solid shape): 83.51,99.76 83.51,98.81 83.34,98.64 82.28,98.64 81.74,99.18 81.74,99.81 81.76,99.83 83.44,99.83
3662AM_LX1_GPU on TOP (solid shape): 84.84,110.96 84.84,110.63 84.65,110.45 83.09,110.45 83.05,110.48 83.05,111.28 83.09,111.31 84.5,111.31
3662AM_LX1_GPU on BOTTOM (solid shape): 88.33,110.91 88.33,108.91 88.17,108.75 87.92,108.75 87.92,108.16 88.43,108.16 88.61,107.98 88.61,106.37 88.2,105.96 86.35,105.96 85.56,106.75 84.52,106.75 84.25,107.02 84.25,110.42 84.26,110.44 84.26,111.08 84.38,111.2 88.04,111.2
3662AM_LX1_VDDCI on BOTTOM (solid shape): 87.35,121.58 87.36,121.55 87.36,121.53 87.35,121.48 87.44,121.18 87.7,121.03 87.71,121 87.71,120.63 87.67,120.59 86.63,120.59 86.63,119.98 87.64,119.98 87.71,119.91 87.71,118.31 86.45,117.05 79.1,117.05 79.09,117.06 79.09,119.8 79.25,119.96 83.09,119.96 83.62,120.49 83.62,121.63 84.03,122.03 86.89,122.03
3662AM_LX2_GPU on BOTTOM (solid shape): 87.5,103.36 87.5,101.89 87.12,101.51 86.47,101.51 86.47,100.98 87.18,100.98 87.32,100.83 87.34,100.81 87.34,100.79 87.34,99.98 87.07,99.71 86.85,99.71 86.61,99.47 86.61,99.2 86.4,98.99 85.78,98.99 85.25,98.46 85.25,97.83 84.85,97.44 83.83,97.44 83.7,97.56 83.7,98.39 83.78,98.47 83.78,100.14 83.56,100.37 82.85,100.37 82.71,100.51 82.71,103.92 83.21,104.41 86.45,104.41
3662AM_UGATE1_GPU on BOTTOM (solid shape): 77.43,108.53 77.43,108.46 77.43,108.4 77.6,108.23 78.03,108.23 78.38,107.88 78.38,107.18 78.37,107.17 77.55,107.17 77.25,107.47 77.25,107.82 76.92,108.15 76.92,108.52 77.07,108.67 77.29,108.67
3662AM_UGATE2_GPU on BOTTOM (solid shape): 75.84,99.66 75.84,98.49 75.66,98.32 75.35,98.32 74.77,98.9 74.77,99.81 74.86,99.9 75.6,99.9
3662AM_UGATE_VDDCI on BOTTOM (solid shape): 77.18,122.15 77.18,120.59 77.04,120.45 76.8,120.45 76.63,120.62 76.62,120.64 76.62,120.66 76.62,120.92 76.04,121.5 76.04,122.39 76.16,122.5 76.84,122.5
5213FB_1.8V on TOP (solid shape): 41.82,24.17 41.82,23.86 41.72,23.76 41.36,23.76 40.98,23.38 39.43,23.38 39.33,23.48 39.33,23.79 39.41,23.86 40.78,23.86 41.16,24.24 41.74,24.24
5213LX_1.8V on TOP (solid shape): 38.23,28.42 38.23,28.29 38.78,27.73 39.74,27.73 39.76,27.71 39.76,27.44 38.83,27.44 38.63,27.24 38.6,27.22 38.42,27.04 38.4,27.01 38.18,26.79 38.18,24.79 38.01,24.63 37.34,24.63 37.21,24.75 37.21,28.48 37.23,28.5 38.15,28.5
5213LX_VDD08 on TOP (solid shape): 91.6,112.86 90.38,112.86 90.13,113.12 90.13,113.78 90.02,113.88 89.17,113.88 89.17,114.18 90.13,114.18 90.84,114.9 91.6,114.9
24780_LX on BOTTOM (solid shape): 125.05,32.62 125.05,28.45 124.77,28.17 123.78,28.17 123.53,27.91 123.53,27.1 123.38,26.95 122.82,26.95 122.69,27.08 122.69,28 122.39,28.31 119.39,28.31 119.24,28.45 119.24,31.86 119.46,32.07 122.18,32.07 122.5,32.39 122.5,33.07 122.57,33.15 124.53,33.15
24780_VCC on BOTTOM (solid shape): 131.96,32.94 132.12,32.94 132.62,32.44 132.62,32.35 132.6,32.33 131.76,32.33 131.58,32.52 131.2,32.52 131.14,32.58 130.86,32.58 130.76,32.69 130.76,33.06 130.28,33.54 129.85,33.54 129.84,33.55 129.84,34.36 129.86,34.38 130.52,34.38
+601_VCC on TOP (solid shape): 212.88,18.4 213.48,18.4 213.61,18.4 213.79,18.4 213.81,18.38 213.81,17.44 213.78,17.41 213.43,17.41 213.31,17.49 213.17,17.51 212.95,17.44 212.79,17.24 212.76,17.23 212.64,17.23 211.68,17.23 211.66,17.25 211.66,17.48 211.71,17.53 211.98,17.53 212.63,18.18 212.63,18.38 212.65,18.4
+601_VCC on TOP (solid shape): outline of 95 points within 203.13,10.45 208.83,18.66
+601_VCC on IN2 (solid shape): outline of 609 points within 206.38,10.1 216.63,18.74
+APU_VDD_33 on BOTTOM (solid shape): 90.3,49.56 90.3,49.22 89.83,48.75 89.59,48.75 89.48,48.86 89.48,49.06 89.63,49.21 89.63,49.61 89.14,50.1 89.14,50.3 89.21,50.37 89.49,50.37
+APU_VDD_33_S5 on TOP (solid shape): outline of 116 points within 90.25,30.97 93.2,34.69
+APU_VDD_33_S5 on BOTTOM (solid shape): 91,49.63 91.01,49.62 91.04,49.54 91.09,49.46 91.1,49.44 91.1,49.29 91.09,49.26 91.07,49.25 90.99,49.16 90.95,49.05 90.95,49.03 90.67,48.76 90.5,48.76 90.39,48.87 90.39,49.12 90.47,49.2 90.47,49.57 89.94,50.09 89.94,50.27 90.05,50.37 90.27,50.37
+APU_VDDIO_AZ on TOP (solid shape): 98.28,36.51 99.83,36.51 100.19,36.15 101.13,36.15 101.22,36.24 101.6,36.24 101.92,35.93 101.92,35.17 101.75,35 101.1,35 101.03,35.03 101,35.1 101,35.11 100.9,35.37 100.65,35.47 100.42,35.39 100.28,35.17 100.25,35.15 99.27,35.15 99.18,35.21 99.19,35.32 99.25,35.43 99.27,35.55 98.92,35.9 98.56,35.55 98.61,35.38 98.72,35.25 98.75,35.23 98.75,35.15 98.63,35.15 98.52,35.05 97.74,35.05 97.59,34.9 96.88,34.9 96.87,34.89 94.93,34.89 94.81,34.95 94.68,34.98 94.61,34.98 94.17,35.42 94.17,35.93 94.27,36.03 95.5,36.03 95.63,35.9 95.82,35.85 95.93,35.87 96.04,35.92 96.05,35.93 96.21,35.93 96.3,35.8 96.34,35.8 96.35,35.79 96.45,35.74 96.56,35.72 96.62,35.73 97.12,35.73 97.37,35.83 97.47,36.08 97.46,36.17 97.8,36.51 98.28,36.51
+ECVSPI on TOP (solid shape): 163,33.04 163,32.21 163,32.18 163,31.04 163,31.01 163,30.69 163,30.63 162.99,30.62 162.96,30.54 162.95,30.47 162.96,30.39 162.99,30.32 163,30.3 163,30.24 163,30.09 163.35,29.74 163.35,28.93 163.27,28.84 161.35,28.84 161.23,28.97 161.23,29.48 161.34,29.59 161.44,29.59 161.48,29.59 161.74,29.59 161.78,29.59 162.01,29.59 162.52,30.11 162.52,30.16 162.53,30.18 162.6,30.31 162.62,30.47 162.62,31.61 162.6,31.76 162.53,31.9 162.52,31.92 162.2,32.25 162.2,32.64 162.2,32.65 162.23,32.75 162.24,32.85 162.24,32.91 162.23,32.97 162.23,33 162.37,33.13 162.91,33.13
+G_SEN_PW on TOP (solid shape): 63.77,19.59 63.77,19.31 63.95,19.13 67.12,19.13 67.22,19.02 67.22,18.61 67.16,18.55 66.21,18.55 66.09,18.42 66.09,17.57 65.78,17.27 64.51,17.27 64.45,17.26 64.33,17.14 64.31,17.14 64.31,16.19 64.43,16.07 64.95,16.07 65.09,15.94 65.09,15.28 64.99,15.18 64.44,15.18 64.41,15.19 64.4,15.2 64.39,15.44 64.38,15.47 64.36,15.5 64.34,15.52 64.32,15.54 64.29,15.55 64.27,15.55 64.25,15.57 64.2,15.6 64.15,15.62 64.1,15.63 64.07,15.63 60.66,15.63 60.39,15.9 60.39,17.62 60.39,17.66 60.39,17.87 61.28,17.87 61.28,16.77 61.68,16.37 63.14,16.37 63.57,16.8 63.57,17.16 63.7,17.29 64.21,17.29 64.37,17.46 64.37,18.45 64.17,18.66 63.08,18.66 62.95,18.53 61.93,18.53 61.28,17.87 60.39,17.87 60.39,17.95 60.41,17.98 60.45,18.04 60.48,18.11 60.51,18.18 60.52,18.26 60.53,18.33 60.53,18.37 60.53,19.77 60.56,19.8 60.8,19.8 61.69,19.8 61.82,19.93 63.44,19.93
+G_SEN_PW on IN3 (solid shape): 67.24,16.37 67.24,15.61 67.1,15.46 66.57,15.46 66.48,15.51 66.48,15.61 66.51,15.69 66.52,15.78 66.16,16.13 65.81,15.78 65.82,15.69 65.85,15.61 65.85,15.51 65.76,15.46 64.35,15.46 64.2,15.61 64.2,16.24 64.7,16.75 66.86,16.75
+TYPEC_VBUS on BOTTOM (solid shape): 14.26,23.44 14.44,23.44 14.45,23.46 15.55,23.46 15.59,23.41 15.59,22.81 15.52,22.73 14.05,22.73 13.68,22.37 11.67,22.37 11.51,22.53 11.51,24.28 11.74,24.5 13.2,24.5
+TYPEC_VBUS on BOTTOM (solid shape): 20.56,11.93 21.72,11.93 21.74,11.92 21.76,11.91 22.03,11.8 22.31,11.91 22.32,11.92 22.34,11.93 23.25,11.93 23.27,11.92 23.41,11.83 23.56,11.8 23.83,11.91 23.94,12.18 23.88,12.38 23.71,12.54 23.7,12.57 23.7,14.34 25.68,16.32 26.54,16.32 26.69,16.17 26.69,15.78 26.67,15.75 26.65,15.74 26.6,15.74 26.34,15.63 26.22,15.36 26.23,15.32 26.22,15.3 24.87,13.95 24.85,13.95 24.64,13.81 24.56,13.58 24.59,13.42 24.69,13.28 24.69,13.26 24.69,11.71 23.71,10.73 20.38,10.73 14.43,16.68 14.42,16.7 14.41,16.72 14.41,16.75 14.36,16.94 14.2,17.1 14.2,17.12 14.2,17.58 14.38,17.76 14.73,17.76
+TYPEC_VBUS on IN2 (solid shape): outline of 1271 points within 5.55,12.54 14.94,24.42
+USBPWR0 on TOP (solid shape): 19.53,52.52 19.53,49.76 19.49,49.73 19.16,49.73 18.76,50.14 17.48,50.14 17.2,50.41 17.2,52.52 17.25,52.58 19.47,52.58
+USBPWR0 on BOTTOM (solid shape): outline of 399 points within 13.97,49.53 22.63,59.07
+USBPWR0 on IN1 (solid shape): outline of 207 points within 13.99,50.9 19.54,59.06
+USBPWR1 on TOP (solid shape): 20.87,34.61 20.87,33.84 20.76,33.72 20.49,33.72 20.08,34.14 19.54,34.14 19.46,34.22 19.46,34.57 19.56,34.67 20.81,34.67
+USBPWR1 on BOTTOM (solid shape): outline of 433 points within 13.83,33.44 22.58,48.7
+VGA_CORE on TOP (solid shape): outline of 786 points within 89.84,99.88 116.48,110.11
+VGA_CORE on BOTTOM (solid shape): outline of 125 points within 103.66,99.48 116.34,109.38
+VGA_CORE on BOTTOM (solid shape): outline of 302 points within 83.25,91.37 94.93,115.81
+VGA_CORE on SVCC (solid shape): 93.61,109.41 93.69,109.35 93.79,109.33 116.03,109.33 116.27,109.1 116.27,108.4 116.19,108.28 116.17,108.14 116.19,108 116.27,107.88 116.27,107.52 116.15,107.38 116.11,107.21 116.15,107.03 116.27,106.9 116.27,100.51 116.22,100.41 116.2,100.3 116.22,100.19 116.27,100.09 116.27,99.58 116.17,99.46 116.14,99.3 116.17,99.14 116.27,99.02 116.27,92.09 116.08,91.95 116.01,91.73 116.08,91.51 116.27,91.37 116.27,89.12 115.91,88.76 93.94,88.76 93.81,88.85 93.66,88.88 93.51,88.85 93.39,88.76 92.12,88.76 90.28,90.59 90.17,90.86 89.91,90.97 88.96,91.91 88.96,99.27 89.06,99.4 89.09,99.55 89.06,99.71 88.96,99.84 88.96,109.61 89.45,110.09 92.92,110.09
+VGA_CORE on IN3 (solid shape): outline of 2008 points within 100.06,100.11 114.84,110.7
+VREF_CA0 on TOP (solid shape): 51.12,56.2 51.12,54.46 51.89,53.69 51.89,52.53 51.88,52.49 51.84,52.48 51.75,52.48 51.68,52.45 51.65,52.37 51.65,51.98 51.61,51.94 51.58,51.93 51.53,51.94 51.28,51.83 51.18,51.58 51.2,51.47 51.25,51.36 51.25,50.87 51.11,50.73 50.53,50.73 50.35,50.91 50.35,54.17 50.36,54.2 50.64,54.49 50.74,54.85 50.52,55.37 49.97,55.6 49.95,55.64 49.95,56.19 50.06,56.3 51.02,56.3
+VREF_CA1 on TOP (solid shape): 43.87,92.22 43.87,90.87 44.11,90.63 44.11,89.7 44.01,89.59 43.07,89.59 42.92,89.73 42.92,92.2 43,92.27 43.83,92.27
ADOGND on TOP (solid shape): outline of 1057 points within 199.95,19.8 215.45,43.04
ADOGND on SGND (solid shape): outline of 122 points within 199.6,19.8 215.45,43.04
ADOGND on IN1 (solid shape): 215.45,42.81 215.45,37.43 214.97,36.94 214.56,36.94 214.45,36.92 214.36,36.84 212.21,36.84 212.13,36.88 212.11,36.97 212.12,37.02 212.13,37.07 212.05,37.29 211.86,37.42 211.82,37.43 211.82,37.86 211.87,37.94 211.97,37.93 212.06,37.89 212.15,37.88 212.4,37.99 212.51,38.24 212.48,38.37 212.41,38.49 212.38,38.56 212.41,38.63 212.48,38.73 212.51,38.85 212.51,38.9 212.59,38.9 213.02,39.33 213.02,40.88 212.66,41.24 211.56,41.24 211.48,41.32 211.51,41.42 212.5,42.21 213.46,43.03 213.48,43.04 215.22,43.04
ADOGND on IN1 (solid shape): outline of 157 points within 202.91,32.48 210.08,40.32
ADOGND on IN1 (solid shape): outline of 464 points within 199.6,19.8 211.39,34.12
ADOGND on IN2 (solid shape): 205.32,25.47 205.38,25.56 205.49,25.54 205.78,25.26 205.78,24.56 205.01,23.8 205.01,22.91 205.23,22.69 205.87,22.69 206.16,22.4 206.16,21.4 206.08,21.31 206.06,21.2 206.06,20.67 205.19,19.8 204.13,19.8 203.9,20.03 203.9,20.18 203.87,20.29 203.8,20.38 203.8,21.5 203.9,21.6 203.9,21.61 204.05,21.77 204.05,24.31 204.21,24.47 205.1,24.47 205.32,24.69
ADOGND on IN2 (solid shape): outline of 217 points within 199.6,29.22 204.93,36.76
ADOGND on IN2 (solid shape): outline of 338 points within 207.19,30.86 215.45,43.04
ADOGND on SVCC (solid shape): outline of 116 points within 199.6,19.8 215.45,43.04
ADOGND on IN3 (solid shape): 215.45,42.81 215.45,37.43 214.97,36.94 214.56,36.94 214.45,36.92 214.36,36.84 214.02,36.84 213.93,36.9 213.95,37.02 214.25,37.31 214.25,40.39 212.83,41.81 212.29,41.81 212.19,41.88 212.23,41.99 212.85,42.5 213.48,43.04 215.22,43.04
ADOGND on IN3 (solid shape): 204.96,36.02 205.06,35.97 205.17,35.95 205.2,35.95 205.24,35.96 205.32,35.94 205.36,35.86 205.36,34.8 204.2,33.64 204.05,33.64 203.97,33.66 203.9,33.67 203.61,33.55 203.49,33.26 203.49,33.18 203.52,33.11 203.52,32.96 203.41,32.85 202.91,32.85 202.91,33.06 202.98,33.15 203.01,33.26 203.01,33.92 203.9,34.81 203.9,35.76 204.16,36.02
ADOGND on IN3 (solid shape): 208.16,31.28 208.27,31.3 208.33,31.21 208.33,30.53 207.64,29.84 207.64,27.49 207.61,27.41 207.52,27.39 207.49,27.39 207.45,27.39 207.1,27.04 207.45,26.68 207.49,26.68 207.52,26.69 207.61,26.67 207.64,26.59 207.64,26.56 207.61,26.48 207.6,26.4 207.64,26.24 207.75,26.11 207.8,26.03 207.75,25.94 207.68,25.89 207.63,25.82 207.56,25.77 207.47,25.79 207.37,25.85 207.25,25.87 207.06,25.81 206.93,25.67 205.99,25.67 205.78,25.45 205.78,24.56 205.01,23.8 205.01,22.91 205.23,22.69 205.87,22.69 206.16,22.4 206.16,21.4 206.08,21.31 206.06,21.2 206.06,20.67 205.19,19.8 204.13,19.8 203.9,20.03 203.9,20.18 203.87,20.29 203.8,20.38 203.8,21.51 204.05,21.77 204.05,24.31 204.21,24.47 205.1,24.47 205.32,24.69 205.32,25.96 205.7,26.34 205.7,28.75 205.37,29.08 205.37,29.77 205.43,29.82 206.17,30.56 206.27,30.59 206.34,30.51 206.47,30.31 206.69,30.24 206.94,30.34 207.05,30.59 207.04,30.65 207.03,30.71 207.04,30.8 207.12,30.85 207.73,30.85
ADOGND on SGND1 (solid shape): outline of 125 points within 199.6,19.8 215.45,43.04
BAT-V on BOTTOM (solid shape): outline of 466 points within 95.18,15.03 113.97,25.96
BI on BOTTOM (solid shape): 99.24,23.22 99.24,22.64 99.77,22.11 99.77,20.82 99.73,20.77 99.16,20.77 99.04,20.89 99.04,21.93 98.61,22.36 98.61,22.98 98.62,22.99 98.62,23.14 98.76,23.28 99.17,23.28
FAN_PWM on TOP (solid shape): 174.14,20.37 174.14,19.97 173.49,19.31 173.47,19.31 173.3,19.21 173.2,19.03 173.2,19.02 173.04,18.87 169.9,18.87 169.81,18.9 169.73,18.91 169.64,18.9 169.55,18.87 169.3,18.87 169.2,18.91 169.09,18.93 168.99,18.91 168.9,18.87 168.89,18.87 168.76,18.87 168.75,18.87 168.61,18.96 168.46,18.99 168.19,18.88 168.08,18.61 168.08,18.55 168.1,18.49 168.1,16.72 166.63,15.26 164.86,15.26 164.84,15.28 164.84,15.8 164.86,15.84 164.89,15.85 165.57,15.85 165.63,15.86 166.51,15.86 167.72,17.07 167.72,18.87 168.09,19.25 172.29,19.25 172.96,19.92 172.99,19.93 173.01,19.93 173.05,19.93 173.09,19.92 173.36,20.04 173.47,20.31 173.47,20.34 173.46,20.38 173.46,20.41 173.47,20.43 173.61,20.56 173.95,20.56
FAN_PWM_C on BOTTOM (solid shape): 177.61,23.56 177.61,23 177.55,22.94 176.99,22.94 176.5,22.45 175.23,22.45 175.15,22.54 175.15,23.11 175.25,23.21 176.22,23.21 176.71,23.7 177.46,23.7
G5335-LX on BOTTOM (solid shape): 148.95,70.7 148.95,69.45 148.55,69.06 148.55,68.06 148.54,68.08 148.5,68.11 148.45,68.14 148.4,68.16 148.35,68.18 148.3,68.19 148.24,68.19 148.19,68.18 148.14,68.16 148.09,68.14 148.04,68.11 148,68.07 147.96,68.03 147.94,67.99 147.91,67.94 147.9,67.89 147.89,67.83 147.89,67.78 147.9,67.72 147.91,67.67 147.94,67.62 147.96,67.57 148,67.53 148.04,67.5 148.09,67.47 148.14,67.45 148.19,67.43 148.24,67.42 148.3,67.42 148.35,67.43 148.4,67.44 148.45,67.47 148.5,67.49 148.54,67.53 148.55,67.55 148.55,67.11 148.11,66.66 147.32,66.66 147.07,66.41 147.07,65.91 147.06,65.9 144.27,65.9 144.11,66.06 144.11,66.16 143.32,66.16 143.32,66.42 144.11,66.42 144.11,66.66 143.32,66.66 143.32,66.92 146.26,66.92 146.34,67 146.34,67.15 146.84,67.15 146.84,67.94 146.59,67.94 146.59,67.15 146.34,67.15 146.34,68.38 146.74,68.77 146.74,69.24 146.45,69.53 143.99,69.53 142.71,70.8 141.51,70.8 141.42,70.9 141.42,71.58 141.66,71.83 147.82,71.83
G5335-LX-1 on BOTTOM (solid shape): 139.15,45.52 141.29,45.52 141.55,45.26 141.79,45.26 141.85,45.21 141.85,44.34 142.1,44.09 142.6,44.09 142.61,44.08 142.61,41.29 142.45,41.13 142.35,41.13 142.35,40.34 142.09,40.34 142.09,41.13 141.85,41.13 141.85,40.34 141.59,40.34 141.59,43.28 141.51,43.36 140.58,43.36 140.56,43.34 139.17,43.34 138.98,43.15 138.98,42.71 138.73,42.45 138.73,41.05 139.17,40.61 139.17,39.87 139.16,39.86 138.3,39.86 136.93,41.23 136.35,41.23 136.27,41.31 136.27,43.61 141.36,43.61 141.36,43.86 140.58,43.86 140.58,43.61 136.27,43.61 136.27,44.72 137.43,45.88 138.8,45.88
JW5222LX1.5V on TOP (solid shape): 197.04,26.4 197.04,24.93 197.03,24.89 196.99,24.88 196.63,24.5 196.99,24.12 197.03,24.1 197.04,24.07 197.04,23.89 196.94,23.79 194.7,23.79 194.7,23.79 193.89,23.79 193.81,23.86 193.81,25.08 193.98,25.24 194,25.25 194.02,25.26 195.55,25.26 195.77,25.47 195.77,26.66 195.86,26.74 195.89,26.76 195.92,26.78 196.66,26.78
L_SPK+ on TOP (solid shape): 115.96,17.75 115.96,16.11 115.86,16.02 114.79,16.02 114.65,16.16 114.65,17.78 114.76,17.89 115.81,17.89
L_SPK+ on IN2 (solid shape): 115.73,16.46 115.75,16.45 115.75,16.43 115.75,15.92 115.11,15.28 115.11,15.08 115.02,14.85 115.11,14.61 115.11,14.02 114.99,13.91 114.02,13.91 113.89,14.03 113.89,14.63 113.9,14.65 113.92,14.67 114.08,14.97 113.92,15.27 113.9,15.29 113.89,15.32 113.89,16.39 113.92,16.46 113.99,16.5 114.16,16.54 114.29,16.67 114.29,16.68 114.34,16.7 114.97,16.7 114.98,16.71 115.49,16.71
L_SPK+ on IN2 (solid shape): outline of 85 points within 201.88,17.11 204.05,22.67
L_SPK+_1 on TOP (solid shape): 116.03,21.32 116.15,21.28 116.27,21.27 116.36,21.27 116.44,21.29 116.46,21.3 116.48,21.29 116.58,21.2 116.58,20.52 116.38,20.32 116.38,19.59 115.88,19.08 115.88,18.56 115.72,18.4 114.95,18.4 114.83,18.52 114.83,18.94 114.84,19 114.84,19.06 114.84,19.12 114.83,19.18 114.83,20.33 115.82,21.32 116.02,21.32
