# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_RXN3_C: length 12.9
  TOP w0.102: v2(104.79,111.82) 105.25,112.29 105.25,113.75 104.2,114.79 101.92,114.79 101.28,114.16 99.43,114.16 99.13,114.45 96.85,114.45 C8116.2
  BOTTOM w0.102: U2029.AN38 105.4,112.62 104.79,112.01 v2(104.79,111.82)
PEG_RXP0: length 58.8
  TOP w0.102: C8134.1 96.23,110.38 96.09,110.23 95.88,110.23 v2(95.67,110.45)
  IN1 w0.089: v2(95.67,110.45) 95.9,110.22 96.36,110.22 96.6,109.98 96.6,96.27 97.47,95.4 97.47,94.09 98.23,93.33 98.23,91.06 100.85,88.44 100.85,87.4 102.12,86.13 102.12,85.37 103.21,84.28 103.21,83.88 103.82,83.27 103.82,81.81 105.78,79.85 105.78,79.11 106.31,78.58 106.31,75.63 105.78,75.1 105.78,68.84 101.85,64.91 97.24,64.91 97.12,64.78 97.12,64.63 97.22,64.53 v1(97.34,64.53)
  BOTTOM w0.102: v1(97.34,64.53) 97.34,64.38 U2030.P8
PEG_RXP0_C: length 7.8
  TOP w0.102: C8134.2 96.82,110.34 97.38,110.34 97.66,110.62 101.12,110.62 101.99,111.49 102.49,111.49 102.62,111.62 102.62,111.86 v2(102.49,111.98)
  BOTTOM w0.102: v2(102.49,111.98) 102.4,111.89 102.4,111.6 102.58,111.42 U2029.AV35
PEG_RXP1: length 59.1
  TOP w0.102: v2(96,107.91) 95.31,107.91 94.97,108.25 94.97,111.49 95.22,111.75 95.98,111.75 C8127.1
  IN1 w0.089: v1(99.53,65.54) 99.39,65.54 99.3,65.63 99.3,65.82 99.41,65.94 101.48,65.94 102.2,66.66 102.55,66.66 105.11,69.22 105.11,75.57 105.6,76.06 105.6,77.79 103.14,80.25 103.14,82.4 102.48,83.05 102.48,84.05 101.42,85.12 101.42,85.87 100.06,87.24 100.06,88.28 97.34,90.99 97.34,92.57 94.63,95.29 94.63,96.93 94.8,97.11 94.8,97.74 95.86,98.8 95.86,106.63 95.39,107.1 95.39,107.94 95.54,108.09 95.82,108.09 v2(96,107.91)
  BOTTOM w0.102: v1(99.53,65.54) 99.53,65.33 U2030.N6
PEG_RXP1_C: length 9.1
  TOP w0.102: v2(102.63,113.35) 103.04,113.35 103.14,113.25 103.14,113.05 102.82,112.72 101.95,112.72 100.56,111.33 97.54,111.33 97.21,111.66 96.81,111.66 96.68,111.78 C8127.2
  BOTTOM w0.102: v2(102.63,113.35) 103.06,112.92 U2029.AU38
PEG_RXP2: length 60.1
  TOP w0.102: v2(95.59,112.81) 95.83,113.05 95.94,113.05 C8118.1
  IN1 w0.089: v1(98.11,66.53) 97.9,66.53 97.81,66.63 97.81,66.81 97.91,66.92 101.48,66.92 104.44,69.87 104.44,73.02 104.02,73.43 104.02,75.63 104.81,76.41 104.81,77.57 102.02,80.35 102.02,82.45 101.81,82.66 101.81,83.77 100.75,84.84 100.75,85.59 99.38,86.96 99.38,88 96.58,90.8 96.58,92.19 93.91,94.86 93.91,96.07 93.61,96.38 93.61,97.6 94.37,98.36 94.37,99.67 95.18,100.49 95.18,106.29 94.68,106.79 94.68,112.86 94.89,113.07 95.34,113.07 v2(95.59,112.81)
  BOTTOM w0.102: U2030.M8 98.11,66.4 v1(98.11,66.53)
PEG_RXP2_C: length 10.8
  TOP w0.102: C8118.2 96.68,112.96 96.9,113.18 101.7,113.18 102.42,113.91 103.95,113.91 104.18,113.67 104.18,112.93 104.35,112.77 104.35,112.59 104.19,112.44 103.98,112.44 v2(103.77,112.64)
  BOTTOM w0.102: v2(103.77,112.64) 104.07,112.34 104.09,112.34 U2029.AR37
PEG_RXP3: length 62.8
  TOP w0.102: C8110.1 96.23,114.83 96.08,114.68 95.68,114.68 v2(95.31,115.05)
  IN1 w0.089: v1(99.48,67.52) 99.24,67.76 99.24,67.83 99.37,67.95 100.67,67.95 101.84,69.12 102.73,69.12 103.26,69.66 103.26,70.18 103.76,70.69 103.76,72.74 103.31,73.19 103.31,78.08 101.35,80.05 101.35,82.17 101.14,82.38 101.14,83.5 100.07,84.56 100.07,85.31 98.71,86.68 98.71,87.72 95.57,90.87 95.57,92.21 91.83,95.95 91.83,99.34 93.15,100.66 93.15,105.65 93.99,106.49 93.99,115.12 94.42,115.56 95.53,115.56 95.95,115.14 95.95,114.83 95.76,114.64 95.19,114.64 95.07,114.77 95.07,114.95 95.17,115.05 v2(95.31,115.05)
  BOTTOM w0.102: U2030.L6 99.48,67.28 v1(99.48,67.52)
PEG_RXP3_C: length 13.4
  TOP w0.102: C8110.2 96.68,114.82 96.83,114.67 99.22,114.67 99.52,114.37 101.19,114.37 101.83,115.01 104.29,115.01 105.47,113.84 105.47,112.2 105.34,112.07 105.34,111.89 105.49,111.73 105.84,111.73 v2(105.93,111.82)
  BOTTOM w0.102: v2(105.93,111.82) 105.5,111.82 105.4,111.92 U2029.AN37
PEG_TXN0: length 62
  IN1 w0.089: v2(111.31,68.57) 111.1,68.35 108.23,68.35 106.82,69.76 106.82,74.23 107,74.41 107,79.23 106.46,79.77 106.46,80.79 105.29,81.95 105.29,85.93 103.9,87.33 103.9,89.99 102.55,91.33 102.55,92.6 98.58,96.58 98.58,100.1 98.48,100.2 98.48,112.47 99.77,113.76 99.77,114.74 100.97,115.94 102.08,115.94 102.2,116.06 102.98,116.06 v2(103.24,115.81)
  BOTTOM w0.102: C2653.1 110.65,68.48 110.76,68.38 111.12,68.38 v2(111.31,68.57) ; U2029.AT40 103.75,114.24 103.45,114.55 103.45,114.82 103.53,114.9 103.53,115.27 103.7,115.44 103.7,115.75 103.51,115.94 103.36,115.94 v2(103.24,115.81)
PEG_TXN1: length 58.6
  IN1 w0.089: v2(109.03,69.71) 108.82,69.51 108.09,69.51 107.5,70.09 107.5,73.22 108.31,74.03 108.31,75.93 107.74,76.5 107.74,78.83 108.23,79.33 108.23,80.12 107.08,81.27 107.08,85.09 104.66,87.52 104.66,90.24 103.82,91.08 103.82,92.31 99.25,96.88 99.25,100.38 99.15,100.47 99.15,112.19 100.44,113.48 100.44,113.83 101.74,115.12 103.64,115.12 104,115.48 104,115.79 104.13,115.92 104.31,115.92 v2(104.46,115.77)
  BOTTOM w0.102: C2651.1 108.36,69.6 108.49,69.47 108.79,69.47 v2(109.03,69.71) ; v2(104.46,115.77) 104.46,115.61 104,115.15 104,114.9 104.3,114.59 U2029.AR40
PEG_TXN2: length 63.9
  IN1 w0.089: v2(107,116.83) 106.87,116.95 106.49,116.95 105.9,116.36 105.9,115.99 104.35,114.44 102.07,114.44 101.12,113.49 101.12,110.42 99.84,109.14 99.84,100.74 99.92,100.66 99.92,97.25 104.66,92.52 104.66,91.26 105.42,90.49 105.42,87.71 107.76,85.37 107.76,81.55 109.41,79.9 109.41,78.34 110.01,77.74 110.01,74.64 108.22,72.84 108.22,71.57 109.15,70.64 111.1,70.64 v2(111.31,70.85)
  BOTTOM w0.102: v2(111.31,70.85) 111.1,70.63 110.8,70.63 110.65,70.79 C2649.1 ; v2(107,116.83) 106.75,117.07 106.63,117.07 105.6,116.04 105.6,115.71 105.08,115.19 105.08,114.89 105.17,114.8 105.17,114.55 104.85,114.23 U2029.AP40
PEG_TXN3: length 57
  IN1 w0.089: v2(109.41,72) 109.21,71.79 109.03,71.79 108.9,71.92 108.9,72.58 110.74,74.42 110.74,77.97 110.08,78.62 110.08,80.18 108.92,81.34 108.92,85.34 106.11,88.16 106.11,92.06 104.33,93.84 104.33,94.6 100.94,97.99 100.94,109.29 101.79,110.14 101.79,113.14 102.4,113.75 104.72,113.75 106.37,115.4 106.83,115.4 v2(107.01,115.22)
  BOTTOM w0.102: U2029.AM40 105.95,114.23 106.26,114.54 106.26,114.83 106.17,114.92 106.17,115.16 106.44,115.43 106.8,115.43 v2(107.01,115.22) ; v2(109.41,72) 109.17,71.76 108.73,71.76 C2647.1
PEG_TXP0: length 62.3
  IN1 w0.089: v2(111.31,67.93) 111.1,68.15 108.14,68.15 106.61,69.68 106.61,74.31 106.79,74.49 106.79,79.15 106.25,79.69 106.25,80.71 105.09,81.87 105.09,85.85 103.69,87.25 103.69,89.9 102.35,91.25 102.35,92.52 98.37,96.49 98.37,100.02 98.28,100.11 98.28,112.56 99.57,113.84 99.57,114.82 100.88,116.14 101.99,116.14 102.12,116.27 103.05,116.27 103.08,116.29 103.08,116.29 v2(103.24,116.45)
  BOTTOM w0.102: C2652.1 110.65,68.03 110.78,68.16 111.08,68.16 v2(111.31,67.93) ; v2(103.24,116.45) 103.53,116.15 103.6,116.15 103.91,115.84 103.91,115.35 103.75,115.18 103.75,114.68 U2029.AT41
PEG_TXP1: length 59.2
  IN1 w0.089: v2(109.03,69.07) 108.8,69.3 108,69.3 107.3,70.01 107.3,73.31 108.11,74.12 108.11,75.84 107.54,76.42 107.54,78.92 108.03,79.41 108.03,80.03 106.88,81.18 106.88,85.01 104.46,87.44 104.46,90.16 103.62,90.99 103.62,92.22 99.05,96.79 99.05,100.29 98.95,100.39 98.95,112.28 100.24,113.56 100.24,113.91 101.65,115.33 103.56,115.33 103.8,115.56 103.8,115.88 104.04,116.12 104.18,116.12 v2(104.46,116.41)
  BOTTOM w0.102: v2(104.46,116.41) 104.89,115.98 104.89,115.61 U2029.AR41 ; C2650.1 108.67,69.25 108.85,69.25 v2(109.03,69.07)
PEG_TXP2: length 64.5
  IN1 w0.089: v2(107,117.46) 106.69,117.15 106.41,117.15 105.7,116.45 105.7,116.07 104.27,114.64 101.98,114.64 100.91,113.57 100.91,110.5 99.64,109.23 99.64,100.66 99.72,100.57 99.72,97.17 104.46,92.43 104.46,91.17 105.22,90.41 105.22,87.63 107.55,85.29 107.55,81.46 109.21,79.81 109.21,78.26 109.81,77.66 109.81,74.72 108.01,72.93 108.01,71.49 109.07,70.43 111.1,70.43 v2(111.31,70.22)
  BOTTOM w0.102: v2(111.31,70.22) 111.11,70.42 110.75,70.42 110.65,70.32 C2648.1 ; v2(107,117.46) 106.82,117.29 106.54,117.29 105.38,116.13 105.38,115.8 104.86,115.28 104.86,115.13 104.59,114.86 104.59,114.75 104.67,114.67 U2029.AP41
PEG_TXP3: length 57.1
  IN1 w0.089: v2(107.01,115.85) 106.76,115.61 106.28,115.61 104.63,113.96 102.31,113.96 101.59,113.23 101.59,110.22 100.73,109.37 100.73,97.91 104.13,94.52 104.13,93.75 105.9,91.98 105.9,88.07 108.72,85.26 108.72,81.25 109.88,80.09 109.88,78.54 110.54,77.88 110.54,74.5 108.7,72.66 108.7,71.84 108.94,71.59 109.18,71.59 v2(109.41,71.36)
  BOTTOM w0.102: U2029.AM41 105.95,115.25 106.35,115.64 106.8,115.64 v2(107.01,115.85) ; C2646.1 108.68,71.54 109.22,71.54 v2(109.41,71.36)
PEGX_RST#: length 68.3
  TOP w0.102: v2(111.81,123.71) 113.37,122.15 113.37,121.55 111.82,120 111.06,120 110.71,119.65 R77865.2 110.42,119.37 110.07,119.01 110.07,117.23 109.54,116.7 108.96,116.7 107.76,117.89 105.67,117.89 v2(105.49,117.72) 104.65,116.88 102.98,116.88 102.22,116.11 v2(97.6,116.11)
  IN1 w0.089: v2(97.6,116.11) 97.27,116.45 94.04,116.45 91.85,114.26 v2(91.85,112.46)
  IN2 w0.089: v2(91.85,112.46) 93.05,111.26 93.05,100.34 91.82,99.11 91.82,98.09 88.96,95.24 85.62,95.24 82.66,92.27 82.66,90.87 v2(83.27,90.26)
  BOTTOM w0.102: U8023.2 112.8,124.7 v2(111.81,123.71) 111.34,123.71 111.22,123.59 R8123.1 ; v2(105.49,117.72) 105.49,117.74 105.6,117.85 105.6,118.23 105.5,118.32 105.5,119.08 105.62,119.21 R8533.1 ; R8133.2 82.94,89.92 v2(83.27,90.26) 83.61,89.92 U8001.4
PEGX_RST#_R: length 7.5
  BOTTOM w0.102: R8533.2 105.85,118.6 106.13,118.32 106.13,117.78 105.61,117.26 102.86,117.26 102.41,116.81 102.41,115.48 102.65,115.24 U2029.AV41
PGANG: length 2.8
  BOTTOM w0.102: U2033.23 100.89,86.84 R559.2 v2(102.04,87.1)
PIRQA#: length 44.2
  TOP w0.102: R400.1 121.14,22.85 120.66,23.33 R2428.1 120.5,23.48 119.91,24.08 115.86,24.08 115.52,23.74 113.6,23.74 v2(113.09,24.24)
  IN2 w0.089: v1(92.01,38.24) 94.83,41.06 101.56,41.06 104.11,38.52 104.11,38.07 105.61,36.56 105.72,36.56 109.4,32.88 v1(109.62,32.88)
  IN3 w0.089: v2(113.09,24.24) 113.09,24.86 112.18,25.77 112.18,29.43 109.73,31.88 109.73,32.77 v1(109.62,32.88)
  BOTTOM w0.089: 91.64,39.23 91.62,39.25 91.62,40.6 U2030.BD15
  BOTTOM w0.102: 91.64,39.23 92.01,38.86 v1(92.01,38.24)
PLLCHARZ_H: length 8.4
  TOP w0.102: TP8011.1 100.39,99.94 101.97,101.51 103.39,101.51 v2(103.97,100.93)
  BOTTOM w0.102: v2(103.97,100.93) 103.6,100.56 U2029.AU15
PLLCHARZ_L: length 8.1
  TOP w0.102: TP8009.1 97.85,99.43 100.21,99.43 102.06,101.28 102.91,101.28 v2(103.26,100.93)
  BOTTOM w0.102: U2029.AV15 102.8,100.47 v2(103.26,100.93)
PLTRST#_EC: length 5.5
  TOP w0.102: U13.22 164.46,19.76 v2(164.41,19.71)
  BOTTOM w0.102: R441.2 163.51,21.2 163.74,20.97 R77864.2 R6572.1 164.37,19.67 v2(164.41,19.71) 164.69,19.71 165.15,20.17 C437.1
PMON: length 4.2
  TOP w0.203: v2(138.52,32.4) 138.5,32.4 138.48,32.38 138.44,32.38 138.1,32.05 PC77.2 ; PR76.1 137.72,31.09 138.06,31.42 TP68.1
  TOP w0.254: PR76.1 PC77.2
  BOTTOM w0.198: v2(138.52,32.4) 138.5,32.42 138.5,32.62 137.99,33.14 PR251.2
PP: length 1.3
  TOP w0.102: U15.4 129,20.21 129.09,20.31 R423.2
PRE: length 2
  BOTTOM w0.102: R2709.1 20.38,74.15 20.25,74.28 19.95,74.28 19.82,74.41 19.82,74.99 19.85,75.02 U26.15
PROCHOT_EC: length 20.3
  TOP w0.102: Q20.2 150.67,15.72 151.01,16.06 158.81,16.06 159.07,16.32 159.07,19.38 159.52,19.83 159.52,20.43 160.38,21.29 R6563.1 R440.2 162.65,21.29 162.87,21.08 C440.2 163.77,21.08 164.15,21.45 164.4,21.45 164.71,21.76 U13.17
PS_0: length 17.8
  BOTTOM w0.102: U2029.AM29 105.74,108.12 105.3,107.68 102.8,107.68 102.68,107.56 102.16,107.56 101.88,107.27 101.58,107.27 101.53,107.33 101.28,107.33 101.01,107.05 101.01,106.85 99.12,104.97 99.12,102.16 98.04,101.08 96.45,101.08 96.32,101.21 R77818.1 C28052.1 R77817.2 95.57,103.62 v2(95.44,103.49)
PS_1: length 10.2
  BOTTOM w0.102: v2(95.44,104.76) 95.57,104.63 R77819.2 R77820.1 C28053.1 97.19,107.53 100.54,107.53 100.91,107.9 101.19,107.9 101.31,107.78 101.51,107.78 101.64,107.91 101.87,107.91 101.97,107.81 102.49,107.81 U2029.AV29
PS_2: length 13.7
  BOTTOM w0.102: U2029.AU31 102.99,109.84 102.11,109.84 101.88,110.08 101.63,110.08 101.56,110 101.25,110 101.16,110.1 100.9,110.1 100.78,109.97 100.26,109.97 98.21,112.03 98.21,114.2 97.36,115.05 96.45,115.05 96.32,114.91 R77821.1 96.34,114.51 C28054.1 96.36,113.51 R77822.2
PS_3: length 9.6
  BOTTOM w0.102: U2029.AV31 102.48,109.55 101.96,109.55 101.88,109.47 101.63,109.47 101.52,109.58 101.28,109.58 101.12,109.41 100.94,109.41 100.83,109.53 99.57,109.53 98.74,108.7 96.71,108.7 96.37,109.04 R77826.1 C28055.1 R77825.2
PSELF: length 2.3
  BOTTOM w0.305: U2033.22 99.98,87.34 100.13,87.49 R556.1
PTP_PWR_EN#: length 3
  TOP w0.102: U13.125 168.42,30.8 168.45,30.83 168.45,32.08 TP35.1
PWRLED#: length 77
  TOP w0.102: v2(167.98,20.45) 167.95,20.48 167.87,20.48 166.34,18.96 U13.24
  IN1 w0.089: v2(167.98,20.45) 168.03,20.4 168.03,20.32 169.05,19.3 171.68,19.3 172.03,19.65 174.08,19.65 177.07,16.67 185.63,16.67 186.65,17.69 191.27,17.69 193.31,15.66 193.31,13.3 194.41,12.19 199.69,12.19 200.15,11.73 206.9,11.73 209.94,14.78 211.2,14.78 212.66,16.24 212.66,17.89 213.42,18.66 213.42,23.61 215.96,26.15 215.96,32.07 v2(216.27,32.37)
  BOTTOM w0.102: CN6.19 214.74,33.9 v2(216.27,32.37)
PX_EN: length 6.8
  BOTTOM w0.102: R2620.1 112.15,121.27 111.57,120.69 TP8068.1 110.98,119.79 110.98,115.1 U2029.AC41
R_SPK+: length 83.2
  IN2 w1.016: 196.4,19.63 194.54,17.77 190.31,17.77 189.98,17.44 186.5,17.44 184.98,15.91 183.54,15.91 181.66,14.03 176.97,14.03 176.76,13.82 171.58,13.82 171.32,13.55 166.71,13.55 166.03,14.24 165.98,14.24 165.9,14.31 148.75,14.31 147.58,15.48 146.01,15.48 143.91,17.58 123.07,17.58 122.61,17.12 120.59,17.12
  BOTTOM w0.203: U30.45 202.13,22.96 201.63,22.46 201.61,22.41 201.61,22.08 200.72,21.2 v3(200.65,21.2)
  vias: v2(118.93,16.75) v2(119.58,16.75)
R_SPK+_1:
  vias: v2(119.42,19.66) v2(120.05,19.66)
R_SPK-: length 91.7
  IN2 w1.016: 118.38,18.44 122.05,18.44 122.51,18.9 144.46,18.9 146.48,16.88 148.05,16.88 149.29,15.63 166.53,15.63 167.3,14.87 170.77,14.87 171.04,15.14 176.21,15.14 176.43,15.35 180.34,15.35 180.34,15.36 184.18,19.19 193.74,19.19 194.63,20.08 194.63,22.21 196.03,23.61 197.92,23.61 198.41,23.13 199.17,23.13 199.78,23.74 201.36,23.74
  BOTTOM w0.203: v3(202.12,22.21) 202.12,22.47 202.54,22.88 U30.44
  vias: v2(117.65,16.75) v2(118.29,16.75)
R_SPK-_1:
  vias: v2(118.04,19.66) v2(118.4,20.2) v2(118.68,19.66)
RAM_ID0: length 10.4
  TOP w0.102: v1(97.92,44.56) 97.92,44.56 98.34,44.13 99.19,44.13 99.29,44.23 99.82,44.23 100.17,43.88 101.34,43.88 101.72,43.5 104.7,43.5 105.57,42.63 R730.1 105.85,42.15 105.88,42.12 R763.2
  BOTTOM w0.102: v1(97.92,44.56) 97.51,44.15 U2030.AV8
RAM_ID1: length 13.8
  TOP w0.102: R392.2 R385.1 106.71,42.81 106.4,42.51 106.01,42.51 103.83,44.69 101.97,44.69 100.68,45.98 99.78,45.98 99.38,45.58 99.38,45.27 99.12,45.02 97.65,45.02 97.22,45.45 v1(97.12,45.45)
  BOTTOM w0.102: v1(97.12,45.45) 97.12,45.41 U2030.AU10
RAM_ID2: length 12.8
  TOP w0.102: v1(98.94,45.5) 99.65,46.21 100.78,46.21 102.04,44.94 103.9,44.94 104.79,44.06 v2(107.51,44.06) 108.13,43.44 108.13,42.94 108,42.81 R732.1 R731.2
  BOTTOM w0.102: U2030.AU6 98.94,45.28 v1(98.94,45.5)
RAM_ID3: length 10
  TOP w0.102: v1(93.99,42.99) 93.99,42.99 93.53,42.53 93.53,40.3 95.16,38.67 95.16,38.49 96.1,37.55 97.47,37.55 97.73,37.3 R376.1 98.15,37.3 98.28,37.42 R389.2
  BOTTOM w0.102: U2030.AW13 93.83,42.99 v1(93.99,42.99)
RASA0B: length 24.8
  TOP w0.102: 123.68,101.89 123.15,102.42 122.75,102.42 122.1,103.07 v2(121.53,103.07)
  TOP w0.127: v2(141.58,107.78) 140.42,106.63 140.42,105.78 140.3,105.65 139.79,105.65 136.03,101.89 123.68,101.89
  BOTTOM w0.102: v2(121.53,103.07) 121.2,103.4 U2029.D21
  BOTTOM w0.127: VRAM2001.G3 v2(141.58,107.78)
RASA1B: length 28.7
  TOP w0.102: 122.24,102.5 121.26,102.5 v2(120.89,102.12)
  TOP w0.127: v2(141.58,92.59) 141.26,92.91 141.26,94.49 136.85,98.91 136.85,99.09 137.06,99.31 137.06,99.49 136.88,99.67 136.7,99.67 136.49,99.45 136.31,99.45 136.13,99.63 136.13,99.81 136.34,100.03 136.34,100.21 136.16,100.38 135.98,100.38 135.77,100.17 135.59,100.17 v2(135.01,100.75) 123.99,100.75 122.24,102.5
  BOTTOM w0.102: U2029.D19 120.89,102.31 v2(120.89,102.12)
  BOTTOM w0.127: VRAM2002.L3 v2(141.58,92.59)
REGN6V: length 9.3
  TOP w0.305: v2(131.11,30.78) 131.3,30.97 PC80.1 131.99,31.49 131.84,31.64 v2(131.84,32.24) 131.84,34.8 131.55,35.09 131.55,35.53 131.86,35.85 133.03,35.85 133.6,35.27 PR75.1
  BOTTOM w0.198: PU12.24 v2(131.11,30.78)
REQ_WLAN#: length 3
  BOTTOM w0.102: CN9.53 182.2,18.13 181.8,18.53 R816.1 181.52,19.25 Q18.1
RESET#_USB: length 7.4
  BOTTOM w0.102: U2033.17 96.21,89.01 96.08,89.14 95.91,89.14 95.48,89.57 94.77,89.57 94.1,90.24 93.82,90.24 C2767.1 R6508.2 R6507.1 90.75,90.91 90.58,91.07 R2722.2
RF_EN: length 8.2
  TOP w0.102: v2(189.22,16.57) 188.81,16.17 R828.1 188.02,15.73 187.39,15.1 R487.2
  BOTTOM w0.102: CN9.56 190.03,17.38 189.22,16.57 v2(189.22,16.57)
RING2:
  vias: v2(202.37,30.97) v2(202.88,31.36) v2(209.48,34.53) v2(210.12,34.53) v2(212.15,40.27) v2(212.15,39.64)
ROMCSB: length 1.7
  TOP w0.102: R2669.2 109.15,124.83 109.28,124.7 U2028.1
ROMSCK: length 2.1
  TOP w0.102: U2028.6 116.77,122.16 117,121.93 R2657.2
ROMSI: length 2
  TOP w0.102: U2028.5 117.52,120.89 117.55,120.92 R2656.2
ROMSO: length 1.7
  TOP w0.102: U2028.2 109.41,123.43 109.15,123.18 R2664.2
RREF: length 1.6
  BOTTOM w0.305: R571.2 93.28,83.93 93.68,84.34 U2033.8
RSET: length 5
  TOP w0.102: U1.31 43.64,108.44 43.38,108.7 42.23,108.7 41.97,108.95 41.97,110.48 42.23,110.73 R6.2
RSMRST#: length 102.3
  TOP w0.102: U13.112 173.62,29 173.88,28.73 173.88,27.33 174.81,26.4 v2(175.12,26.4)
  IN2 w0.089: v2(175.12,26.4) 174.83,26.4 173.18,24.76 171.25,24.76 170.45,23.96 168.28,23.96 167.29,24.95 166.56,24.95 165.92,24.31 161.62,24.31 161.11,23.8 155.87,23.8 154.62,25.04 154.34,25.04 153.14,26.25 140.42,26.25 139.86,25.68 131.82,25.68 131.34,26.16 120.61,26.16 120.31,26.46 115.69,26.46 115.27,26.04 110.47,26.04 109.88,25.45 97.99,25.45 96.34,23.8 91.81,23.8 90.82,24.79 87.45,24.79 v2(87,25.23)
  BOTTOM w0.102: v2(87.31,29.96) 87.31,29.7 87.16,29.55 D2026.1 87.16,25.39 v2(87,25.23)
RSMRST#_R: length 23.7
  TOP w0.102: v2(91.65,28.41) 92.57,29.32 93.18,29.32 93.51,29.65 93.51,31.63 93.05,32.09 92.78,32.09 92.54,32.33 92.54,34 91.75,34.79 91.75,37.58 91.5,37.83 91.5,38.78 92.19,39.46 92.19,41.61 91.5,42.29 91.5,44.82 91.14,45.18 v1(90.92,45.18)
  BOTTOM w0.102: v1(90.92,45.18) 90.51,45.59 U2030.AT16 ; D2026.2 89.3,28.23 89.47,28.05 90,28.05 90.11,27.95 C2574.1 R2400.1 91.27,28.21 91.47,28.41 v2(91.65,28.41)
RTC_CLK_APU: length 113.5
  IN2 w0.089: v1(92.01,43.04) 92.52,43.55 92.52,43.67 92.9,44.06 93.18,44.06 93.62,43.61 94.25,43.61 96.23,41.63 101.8,41.63 103.31,40.12 103.71,40.12 106.29,37.54 106.29,36.8 107.65,35.44 109.12,35.44 109.4,35.15 109.4,34.64 113.32,30.72 120.19,30.72 120.81,30.1 130.64,30.1 132.12,28.62 136.58,28.62 137.85,29.89 138.29,29.89 138.55,30.15 152.37,30.15 153.61,28.91 156.16,28.91 156.81,28.26 159.16,28.26 159.35,28.45 164.13,28.45 164.75,29.08 168.46,29.08 168.65,28.88 174.54,28.88 175.13,29.48 181.16,29.48 181.63,29.95 182.44,29.95 182.87,30.38 185.56,30.38 189.29,26.66 192.09,26.66 v2(192.5,27.07)
  BOTTOM w0.102: U2030.AW14 92.28,43.31 v1(92.01,43.04) ; R6640.2 v2(192.5,27.07)
RTC_CLK_APU_C: length 3.8
  BOTTOM w0.102: U2039.2 193.43,26.07 192.95,26.56 R6640.1 193.61,27.67 v2(194.24,28.31)
S0A3_GPIO: length 21.1
  TOP w0.102: R2452.1 114.46,48.98 112.22,51.22 111.75,51.22 110.3,49.77 106.05,49.77 103.07,46.8 100.98,46.8 100.62,46.44 98.98,46.44 98.02,45.47 v1(97.91,45.47)
  BOTTOM w0.102: v1(97.91,45.47) 97.71,45.68 U2030.AR8
S5_ON: length 202.5
  TOP w0.102: v2(41.46,25.77) 41.46,25.56 v2(40.68,24.78) 40.53,24.62 PR566.2 ; R333.1 181.93,31.13 181.77,30.97 179.32,30.97 179.09,30.75 178.62,30.75 178.42,30.54 U13.100 178.42,28.94 177.63,28.15 176.46,28.15 v2(175.83,27.52)
  TOP w0.203: PR100.2 v2(27.82,27.29)
  IN1 w0.089: v2(27.82,27.29) 31.72,27.29 32.78,26.23 38.72,26.23 39.83,25.11 40.97,25.11 41.46,25.61 v2(41.46,25.77)
  IN2 w0.089: v2(175.83,27.52) 175.3,26.99 174.88,26.99 173.38,25.49 169.75,25.49 169.3,25.94 168.29,25.94 167.71,26.52 165.78,26.52 165.39,26.13 159.68,26.13 158.57,25.02 156,25.02 v2(154.78,26.25) 154.65,26.25 153.7,27.2 144.17,27.2 143.21,28.16 140.99,28.16 139.28,26.45 132.4,26.45 131.91,26.94 120.91,26.94 120.62,27.22 115.81,27.22 115.62,27.41 110.6,27.41 109.47,26.28 97.73,26.28 96.03,24.57 92.12,24.57 91.14,25.55 88.72,25.55 88.14,26.12 86.48,26.12 84.91,24.56 77.4,24.56 76.68,23.84 75.54,23.84 75.12,23.42 70.95,23.42 70.82,23.29 60.96,23.29 59.43,24.81 53.95,24.81 52.99,25.77 46.99,25.77 46.8,25.96 41.78,25.96 41.59,25.77 v2(41.46,25.77)
  IN3 w0.089: v2(159.04,34.69) 158.36,34.69 157.85,34.17 153.58,34.17 152.76,34.99 152.76,36.26 151.1,37.92 151.1,39.22 148.81,41.51 148.81,42.54 148.01,43.35 148.01,43.81 147.13,44.69 147.13,45.79 v2(146.84,46.08)
  BOTTOM w0.102: v2(159.04,34.69) 159.04,33.69 158.38,33.02 158.38,32.07 157.64,31.33 PR257.2 158.05,30.72 158.38,30.39 158.38,28.75 158.01,28.38 158.01,27.93 156.33,26.25 v2(154.78,26.25)
  BOTTOM w0.203: v2(146.84,46.08) 146.84,46.32 147.03,46.51 PR2009.1
SATA_RXN0: length 160
  TOP w0.102: C429.2 v2(209.99,21.22)
  IN1 w0.089: v1(98.96,63.53) 99.12,63.36 99.12,63.15 99.37,62.9 100.34,62.9 101.28,61.96 101.28,61.79 102.21,60.86 102.52,60.86 103.24,60.14 104.34,59.04 106.83,59.04 108.64,57.23 108.64,55.94 113.73,50.85 113.73,45.18 113.98,44.93 113.98,41.15 113.02,40.19 113.02,37.77 111.78,36.53 111.78,36.08 110.79,35.08 110.79,33.46 111.12,33.13 111.12,32.66 111.68,32.1 111.68,26.4 113.5,24.58 113.5,23.89 113.78,23.61 115.95,23.61 116.08,23.74 120.97,23.74 121.61,24.38 125.08,24.38 125.49,23.97 130.23,23.97 131.01,24.75 144.53,24.75 145.85,26.07 147.78,26.07 148.95,27.24 154.01,27.24 154.34,27.57 156.41,27.57 156.56,27.42 158.21,27.42 159.01,26.62 164.89,26.62 165.78,27.51 167.74,27.51 168.95,26.29 170.19,26.29 171.25,25.24 173.8,25.24 174.22,24.82 177.09,24.82 177.91,24 182.76,24 183.22,23.53 187.77,23.53 196,15.3 198.93,15.3 199.29,14.93 204.44,14.93 207.93,18.43 209.07,18.43 209.84,19.2 209.84,21.07 v2(209.99,21.22)
  BOTTOM w0.102: U2030.R7 98.96,63.45 v1(98.96,63.53)
SATA_RXN0_CN: length 5.9
  TOP w0.102: C469.1 209.87,11.8 v2(209.99,11.67)
  BOTTOM w0.102: HD1.8 213.54,12.82 213.37,12.99 210.91,12.99 210.23,12.31 209.99,12.31 209.74,12.05 209.74,11.92 v2(209.99,11.67)
SATA_RXN0_IN: length 2.2
  TOP w0.102: C429.1 209.84,20.06 209.84,19.42 209.5,19.08 209.5,18.94 209.75,18.7 U17.4
SATA_RXN1: length 77.1
  IN1 w0.089: v1(96.69,63.51) 96.9,63.71 96.9,63.91 97.12,64.13 100.45,64.13 102.27,62.31 102.27,62.11 102.58,61.81 102.9,61.81 104.74,59.97 107.21,59.97 109.57,57.61 109.57,56.32 114.66,51.23 114.66,45.56 114.91,45.31 114.91,40.77 114.49,40.34 114.49,37.58 113.88,36.97 113.57,36.97 112.71,36.11 112.71,35.7 112.04,35.03 112.04,33.04 112.6,32.48 112.6,27.5 115.09,25.01 115.81,25.01 116.15,24.66 120.55,24.66 121.2,25.31 127,25.31 127.27,25.05 127.27,24.76 v2(127.43,24.6)
  BOTTOM w0.102: C697.2 134.38,20.54 134.38,20.71 133.87,21.22 133.64,21.22 131.89,22.97 128.08,22.97 127.43,23.62 v2(127.43,24.6) ; U2030.R10 v1(96.69,63.51)
SATA_RXN1A_C: length 2.4
  BOTTOM w0.102: C697.1 134.25,19.18 134.25,18.96 134.73,18.48 134.73,18.12 134.85,17.99 CN15.5
SATA_RXN_OUT: length 1.8
  TOP w0.102: U17.12 209.75,13.8 209.62,13.67 209.62,13.03 C469.2
SATA_RXP0: length 160
  TOP w0.102: C428.2 209.23,21.09 v2(209.36,21.22)
  IN1 w0.089: v1(99.54,63.53) 99.35,63.34 99.35,63.24 99.46,63.13 100.44,63.13 101.51,62.06 101.51,61.89 102.31,61.09 102.61,61.09 104.43,59.27 106.92,59.27 108.87,57.32 108.87,56.03 113.96,50.94 113.96,45.27 114.21,45.03 114.21,41.05 113.25,40.09 113.25,37.67 112.01,36.43 112.01,35.98 111.02,34.99 111.02,33.56 111.35,33.23 111.35,32.75 111.9,32.2 111.9,26.5 113.73,24.67 113.73,23.99 113.88,23.84 115.86,23.84 115.98,23.96 120.87,23.96 121.52,24.61 125.17,24.61 125.58,24.2 130.14,24.2 130.91,24.98 144.43,24.98 145.76,26.3 147.69,26.3 148.86,27.47 153.92,27.47 154.25,27.8 156.5,27.8 156.65,27.65 158.3,27.65 159.1,26.85 164.79,26.85 165.68,27.74 167.83,27.74 169.05,26.52 170.29,26.52 171.34,25.47 173.89,25.47 174.31,25.05 177.18,25.05 178.01,24.22 182.85,24.22 183.32,23.76 187.86,23.76 196.09,15.53 199.02,15.53 199.39,15.16 204.34,15.16 207.83,18.66 208.97,18.66 209.61,19.3 209.61,20.59 209.48,20.71 209.14,20.71 209.06,20.79 209.06,20.92 v2(209.36,21.22)
  BOTTOM w0.102: U2030.R6 99.49,63.01 99.62,63.14 99.62,63.45 v1(99.54,63.53)
SATA_RXP0_CN: length 6.3
  TOP w0.102: v2(209.36,11.67) 209.1,11.92 C468.1
  BOTTOM w0.102: HD1.7 213.42,13.32 213.35,13.24 210.81,13.24 210.12,12.56 209.89,12.56 209.48,12.16 209.48,11.8 v2(209.36,11.67)
SATA_RXP0_IN: length 2.3
  TOP w0.102: U17.5 209.25,19.18 209.59,19.52 209.59,19.93 209.3,20.21 C428.1
SATA_RXP1: length 77.1
  IN1 w0.089: v1(97.3,63.51) 97.13,63.69 97.13,63.81 97.21,63.9 100.36,63.9 102.04,62.22 102.04,62.02 102.48,61.58 102.8,61.58 104.65,59.74 107.12,59.74 109.34,57.52 109.34,56.23 114.43,51.14 114.43,45.47 114.69,45.21 114.69,40.86 114.26,40.44 114.26,37.67 113.78,37.2 113.47,37.2 112.48,36.21 112.48,35.79 111.82,35.12 111.82,32.95 112.37,32.39 112.37,27.4 115,24.78 115.72,24.78 116.06,24.43 120.65,24.43 121.29,25.08 126.91,25.08 127.04,24.95 127.04,24.84 v2(126.8,24.6)
  BOTTOM w0.102: v1(97.3,63.51) 97.42,63.39 97.42,63.21 97.12,62.91 97.01,62.91 U2030.R9 ; v2(126.8,24.6) 127.18,24.22 127.18,23.52 127.97,22.72 131.78,22.72 133.53,20.97 133.76,20.97 134.12,20.61 134.12,20.47 133.97,20.31 C696.2
SATA_RXP1A_C: length 2.4
  BOTTOM w0.102: CN15.6 134.35,17.99 134.47,18.12 134.47,18.38 134,18.85 134,19.18 C696.1
SATA_RXP_OUT: length 1.8
  TOP w0.102: U17.11 209.25,13.8 209.37,13.67 209.37,13.05 C468.2
SATA_TXN0: length 157
  TOP w0.102: C430.2 210.75,21.19 v2(210.76,21.2)
  IN1 w0.089: v1(105.42,62.22) 105.57,62.06 105.57,61.73 106.13,61.17 108.03,61.17 112.86,56.34 112.86,55.61 116.16,52.32 116.16,45.31 116.42,45.05 116.42,40.14 116.08,39.81 116.08,37.34 115,36.25 115,35.77 113.73,34.5 113.73,33.19 113.88,33.04 113.88,28.34 115.9,26.32 119.74,26.32 119.9,26.48 130.52,26.48 131.16,25.84 144.52,25.84 145.46,26.78 147.45,26.78 148.65,27.98 153.6,27.98 153.93,28.31 156.81,28.31 156.98,28.13 158.54,28.13 159.35,27.32 164.58,27.32 165.57,28.31 166.94,28.31 167.4,28.76 170.38,28.76 170.72,28.42 170.72,27.82 172.33,26.21 173.89,26.21 174.58,25.52 182.36,25.52 183,24.88 186.05,24.88 186.7,24.23 188.06,24.23 195.11,17.18 197.43,17.18 198.24,16.37 198.85,16.37 199.58,15.63 203.23,15.63 205.62,18.02 206.46,18.02 208.06,19.62 208.06,20.85 209.45,22.23 210.67,22.23 210.91,21.99 210.91,21.35 v2(210.76,21.2)
  BOTTOM w0.089: 102.52,61.37 102.5,61.37 102.46,61.33 101.79,61.33 101.63,61.27 101.53,61.17 U2030.V3
  BOTTOM w0.102: v1(105.42,62.22) 105.42,61.64 105.02,61.23 103.77,61.23 103.63,61.37 102.52,61.37
SATA_TXN0_CN: length 4.9
  TOP w0.102: C470.1 v2(210.63,11.67)
  BOTTOM w0.102: v2(210.63,11.67) 210.88,11.92 210.88,12.16 211.23,12.51 212.33,12.51 213.12,11.71 213.3,11.71 213.41,11.82 HD1.10
SATA_TXN0_IN: length 2.2
  TOP w0.102: C430.1 211.01,19.95 211.01,19.65 210.88,19.52 210.88,19.08 210.75,18.94 U17.2
SATA_TXN1: length 76.3
  IN1 w0.089: v2(129.34,24.6) 129.25,24.69 129.25,25.64 128.88,26.01 120.75,26.01 120.1,25.36 116.44,25.36 116.1,25.7 115.38,25.7 113.3,27.79 113.3,32.77 112.74,33.33 112.74,34.69 115.25,37.2 115.25,40.12 115.61,40.48 115.61,45.6 115.36,45.85 115.36,51.52 110.27,56.61 110.27,57.93 107.53,60.67 105.88,60.67 104.96,61.58 104.96,62.81 104.44,63.33 103.7,63.33 103.44,63.07 v1(103.44,62.22)
  BOTTOM w0.089: 102.52,61.84 102.5,61.84 102.47,61.8 102.03,61.8 101.94,61.71 101.74,61.71 101.54,61.78 101.46,61.81 101.37,61.81 101.25,61.77 101.18,61.7 U2030.U4
  BOTTOM w0.102: v1(103.44,62.22) 103.06,61.84 102.52,61.84 ; v2(129.34,24.6) 129.16,24.43 129.16,23.95 129.38,23.74 132.27,23.74 134.05,21.96 135.68,21.96 136.66,20.97 136.66,20.49 C694.2
SATA_TXN1A_C: length 2.3
  BOTTOM w0.102: CN15.2 136.35,17.99 136.23,18.12 136.23,18.3 136.49,18.55 136.49,19.18 C694.1
SATA_TXN_OUT: length 1.8
  TOP w0.102: C470.2 210.87,13.03 210.87,13.67 210.75,13.8 U17.14
SATA_TXP0: length 156.9
  TOP w0.102: C431.2 211.52,21.07 v2(211.39,21.2)
  IN1 w0.089: v1(106.01,62.22) 105.8,62.01 105.8,61.83 106.23,61.4 108.13,61.4 113.09,56.44 113.09,55.71 116.39,52.41 116.39,45.4 116.65,45.14 116.65,40.05 116.31,39.71 116.31,37.24 115.23,36.16 115.23,35.67 113.96,34.4 113.96,33.29 114.11,33.13 114.11,28.43 115.99,26.55 119.65,26.55 119.8,26.71 130.62,26.71 131.25,26.07 144.43,26.07 145.37,27.01 147.36,27.01 148.55,28.21 153.5,28.21 153.83,28.54 156.9,28.54 157.08,28.36 158.63,28.36 159.45,27.55 164.48,27.55 165.47,28.54 166.85,28.54 167.3,28.99 170.47,28.99 170.95,28.51 170.95,27.91 172.43,26.44 173.98,26.44 174.67,25.75 182.45,25.75 183.09,25.11 186.14,25.11 186.79,24.46 188.15,24.46 195.2,17.41 197.52,17.41 198.33,16.6 198.94,16.6 199.68,15.86 203.13,15.86 205.52,18.25 206.37,18.25 207.83,19.71 207.83,20.94 209.35,22.46 210.76,22.46 211.14,22.08 211.14,21.32 211.26,21.2 v2(211.39,21.2)
  BOTTOM w0.089: 102.52,61.11 102.5,61.11 102.48,61.14 101.94,61.14 U2030.V1
  BOTTOM w0.102: 102.52,61.11 103.53,61.11 103.66,60.98 105.12,60.98 105.68,61.53 105.68,61.89 v1(106.01,62.22)
SATA_TXP0_CN: length 4.5
  TOP w0.102: C471.1 v2(211.39,11.67)
  BOTTOM w0.102: HD1.11 213.41,11.32 213.27,11.46 213.02,11.46 212.22,12.25 211.34,12.25 211.14,12.05 211.14,11.92 v2(211.39,11.67)
SATA_TXP0_IN: length 2.1
  TOP w0.102: U17.1 211.25,18.94 211.14,19.05 211.14,19.42 211.26,19.54 211.26,19.95 C431.1
SATA_TXP1: length 76.3
  IN1 w0.089: v2(128.7,24.6) 129.02,24.92 129.02,25.55 128.79,25.78 120.84,25.78 120.2,25.13 116.35,25.13 116.01,25.47 115.29,25.47 113.07,27.69 113.07,32.68 112.51,33.24 112.51,34.78 115.02,37.29 115.02,40.21 115.38,40.57 115.38,45.5 115.13,45.76 115.13,51.42 110.04,56.52 110.04,57.84 107.43,60.44 105.78,60.44 104.74,61.49 104.74,62.71 104.34,63.11 103.8,63.11 103.67,62.98 103.67,62.71 103.76,62.62 104.05,62.62 104.18,62.5 104.18,62.37 v1(104.02,62.22)
  BOTTOM w0.089: 102.52,61.58 102.5,61.58 102.47,61.61 102.11,61.61 102.01,61.52 101.42,61.52 U2030.U2
  BOTTOM w0.102: v2(128.7,24.6) 128.91,24.39 128.91,23.84 129.27,23.48 132.16,23.48 133.94,21.7 135.57,21.7 136.41,20.86 136.41,20.44 136.28,20.31 C693.2 ; v1(104.02,62.22) 103.62,61.81 103.41,61.81 103.19,61.58 102.52,61.58
SATA_TXP1A_C: length 2.3
  BOTTOM w0.102: CN15.3 135.85,18 135.97,18.12 135.97,18.4 136.23,18.66 136.23,19.18 C693.1
SATA_TXP_OUT: length 1.8
  TOP w0.102: U17.15 211.25,13.8 211.12,13.67 211.12,13.05 C471.2
SCL: length 19.2
  TOP w0.102: R2227.2 118.4,125.31 118.22,125.13 118.22,123.31 118.38,123.15 118.88,123.15 119.11,122.92 119.11,121.19 118.86,120.94 118.86,120.71 117.46,119.32 116.22,119.32 v2(116.14,119.24) 116.14,118.93 111.87,114.67 111.87,112.1 v2(111.47,111.7)
  BOTTOM w0.102: v2(111.47,111.7) 111.09,111.32 U2029.AC35
SDA: length 17.5
  TOP w0.102: v2(111.49,110.93) 112.1,111.54 112.1,114.57 116.62,119.09 117.55,119.09 119.09,120.62 119.09,120.85 119.34,121.1 119.34,123.02 118.93,123.43 R2217.2
  BOTTOM w0.102: v2(111.49,110.93) 111.08,110.52 U2029.AC34
SEN_A0: length 3.9
  TOP w0.102: v2(142.48,111.26) 142.61,111.38 R2240.1
  BOTTOM w0.102: VRAM2001.J10 140.58,112.78 140.58,112.17 141.49,111.26 v2(142.48,111.26)
SEN_A1: length 4.3
  TOP w0.102: v2(142.71,87.55) 142.84,87.42 R2253.1
  BOTTOM w0.102: VRAM2002.J10 140.38,87.56 140.7,87.88 142.38,87.88 v2(142.71,87.55)
SENSEA:
  vias: v2(200.57,32.02)
SERIRQ: length 77.9
  TOP w0.102: v2(148.54,18.9) v2(149.17,19.53) 149.67,20.03 149.67,21.02 150.37,21.73 154.39,21.73 154.63,21.97 154.9,21.97 155.98,23.05 157.64,23.05 160.52,25.92 R6570.2
  IN3 w0.102: v1(108.01,29.07) 107.3,28.36 107.3,24.13 112.84,18.59 133.06,18.59 134.79,20.33 143.8,20.33 144.31,19.82 147.63,19.82 v2(148.54,18.9)
  BOTTOM w0.102: R6559.2 97.73,30.85 98.49,30.09 100.33,30.09 100.94,29.48 103.72,29.48 104,29.2 107.88,29.2 v1(108.01,29.07)
SERIRQ_R: length 70.7
  TOP w0.102: R77859.2 108.27,16.12 v2(108.01,16.37) ; U13.5 164,26.56 163.66,26.9 162.62,26.9 162.1,26.37 R6570.1 160.5,26.37 157.51,23.38 155.84,23.38 154.76,22.3 154.49,22.3 154.25,22.06 150.24,22.06 149.29,21.11 149.29,20.48 147.39,18.58 v2(147.39,16.75) 147.39,14.84 147.76,14.46 v2(147.76,13.96)
  IN1 w0.102: v2(108.01,16.37) 114.43,16.37 114.69,16.62 114.71,16.65 115.87,16.65 116.23,16.29 138.1,16.29 139.55,17.73 142.16,17.73 142.8,17.1 142.8,16.43 143.25,15.98 146.25,15.98 147.76,14.46 v2(147.76,13.96)
SI_SS_SEL: length 3.6
  BOTTOM w0.102: U8021.5 104.58,120.51 104.46,120.64 103.92,120.64 103.19,119.9 R2651.2 R2650.1
SI_VDD: length 1.1
  BOTTOM w0.203: FB104.1 103.74,120.92 103.96,121.14 U8021.1
SI_XTALIN: length 7.8
  TOP w0.102: v1(103.85,121.83) 103.85,122.65 104.35,123.15 R77830.1
  BOTTOM w0.102: U8021.2 104.58,121.53 104.28,121.83 v1(103.85,121.83) 104.23,122.21 R2648.2 C2656.1 103.88,122.85 103.88,124.34 Y2004.1
SI_XTALOUT: length 6.4
  TOP w0.102: v1(105.08,121.79) 105.25,121.95 R77829.2
  BOTTOM w0.102: U8021.3 104.98,121.68 v1(105.08,121.79) 104.61,121.79 104.51,121.89 104.51,122.08 104.68,122.25 R2648.1 C2657.1 105.46,122.72 105.34,122.85 104.41,122.85 104.29,122.97 104.29,123.52 104.42,123.65 Y2004.3
SIO_EXT_SCI#: length 103.4
  TOP w0.102: R77882.1 97.07,36.49 96.45,36.49 96.05,36.89 96.05,37.15 94.88,38.31 94.88,38.59 93.01,40.46 v1(93.01,42.41) ; v2(168.85,27.29) 168.85,26.06 168.49,25.71 168.49,25.25 168.29,25.05 168.29,21.53 167.17,20.41 167.17,20.11 166.42,19.36 U13.23
  IN2 w0.089: v2(168.85,27.29) 168.85,28 168.24,28.61 167.8,28.61 167.46,28.27 165.5,28.27 164.7,27.46 156.92,27.46 155.85,28.53 153.45,28.53 152.73,29.25 148.34,29.25 147.82,29.77 138.71,29.77 138.12,29.18 137.69,29.18 136.69,28.18 132.01,28.18 131.68,28.51 121.6,28.51 119.78,30.34 113.16,30.34 109.74,33.77 108.78,33.77 105.8,36.75 105.69,36.75 104.73,37.72 104.3,38.15 104.3,38.59 101.64,41.25 94.17,41.25 v1(93.01,42.41)
  BOTTOM w0.102: U2030.BA13 v1(93.01,42.41)
SL_CLK_100M: length 1.1
  BOTTOM w0.102: R2652.2 104.81,119.59 104.98,119.77 U8021.4
SLEEVE: length 12.6
  IN3 w1.016: 204.53,30.72 205.93,32.12 207.2,32.12 207.83,32.75 207.83,34.15 209.99,36.31 209.99,37.3 210.91,38.21 211.01,38.21 ; 204.4,30.59 203.9,30.09
  BOTTOM w0.203: U30.18 v2(202.94,30.67)
  vias: v2(209.48,33.9) v2(210.12,33.9) v2(212.15,38.87) v2(212.15,38.24)
SMB_ALW_CLK: length 64.8
  TOP w0.102: R450.2 R2453.1 72.17,14.44 71.84,14.11 69.94,14.11 68.56,15.49 68.56,16.89 68.46,16.99 68.46,18.67 69.18,19.38 69.18,20.91 69.94,21.67 v2(69.94,23.07) 73.39,26.52 73.39,28.64 v2(72.71,29.32)
  IN2 w0.089: v2(72.71,29.32) 73.3,29.91 74.22,29.91 76.09,28.04 80.58,28.04 82.08,29.54 82.08,31.22 82.96,32.1 83.92,32.1 85.21,33.39 87.46,33.39 89.82,35.75 89.82,40.63 90.1,40.9 90.1,45.43 90.23,45.57 90.23,46.72 90.71,47.2 91.1,47.2 91.76,47.87 93.15,47.87 93.45,48.16 93.45,48.58 93.84,48.97 96.84,48.97 v1(97.3,48.51)
  BOTTOM w0.102: U2030.AM9 96.91,48.9 v1(97.3,48.51)
SMB_ALW_DAT: length 62.2
  TOP w0.102: R437.2 R2454.1 71.15,14.56 70.93,14.34 70.04,14.34 68.79,15.59 68.79,16.98 68.69,17.08 68.69,18.58 69.4,19.29 69.4,20.69 v2(70.86,22.15) 70.86,23.67 73.62,26.43 73.62,28.73 73.34,29.01 v2(73.34,29.32)
  IN2 w0.089: v2(73.34,29.32) 73.74,29.72 74.14,29.72 76.02,27.85 80.66,27.85 82.27,29.46 82.27,31.14 83.04,31.91 84,31.91 85.29,33.2 87.54,33.2 90.01,35.68 90.01,40.55 90.29,40.82 90.29,45.35 90.42,45.49 90.42,46.21 90.63,46.42 93.15,46.42 93.64,46.9 93.64,48.5 93.91,48.78 96.42,48.78 v1(96.69,48.51)
  BOTTOM w0.102: v1(96.69,48.51) 96.61,48.51 U2030.AM10
SMB_RUN_CLK: length 83.3
  TOP w0.102: R484.1 v2(60.01,15.32) 59.42,15.32 58.84,15.91 58.84,18.4 59.11,18.67 59.11,21.27 58.71,21.67 58.71,23.89 60.21,25.39 60.21,29.32 58.74,30.79 58.74,32.12 58.49,32.37 57.59,32.37 57.47,32.5 57.47,33.12 57.59,33.24 58.76,33.24 58.86,33.35 58.86,33.75 58.76,33.85 57.59,33.85 57.47,33.98 57.47,34.53 57.59,34.66 59.75,34.66 59.88,34.53 v2(59.88,30.59)
  IN2 w0.089: v2(59.88,30.59) 60.57,30.59 61.2,29.96 70.66,29.96 71,30.29 74.38,30.29 76.25,28.42 80.42,28.42 81.7,29.69 81.7,31.69 81.79,31.78 82.1,31.78 82.19,31.87 82.19,32.16 82.1,32.25 81.79,32.25 81.7,32.34 81.7,32.6 82.03,32.93 82.15,32.93 82.52,32.56 82.7,32.56 82.88,32.74 82.88,32.86 82.48,33.26 82.48,33.39 82.89,33.79 83.48,33.79 83.63,33.64 83.63,33.26 83.75,33.13 84.49,33.13 85.51,34.15 85.99,34.15 v1(86.24,33.9)
  BOTTOM w0.102: U2030.BC20 88.08,41.04 88.08,40.06 88.94,39.21 88.94,36.06 88.47,35.6 87.36,35.6 87.16,35.39 86.02,35.39 85.66,35.04 R2463.1 85.12,34.81 85.79,34.15 85.99,34.15 v1(86.24,33.9) ; CN2019.253 59.39,31.21 59.88,30.72 v2(59.88,30.59)
SMB_RUN_DAT: length 84.8
  TOP w0.102: R475.1 67.18,14.65 66.86,14.34 61.4,14.34 v2(61.28,14.46) 59.96,14.46 58.61,15.82 58.61,18.5 58.88,18.77 58.88,21.18 58.48,21.58 58.48,23.99 59.98,25.49 59.98,29.22 58.99,30.21 53.15,30.21 v2(52.51,30.85)
  IN2 w0.089: v2(83.12,33.39) 83.12,32.53 81.89,31.29 81.89,29.62 80.5,28.23 76.17,28.23 74.3,30.1 71.07,30.1 70.74,29.77 60.96,29.77 60.53,30.19 56.28,30.19 55.63,30.85 v2(52.51,30.85)
  BOTTOM w0.102: U2030.BA20 88.01,41.57 87.68,41.23 87.68,41 87.84,40.83 87.84,39.96 88.71,39.1 88.71,36.15 88.38,35.82 87.21,35.82 87.01,35.62 85.92,35.62 85.82,35.52 R2464.1 83.25,35.52 83.12,35.39 v2(83.12,33.39) ; CN2019.254 51.19,30.96 51.71,30.44 52.11,30.44 v2(52.51,30.85)
SMU_ZVDDP: length 5.2
  TOP w0.381: v1(100.09,59.52) 100.25,59.68 v2(102.42,59.68) 103.06,59.68 103.43,59.3 R2509.1
  BOTTOM w0.254: U2030.V4 100.55,60.45 100.55,60.06 100.09,59.6 v1(100.09,59.52)
SPI_ROM_GNT: length 5
  TOP w0.102: TP9098.1 98.87,41.77 97.75,41.77 v1(97.51,42.01)
  BOTTOM w0.102: v1(97.51,42.01) U2030.BB8
SPI_ROM_REQ: length 8.2
  BOTTOM w0.102: TP9097.1 103.57,36.94 103.01,37.5 102.62,37.5 101.53,38.59 100.9,38.59 99.88,39.61 98.84,39.61 98.18,40.26 98.18,40.94 U2030.BC8
SPI_TPM_CS: length 47
  TOP w0.102: R412.1 R411.1 120.81,21.67 120.25,22.23 120.25,22.8 119.63,23.42 116.15,23.42 115.28,22.54 113.27,22.54 v2(112.19,21.46) v2(110.55,19.82)
  IN1 w0.102: v2(110.55,19.82) 109.71,18.99 106.11,18.99 105.73,19.37 105.73,24.47 105.32,24.88 105.32,30.75 105.09,30.97 105.09,33.82 102.55,36.36 v1(102.55,36.76)
  BOTTOM w0.102: U2030.BD8 97.66,40.56 97.66,40.21 98.77,39.1 99.25,39.1 100.42,37.93 101.25,37.93 102.43,36.76 v1(102.55,36.76) 102.63,36.76 102.78,36.61 102.78,36.09 103.36,35.52 R2427.1
SPI_TPM_CS_TPM: length 1.4
  TOP w0.102: R412.2 122.36,20.94 122.6,20.71 U15.20
SSD_DET#: length 111.6
  TOP w0.102: v1(96.2,38.04) 96.43,38.26 99.3,38.26 R2440.1 ; v2(23.05,8.24) 23.2,8.4 R492.1
  IN2 w0.089: v1(96.2,38.04) 95.6,37.43 93.24,37.43 89.34,33.54 89.34,33.16 88.57,32.38 87.87,32.38 87.62,32.63 85.53,32.63 84.23,31.34 83.28,31.34 82.84,30.9 82.84,29.22 80.89,27.27 62.92,27.27 62.05,28.14 56.5,28.14 55.15,29.49 38.66,29.49 38.3,29.86 37.68,29.86 v2(37.27,30.26)
  IN3 w0.089: v1(96.2,38.04) 96.91,38.75 96.91,41.15 96.4,41.67 96.4,42.67 v1(96.01,43.06) ; v2(23.05,8.24) 23.05,9.64 24.72,11.31 24.72,12.7 24.35,13.08 24.35,13.82 25.05,14.53 27.45,14.53 28.33,13.64 30.09,13.64 32.21,15.76 32.21,23.6 37.53,28.92 37.53,30.01 v2(37.27,30.26)
  BOTTOM w0.102: v1(96.01,43.06) 96.26,43.31 U2030.AW10 ; CN18.69 22.85,8.44 v2(23.05,8.24)
SSD_PCIE_CLKREQ#: length 103.8
  TOP w0.102: v2(47.94,11.04) 47.94,12.1 50.05,14.21 55.03,14.21 v2(57.34,16.52) ; v1(84.26,33.64) 84.26,33.77 81.09,36.95 63.31,36.95 60.95,34.58 60.95,25.06 59.85,23.96 59.85,18.37 59.62,18.15 v2(59.62,16.52)
  IN3 w0.089: v1(88.09,45.26) 88.58,44.77 88.58,42.02 90.02,40.59 90.02,36.15 88.83,34.97 88.83,34.75 86.78,32.7 85.2,32.7 v1(84.26,33.64) ; v2(29.91,3.42) 30.67,4.18 37.27,4.18 38.8,5.7 39.05,5.7 41.78,8.43 44.01,8.43 46.61,11.04 v2(47.94,11.04) ; v2(59.62,16.52) v2(57.34,16.52)
  BOTTOM w0.102: v2(29.91,3.42) 29.14,4.18 27.85,4.18 27.1,3.43 CN18.52 ; v1(88.09,45.26) 88.44,45.61 U2030.AT19 ; R2450.1 84.26,33.99 v1(84.26,33.64)
SUSB#: length 89.6
  TOP w0.102: v2(170.24,27.62) 170.57,27.62 170.82,27.87 U13.119
  IN2 w0.089: v2(170.24,27.62) 169.53,27.62 168.34,28.82 167.73,28.82 167.37,28.46 165.42,28.46 164.62,27.65 157.15,27.65 156.08,28.72 153.53,28.72 152.29,29.96 138.63,29.96 138.37,29.7 137.93,29.7 136.61,28.38 132.09,28.38 130.56,29.91 120.73,29.91 120.11,30.53 113.24,30.53 109.81,33.96 108.86,33.96 105.88,36.94 105.77,36.94 104.49,38.23 104.49,38.67 101.72,41.44 96.15,41.44 94.17,43.42 93.26,43.42 v1(93.03,43.64)
  BOTTOM w0.102: U2030.AV13 93.51,44 93.15,43.64 v1(93.03,43.64)
SUSC#: length 99.8
  TOP w0.102: U13.18 166.42,21.36 166.51,21.27 166.92,21.27 167.19,21.55 167.19,22.08 167.38,22.27 167.64,22.27 168.06,22.69 168.06,25.14 168.26,25.35 168.26,27.67 168.46,27.88 168.46,28.38 168.19,28.65 166.5,28.65 165.9,29.25 v2(165.9,29.67)
  IN2 w0.089: v1(92.97,45.27) 93.23,45.27 94.55,46.6 94.55,46.98 94.8,47.23 96.18,47.23 96.33,47.08 98.2,47.08 98.49,46.79 99.96,46.79 101.99,44.75 103.76,44.75 106.68,41.83 106.68,36.95 107.81,35.82 109.27,35.82 109.78,35.31 109.78,34.8 113.48,31.1 120.34,31.1 120.97,30.48 130.79,30.48 132.28,29 136.42,29 137.7,30.27 138.13,30.27 138.45,30.58 153.41,30.58 154.01,31.18 156.06,31.18 158.05,29.2 164.33,29.2 164.8,29.67 v2(165.9,29.67)
  BOTTOM w0.102: U2030.AT14 92.64,45.61 v1(92.97,45.27)
SUSCLK_32KHZ: length 2.1
  BOTTOM w0.102: CN9.50 191.68,18.88 192.24,19.45 R802.1
SUSCLK_WLAN: length 5.7
  BOTTOM w0.102: U2039.4 193.22,22.72 193.13,22.72 192.79,22.38 192.03,22.38 191.73,22.08 191.73,20.41 192.24,19.9 R802.2
SUSLED#: length 74.5
  TOP w0.102: U13.28 166.44,17.36 166.66,17.58 166.66,18.61 167.84,19.79 169.24,19.79 170.57,21.12 174.16,21.12 177.46,17.82 178.54,17.82 v2(178.96,17.4)
  IN1 w0.089: v2(185.1,17.26) 185.05,17.21 184.03,17.21 183.32,17.92 179.54,17.92 179.02,17.4 v2(178.96,17.4)
  IN3 w0.089: v2(216.88,32.55) 216.88,32.14 216.34,31.61 216.34,29 212.39,25.04 212.39,23.04 213.34,22.08 213.34,19.21 212.96,18.83 211.82,18.83 211.22,18.23 209.09,18.23 207.74,16.88 207.28,16.88 207.1,17.05 206.67,17.05 206.09,16.48 205.32,16.48 204.15,15.31 194.4,15.31 192.48,17.23 185.13,17.23 v2(185.1,17.26)
  BOTTOM w0.102: v2(216.88,32.55) 215.03,34.4 CN6.18
SUSON: length 190.3
  TOP w0.102: v2(170.29,28.27) 170.42,28.39 170.42,28.64 U13.120 170.42,31.31 170.34,31.38 R348.1
  IN1 w0.089: v2(90.36,95.74) 89.68,96.43 76.47,96.43 69.02,103.87 69.02,105.78 67.96,106.84 67.96,116.96 69.24,118.24 70.64,118.24 71.16,118.77 71.16,121.36 70.65,121.87 70.65,124.51 70.09,125.08 68.48,125.08 v2(68.01,125.54)
  IN3 w0.089: v2(170.29,28.27) 170.29,28.54 170.08,28.75 169.23,28.75 168.29,27.81 167.85,27.81 167.39,28.26 164.86,28.26 163.85,29.27 158.87,29.27 158.51,29.63 148.57,29.63 144.64,33.56 144.64,37.19 144.09,37.74 136.08,37.74 135.56,37.22 130.74,37.22 129.62,36.1 125.3,36.1 123.9,37.5 123.51,37.5 120.71,40.3 120.71,41.8 118.3,44.21 118.3,49 115.93,51.37 115.93,53.03 114.46,54.49 114.46,57.79 114.75,58.47 116.37,60.1 116.37,64.57 117.73,65.93 117.73,66.34 117.28,66.79 117.02,66.79 114.63,69.18 114.63,69.6 113.63,70.6 113.63,71.55 112.6,72.58 111.66,72.58 110.56,73.68 109.03,73.68 108.35,74.36 108.35,75.87 105.94,78.29 105.94,79.81 104.23,81.52 103.16,81.52 102.83,81.86 102.23,81.86 101.43,82.66 101.43,84.36 100.43,85.36 99.8,86 99.8,91.36 99.09,92.06 99.09,92.07 98.06,93.1 96.01,93.1 94.74,94.37 93.2,94.37 91.82,95.74 v2(90.36,95.74)
  BOTTOM w0.203: PR126.1 67.82,125.36 v2(68.01,125.54)
SVC_APU: length 9.3
  TOP w0.102: v1(95.31,76.57) 90.58,71.84 90.58,71.39 v1(90.99,70.98)
  BOTTOM w0.102: U2030.F16 90.78,70.98 v1(90.99,70.98) ; v1(95.31,76.57) 95.57,76.57 95.72,76.72 R2515.2
SVD_APU: length 10.4
  TOP w0.102: v1(90.99,69.58) 90.25,70.32 90.25,72.02 94.71,76.47 v1(94.71,76.57)
  BOTTOM w0.102: R2516.2 v1(94.71,76.57) ; U2030.H16 90.88,69.58 v1(90.99,69.58)
SVI2_CLK: length 50.7
  TOP w0.102: R2243.2 94.49,99.43 93.86,98.79 v2(93.66,98.79)
  IN3 w0.089: v2(93.66,98.79) 92.9,99.56 92.9,105.74 94.05,106.89 94.05,110.12 92.43,111.74 82.36,111.74 80.13,113.98 78.55,113.98 77.35,115.18 76.15,115.18 76.01,115.04 73.94,115.04 72.98,115.99 71.96,115.99 70.42,117.54 69.91,117.54 69.45,117.07 v2(69.45,117)
  BOTTOM w0.102: PC9176.2 70.81,122.32 PR9305.2
  BOTTOM w0.107: PR9308.2 69.58,117.91 69.4,118.09 69.4,118.27 69.27,118.27 69.16,118.37 69.16,121.07 69.86,121.76 PC9176.2
  BOTTOM w0.203: PR9036.2 69.44,116.93 69.47,116.95 69.47,116.99 v2(69.45,117)
  BOTTOM w0.254: PR9308.2 69.59,117.48 69.45,117.33 v2(69.45,117)
SVI2_DATA: length 46.6
  TOP w0.102: v2(93.03,98.79) 93.53,99.3 94.04,99.3 94.93,100.19 R2242.2
  IN3 w0.089: v2(93.03,98.79) 92.71,99.11 92.71,105.81 93.86,106.97 93.86,110.04 92.35,111.55 82.28,111.55 80.05,113.78 78.47,113.78 77.27,114.98 76.23,114.98 76.09,114.84 73.86,114.84 72.9,115.8 71.86,115.8 70.57,117.09 v2(70.08,117.09)
  BOTTOM w0.203: PR9038.2 69.99,116.67 69.99,117 v2(70.08,117.09) 70.08,118.4 70.54,118.87 PR9306.2 PC9177.2 70.54,120.02 70.93,120.41 70.94,120.41 71.32,120.79 PR9309.2
SVI2_SVT: length 43.9
  TOP w0.102: v2(92.39,98.8) 93.12,99.53 93.89,99.53 95.31,100.95 R2241.2
  IN3 w0.089: v2(70.5,116.59) 70.78,116.59 71.76,115.61 72.82,115.61 73.78,114.65 76.17,114.65 76.31,114.79 77.19,114.79 78.39,113.59 79.97,113.59 82.2,111.36 92.27,111.36 93.67,109.96 93.67,107.05 92.51,105.89 92.51,98.92 v2(92.39,98.8)
  BOTTOM w0.203: PR9041.2 70.64,116.45 v2(70.5,116.59) 70.57,116.67 70.57,117.31 70.42,117.46 PC9178.2
SVID_EN: length 67.8
  IN1 w0.089: v2(69.28,114.41) 70.56,114.41 72.08,115.94 73.09,115.94 73.42,116.27 73.42,116.65 73.93,117.16 73.93,122.19 75.23,123.49 85.94,123.49 87.52,125.08 91.37,125.08 v2(92.52,123.94)
  IN3 w0.089: v2(119.24,125.46) 118.68,125.46 117.66,124.45 114.23,124.45 113.3,123.51 113.3,123.13 111.64,121.46 111.4,121.46 110.28,120.34 108.32,120.34 107.9,120.76 106.99,120.76 106.75,120.52 103.67,120.52 102.88,119.73 101.22,119.73 101.13,119.82 96.1,119.82 95.64,120.29 95.45,120.29 94.14,121.6 94.14,122.42 93.23,123.33 93.12,123.33 v2(92.52,123.94)
  BOTTOM w0.102: v2(119.24,125.46) 119.11,125.34 R77850.1 118.01,124.91 116.85,124.91 116.4,125.35 U8023.4
  BOTTOM w0.203: PR9034.2 69.43,114.26 v2(69.28,114.41)
SVT_APU: length 11
  TOP w0.102: v1(93.69,76.57) 93.69,75.96 89.92,72.19 89.92,70.02 v1(90.99,68.95)
  BOTTOM w0.102: U2030.J16 90.99,68.89 v1(90.99,68.95) ; R2514.2 v1(93.69,76.57)
SYS_HWPG: length 180.2
  TOP w0.102: D9.1 158.89,13.27 157.8,12.18 146.47,12.18 142.81,15.84 142.28,15.84 141.51,16.6 v2(141.51,16.7) 141.59,16.62 142.25,16.62 142.78,17.16 142.78,17.41 145.98,20.6 145.98,22.8 145.18,23.6 145.18,24.35 142.62,26.91 141.7,26.91 141.41,27.2 v2(141.18,27.2) 140.3,28.09 140.3,31.38 142.07,33.16 PR237.2 ; U13.124 168.82,28.67 168.99,28.5 168.99,28.08 169.53,27.54 169.53,26.1 168.95,25.52 v2(168.95,24.6) ; v2(56.58,19.42) 54.04,16.88 52.51,16.88 50.89,15.25 49.54,15.25 47.81,13.52 v2(47.81,13.4)
  IN1 w0.089: v2(56.58,19.42) 56.98,19.82 67.36,19.82 68.35,20.81 90.86,20.81 92.05,22 94.1,22 94.65,21.45 99.69,21.45 105.61,15.53 114.26,15.53 114.34,15.45 116.06,15.45 116.17,15.56 139.13,15.56 140.24,16.67 141.49,16.67 v2(141.51,16.7)
  IN2 w0.089: v2(168.95,24.6) 168.17,24.6 167.44,25.33 166.4,25.33 165.77,24.69 161.46,24.69 160.95,24.18 156.02,24.18 154.78,25.42 154.5,25.42 153.29,26.63 141.76,26.63 v2(141.18,27.2)
  BOTTOM w0.152: v2(47.81,13.4) 47.65,13.56 PR273.2
SYS_PWRGD: length 21.7
  TOP w0.102: v1(99.55,43.6) 99.73,43.42 101.15,43.42 101.53,43.04 103.36,43.04 104.85,41.55 105.48,41.55 105.9,41.13 106.12,41.13 107.02,40.23 107.02,36.55 107.77,35.8 111.82,35.8 v2(112.96,36.94) D2024.2 113.26,37.79 113.63,37.43 R2407.1
  BOTTOM w0.102: v1(99.55,43.6) 99.55,43.67 U2030.AV6
SYS_PWRGD_R: length 5.8
  TOP w0.102: D2025.3 117.03,37.07 117,37.04 R2390.2 117,36.41 116.77,36.18 116.27,36.18 115.89,36.56 R2406.2 115.64,37.19 115.26,37.57 C2567.1 114.73,37.57 114.59,37.43 R2407.2 114.33,38.24 v2(114.29,38.29)
SYS_RST#: length 31
  TOP w0.102: v1(96.67,47.49) 96.68,47.48 96.68,45.22 96.91,44.99 97.25,44.99 97.51,44.74 97.51,44.39 97.99,43.91 99.29,43.91 99.39,44 99.72,44 100.08,43.65 101.25,43.65 101.63,43.27 103.46,43.27 104.94,41.78 105.58,41.78 105.97,41.39 106.49,41.39 v2(107,40.88) 107.25,40.63 107.25,36.65 107.87,36.03 111.73,36.03 112.43,36.73 112.43,38.57 112.96,39.1 D2024.1 113.51,39.9 113.6,39.99 R2309.2 R2311.1
  BOTTOM w0.102: U2030.AP10 96.19,47.01 v1(96.67,47.49)
SYS_SHDN#: length 239.7
  TOP w0.102: Q14.3 106.91,29.4 107.04,29.53 108.35,29.53 108.49,29.68 109.76,29.68 v1(110.04,29.96) ; v2(186.5,32.24) 184.59,30.34 184.15,30.34 182.33,28.51 180.39,28.51 179.64,27.76 179.64,27.04 178.76,26.15 178.76,25.81 177.77,24.83 177.77,24.33 178.35,23.76 U13.85 ; PR276.2 47.81,18.66 48.17,19.01 50.81,19.01 51.34,19.54 v2(51.34,20.08) 51.34,23.13 50.35,24.12 50.35,24.98 v2(51.55,26.17)
  TOP w0.203: v2(143.85,36.87) 143.9,36.87 144.44,36.33 144.44,35.21 144.91,34.74 PR70.1 144.5,34.32 144.5,33.92 PR77.2
  IN2 w0.089: v2(25.31,36.82) 25.33,36.79 25.33,34.02 26.76,32.59 26.76,30.87 27.04,30.59 27.04,26.25 27.91,25.37 30.33,25.37 31.34,24.37 38.42,24.37 39.2,23.59 43.72,23.59 44.19,24.05 50.16,24.05 51.34,22.87 v2(51.34,20.08) ; v2(186.5,32.24) 186.08,31.83 185.7,31.83 185.53,32 181.32,32 179.79,30.47 174.63,30.47 174.04,29.88 169.11,29.88 168.88,30.1 167.12,30.1 166.49,30.74 165.46,30.74 163.84,32.36 160.39,32.36 159.95,32.8 159.95,33.01 157.92,35.04 156.93,35.04 156.16,35.81 155.27,35.81 154.3,36.78 145.49,36.78 145.38,36.66 144.06,36.66 v2(143.85,36.87) ; v2(51.55,26.17) 51.75,25.97 53.06,25.97 54.03,25.01 64.07,25.01 64.58,25.51 84.52,25.51 86.08,27.08 88.54,27.08 89.11,26.5 91.53,26.5 92.52,25.52 95.63,25.52 97.34,27.23 97.8,27.23 99.22,28.65 103.18,28.65 105.4,30.86 105.4,31.75 105.8,32.16 106.2,32.16 106.36,31.99 106.36,31.23 107.13,30.46 109.18,30.46 109.68,29.96 v1(110.04,29.96)
  IN3 w0.089: v2(119.82,39.2) 120.52,39.2 123.48,36.24 124.2,36.24 124.6,35.85 124.6,35.37 125.06,34.92 129.24,34.92 130.97,36.65 135.8,36.65 136.32,37.17 143.54,37.17 143.83,36.87 v2(143.85,36.87)
  BOTTOM w0.102: R67418.1 20.38,38.09 20.51,37.96 23.18,37.96 24.32,36.82 v2(25.31,36.82) ; PR193.1 v2(119.82,39.2) 119.82,34.53 119.19,33.9 115.43,33.9 114.03,32.5 113.35,32.5 111.21,30.36 110.32,30.36 110.04,30.09 v1(110.04,29.96)
