# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N48839459: length 9.4
  TOP w0.102: v2(133.41,124.24) 133.54,124.12 PR9135.1 PR9128.2
  BOTTOM w0.102: PQ9008.2 128.91,123.62 129.09,123.81 132.4,123.81 132.79,123.41 PQ9007.3 v2(133.41,124.24) 133.41,124.57 v2(133.67,124.83)
N48839476: length 4.6
  BOTTOM w0.102: PQ9008.3 129.62,121.4 128.21,121.4 128.09,121.28 PR9129.2 125.93,121.28 v2(125.54,120.89)
N48839503: length 69.1
  IN3 w0.089: v2(88.02,123.68) 89.09,123.68 89.51,124.11 91.24,124.11 92.59,122.76 92.99,122.76 93.57,122.19 93.57,121.37 95.22,119.72 95.4,119.72 95.87,119.25 100.89,119.25 100.98,119.16 103.17,119.16 103.66,119.64 105.2,119.64 105.5,119.34 106.21,119.34 106.23,119.36 107.77,119.36 108.65,118.48 109.49,118.48 111.9,120.89 112.84,120.89 113.98,122.03 113.98,122.6 114.32,122.94 118.34,122.94 118.51,123.12 118.85,123.12 120.19,121.78 121.73,121.78 122.11,122.16 123.76,122.16 124.65,121.27 128.05,121.27 128.33,121.54 133.01,121.54 v2(133.41,121.14)
  BOTTOM w0.102: PR77835.2 73.73,124.57 v2(75.25,124.57) 76.73,124.57 77.94,123.36 87.62,123.36 87.95,123.68 v2(88.02,123.68) ; PQ9007.2 133.68,121.41 v2(133.41,121.14)
N48839793: length 8.7
  TOP w0.381: PR77852.2 142.85,68.78 v2(142.37,69.26) 141.92,69.71 PR77850.1 142.52,70.38 143.12,69.78 PQ9062.2 146.81,69.78 147.27,69.31 PQ9063.3
N48839805: length 4.5
  TOP w0.381: PR77851.2 147,71.74 v2(146.3,71.04) 145.98,70.73 PQ9062.3
N48839825: length 2
  TOP w0.381: PQ9063.2 149.27,66.93 v2(149.29,66.91) PR77853.2
N48842289: length 5.9
  TOP w0.508: v2(92.67,97.71) PQ9065.2 91.19,97.71 91.16,97.74 PR77854.1 PR77857.2
  BOTTOM w0.102: v2(93.41,97.9) 93.21,97.71 v2(92.67,97.71)
  BOTTOM w0.508: PQ9066.3 92.39,96.89 92.67,97.17 v2(92.67,97.71)
N48842319: length 2.7
  TOP w0.102: PR77855.2 95.32,96.79 v2(95.32,98.03)
  TOP w0.508: PQ9065.3 PR77855.2
N48842333: length 2.4
  BOTTOM w0.102: PQ9066.2 94.01,94.31 94.3,94.6 PR77858.2 94.67,95.37 v2(94.55,95.49)
N48844867: length 10.8
  TOP w0.102: PR77859.1 v2(135.06,121.14) 134.43,120.51 PR77861.2 134.01,119.97 133.79,119.75 132.27,119.75 131.87,119.35 PQ9069.2 131.19,119.69 130.69,120.18 v2(130.54,120.18)
  BOTTOM w0.102: v2(135.06,121.14) 135.57,121.14 v2(135.7,121.27) 136.35,121.92 PQ9068.3 ; v2(130.54,120.18) 129.84,119.48 PQ9067.2
N48844873: length 3.3
  BOTTOM w0.102: PR77860.2 127.94,117.34 128.33,116.95 v2(128.84,116.95) 129.09,116.95 129.62,117.48 PQ9067.3
N48844882: length 2.1
  BOTTOM w0.102: PR77862.2 136.15,125.21 136.27,125.08 v2(136.27,124.95) 136.27,124.51 136.15,124.39 PQ9068.2
N48844885: length 4.2
  TOP w0.102: v2(127.57,116.19) 127.32,116.45 PR77863.2 127.32,117.35 PQ9069.3
N48959770: length 5
  TOP w0.102: v2(105.22,27.29) 105.46,27.54 R131.2 104.2,28.18 102.77,29.61 Q14.2
N48963506: length 1.1
  BOTTOM w0.102: R77866.2 67.37,93.84 67.43,93.78 U23.3
N48964387: length 2.1
  TOP w0.102: D8509.1 129.75,123.15 129.5,123.4 R12295.1 R77867.1
N48976098: length 2.3
  TOP w0.102: v2(83.24,117.47) PR9071.2
  TOP w0.457: PR9071.2 82.23,116.96 82.46,116.72 PC9050.1
N48976699: length 1.9
  TOP w0.203: PR9106.1 PC9189.1 87.56,117.84 PR9108.1
N48977175: length 2.3
  BOTTOM w0.203: PR9102.2 72.05,115.33 72.2,115.48 PR9101.2 72.7,115.48 72.95,115.24 PU9000.24
N475840780: length 2.1
  TOP w0.102: TP46.1 173.04,12.31 173.04,13.07 173.22,13.25 U13.48
N4709329327: length 3.1
  TOP w0.102: v2(52.26,53.33) 52.26,53.83 TP2024.1
  BOTTOM w0.102: v2(52.26,53.33) 51.63,53.96 CN2019.162
N4709329328: length 1.9
  BOTTOM w0.102: CN2019.165 60.38,53.21 TP2023.1

## Copper pours and planes (outline as drawn)
1.8V_PU9 on BOTTOM (solid shape): 108.43,86.64 108.43,86.23 108.6,86.05 108.77,86.05 108.84,86.03 108.91,86.03 109.1,86.03 109.35,85.78 109.43,85.71 109.53,85.67 109.54,85.66 109.61,85.6 109.61,85.59 109.8,85.4 109.8,85.39 109.82,85.37 111.81,85.37 111.93,85.24 111.93,84.5 111.74,84.31 109.66,84.31 109.18,83.83 105.9,83.83 105.56,84.18 105.56,86.07 105.71,86.22 105.75,86.19 105.8,86.18 107.17,86.18 107.25,86.2 107.3,86.27 107.76,86.73 108.34,86.73
3.3V_PU9 on BOTTOM (solid shape): 120.19,85.7 120.19,83.12 120.18,83.08 120.18,83.04 120.18,83.01 120.19,82.96 120.19,81.34 120.03,81.18 118.71,81.18 118.63,81.26 118.63,82.68 118.64,82.7 118.65,82.71 118.8,82.85 118.86,83.04 118.8,83.24 118.63,83.4 118.63,83.43 118.63,84.12 118.4,84.35 116.44,84.35 116.13,84.67 116.13,85.03 116.35,85.25 118.72,85.25 119.2,85.74 120.15,85.74
+0.95V on TOP (solid shape): 111.24,45.14 111.33,45.08 111.31,44.97 111.22,44.84 111.19,44.69 111.57,44.31 111.95,44.69 111.92,44.84 111.83,44.97 111.8,45.08 111.9,45.14 117.39,45.14 117.6,44.94 117.6,43 117.47,42.86 114.66,42.86 114.18,42.39 111.96,42.39 111.91,42.43 111.91,42.44 111.77,42.6 111.56,42.66 111.44,42.64 111.33,42.58 110.5,42.58 110.41,42.67 109.97,42.67 109.88,42.58 109.24,42.58 109.17,42.65 109.17,44.65 109.66,45.14
+0.95V on TOP (solid shape): 96.9,50.26 96.9,49.89 96.89,49.86 96.85,49.84 96.31,49.84 96.08,49.61 96.01,49.58 95.94,49.62 95.83,49.69 95.69,49.72 95.46,49.62 95.36,49.39 95.39,49.26 95.47,49.15 95.5,49.08 95.47,49 95.29,48.82 95.29,47.56 95.11,47.39 93.49,47.39 93.35,47.52 93.34,47.55 93.35,47.61 93.4,47.62 93.44,47.61 93.48,47.61 93.84,47.97 93.48,48.32 93.46,48.32 93.39,48.35 93.36,48.42 93.32,48.58 93.19,48.72 93.18,48.75 93.18,48.83 93.19,48.87 93.45,49 93.53,49.24 93.43,49.49 93.18,49.59 93.05,49.57 92.94,49.5 92.87,49.47 92.8,49.5 92.63,49.66 92.63,50.23 92.72,50.31 96.85,50.31
+0.95V on BOTTOM (solid shape): 94.21,50.03 94.21,50.01 94.3,49.79 94.51,49.7 94.63,49.73 94.75,49.81 94.77,49.81 94.99,49.81 95.15,49.65 95.15,49.29 95.14,49.27 95.13,49.25 95.01,49.01 95.13,48.77 95.14,48.75 95.15,48.73 95.15,48.29 95.14,48.27 95.13,48.25 95.01,48.01 95.13,47.77 95.14,47.75 95.15,47.73 95.15,47.55 94.97,47.38 94.84,47.38 94.68,47.53 94.37,47.53 94.15,47.31 93.83,47.31 93.81,47.32 93.67,47.47 93.51,47.51 93.48,47.51 93.45,47.51 93.42,47.51 93.4,47.52 93.32,47.61 93.26,47.68 93.19,47.74 93.11,47.81 93.11,48.08 93.13,48.11 93.15,48.12 93.3,48.24 93.36,48.42 93.3,48.61 93.12,48.75 93.11,48.78 93.11,50.21 93.28,50.37 93.86,50.37
+0.95V on SVCC (solid shape): outline of 255 points within 92.65,32.5 118.55,49.82
+0.95VS5 on TOP (solid shape): outline of 465 points within 91.59,37.06 102.36,50.26
+0.95VS5 on BOTTOM (solid shape): 92.95,50.29 92.95,48.79 92.95,48.76 92.76,48.62 92.7,48.43 92.69,48.41 92.67,48.38 92.57,48.38 92.57,48.39 91.85,48.39 91.82,48.4 91.8,48.44 91.8,48.74 91.78,48.86 91.72,48.95 91.67,49 91.67,49.1 91.68,49.14 91.89,49.23 91.97,49.41 91.93,49.53 91.85,49.62 91.84,49.63 91.67,49.8 91.67,50.05 91.56,50.16 91.56,50.29 91.68,50.42 92.83,50.42
+1.2VSUS on TOP (solid shape): 52.67,63.78 52.67,63.3 52.44,63.06 50.67,63.06 50.56,63.17 50.56,63.89 50.68,64 52.45,64
+1.2VSUS on TOP (solid shape): 61.02,68.63 61.02,68.19 63.18,66.03 70.06,66.03 70.32,65.77 70.32,64.8 70.15,64.63 62.89,64.63 59.52,67.99 59.52,68.72 59.62,68.81 60.84,68.81
+1.2VSUS on TOP (solid shape): 47.32,91.41 47.32,90.69 46.8,90.17 44.65,90.17 44.47,90.35 44.47,90.57 44.8,90.91 44.8,91.43 44.88,91.52 47.21,91.52
+1.2VSUS on TOP (solid shape): 54.91,53.41 55.11,53.31 55.33,53.27 60.92,53.27 63,51.19 72.84,51.19 73.08,50.95 73.08,49.85 72.67,49.44 70.6,49.44 70.23,49.82 61.8,49.82 60.83,50.78 60.83,51.55 60.12,52.26 55.23,52.26 54.63,52.86 54.25,52.86 54.11,53 54.11,53.13 54.12,53.14 54.15,53.22 54.16,53.3 54.16,53.32 54.26,53.41
+1.2VSUS on TOP (solid shape): 87.82,58.43 87.82,57.93 87.81,57.88 87.81,57.83 87.81,57.79 87.82,57.74 87.82,56.17 87.65,56 86.63,56 86.6,56 86.59,56.02 86.56,56.05 86.48,56.12 86.48,56.73 86.5,56.76 86.53,56.78 87.08,56.78 87.1,56.77 87.22,56.7 87.34,56.68 87.67,57.01 87.34,57.34 87.19,57.3 87.05,57.19 87.03,57.18 86.93,57.18 86.89,57.2 86.88,57.23 86.88,57.31 86.89,57.33 86.95,57.39 86.97,57.44 86.97,57.65 86.94,57.72 86.87,57.75 86.53,57.75 86.5,57.76 86.48,57.8 86.48,58.43 86.55,58.5 87.75,58.5
+1.2VSUS on TOP (solid shape): 87.12,54.97 87.49,54.97 87.66,54.8 88.39,54.8 88.51,54.69 88.51,52.28 88.42,52.19 87.62,52.19 87.5,52.07 87.5,51.81 87.39,51.71 87.11,51.71 87.01,51.81 87.01,52.1 87.02,52.12 87.04,52.13 87.24,52.43 87.04,52.74 87.02,52.75 87.01,52.77 87.01,53.2 87.01,53.23 87.03,53.24 87.11,53.32 87.16,53.42 87.2,53.47 87.27,53.49 87.34,53.48 87.67,53.81 87.34,54.14 87.3,54.14 87.22,54.18 87.16,54.19 87.07,54.19 86.92,54.34 86.53,54.34 86.44,54.44 86.44,54.95 86.44,54.97 86.46,54.99 86.58,55.1 86.67,55.22 86.69,55.24 86.72,55.25 86.84,55.25
+1.2VSUS on TOP (solid shape): 47.64,63.1 47.68,63.11 47.71,63.1 47.73,63.06 47.73,62.63 47.73,62.61 47.73,62 47.32,61.59 47.32,59.5 48.79,58.03 48.79,57.2 48.78,57.18 48.78,56.55 48.79,56.52 48.79,54.87 48.79,54.84 48.63,54.69 48.58,54.49 48.69,54.22 49.13,54.15 49.26,54.26 49.33,54.3 49.41,54.27 49.8,53.89 49.8,53.88 49.83,53.83 49.88,53.8 49.89,53.79 50.1,53.58 50.1,52.76 50.07,52.69 49.99,52.66 49.98,52.66 49.7,52.66 49.63,52.65 49.53,52.6 49.31,52.6 49.27,52.63 49.26,52.64 49.13,52.77 48.96,52.81 48.89,52.8 48.81,52.78 48.46,52.78 48.32,52.92 48.32,53.45 48.29,53.65 48.19,53.83 48.19,55.36 47.56,55.99 40.7,55.99 40.42,56.28 40.42,61.11 40.71,61.4 45.65,61.4 45.92,61.45 46.14,61.6
+1.2VSUS on TOP (solid shape): outline of 83 points within 48.25,31.86 51.14,48.94
+1.2VSUS on TOP (solid shape): outline of 615 points within 34.48,63.31 50.61,88
+1.2VSUS on BOTTOM (solid shape): 49.31,121.09 49.31,120.73 49.7,120.35 51.17,120.35 51.18,120.34 57.75,120.34 57.96,120.13 57.96,117.48 57.44,116.97 47.32,116.97 47.02,117.26 47.02,118.86 47,118.87 47,121.04 47.14,121.17 49.23,121.17
+1.2VSUS on BOTTOM (solid shape): outline of 14121 points within 29.02,31.05 49.2,98.6
+1.2VSUS on SGND (solid shape): outline of 109 points within 41.46,49.64 87.56,69.71
+1.2VSUS on IN2 (solid shape): outline of 9959 points within 31.92,33.51 87.56,98.44
+1.2VSUS on SVCC (solid shape): 57.34,125.74 57.34,114.9 50.05,107.61 49.99,107.53 49.97,107.43 49.97,104.35 49.88,104.22 49.85,104.07 49.88,103.92 49.97,103.79 49.97,103.7 49.88,103.57 49.85,103.41 49.88,103.26 49.97,103.13 49.97,99.53 49.11,98.67 44.51,98.67 44.41,98.65 44.33,98.59 42.76,97.01 38.07,97.01 37.94,97.11 37.79,97.14 37.63,97.11 37.5,97.01 37.43,97.01 37.3,97.11 37.15,97.14 36.99,97.11 36.86,97.01 29.89,97.01 29.15,97.75 29.15,101.42 29.25,101.55 29.28,101.71 29.25,101.87 29.15,102 29.15,103.64 29.5,104 37.78,104 37.88,104.02 37.96,104.07 38.72,104.84 38.78,104.92 38.8,105.02 38.8,113.3 38.82,113.32 38.85,113.34 39.16,113.65 40.7,113.65 40.8,113.67 40.88,113.73 42.02,114.87 42.08,114.95 42.1,115.05 42.1,120.53 43.29,121.73 43.35,121.81 43.37,121.91 43.37,122.56 43.67,122.87 48.86,122.87 50.3,123.46 50.89,124.9 50.89,125.97 57.11,125.97
+1.2VSUS on IN3 (solid shape): 32.8,78.09 32.8,75.65 31,73.85 31,71.33 30.06,70.39 29.6,70.39 29.27,70.73 29.27,74.66 29.55,74.66 29.55,74.61 29.56,74.56 29.57,74.51 29.6,74.46 29.63,74.41 29.66,74.38 29.71,74.34 29.75,74.32 29.8,74.3 29.85,74.28 29.91,74.28 29.96,74.28 30.01,74.3 30.06,74.32 30.11,74.34 30.15,74.38 30.19,74.41 30.22,74.46 30.24,74.51 30.25,74.56 30.26,74.61 30.26,74.66 30.25,74.72 30.24,74.77 30.22,74.82 30.19,74.86 30.15,74.9 30.11,74.93 30.06,74.96 30.01,74.98 29.96,74.99 29.91,74.99 29.85,74.99 29.8,74.98 29.75,74.96 29.71,74.93 29.66,74.9 29.63,74.86 29.6,74.82 29.57,74.77 29.56,74.72 29.55,74.66 29.27,74.66 29.27,75.04 31.76,77.53 31.76,78.09 31.89,78.22 32.68,78.22
+1.2VSUS on SGND1 (solid shape): 87.56,57.85 87.56,51.85 87.1,51.39 87.08,51.38 87,51.35 86.93,51.29 83.57,51.29 83.56,51.3 83.54,51.31 83.34,51.51 83.3,51.54 83.25,51.55 81.85,51.55 81.8,51.54 81.76,51.51 81.56,51.31 81.54,51.3 81.52,51.29 80.89,51.29 80.71,51.47 80.71,58.99 81.52,59.8 85.61,59.8
+1.5V on TOP (solid shape): 197.42,21.54 197.42,19.84 198.04,19.22 199.06,19.22 199.15,19.13 199.15,18.76 199.36,18.55 200.6,18.55 201.45,17.7 203.11,17.7 203.27,17.53 203.27,17.37 203.88,17.37 203.88,16.92 203.73,16.77 201.59,16.77 201.54,16.82 201.43,17.08 201.16,17.2 201.05,17.18 200.95,17.13 200.88,17.12 200.82,17.16 200.66,17.28 200.48,17.32 200.43,17.33 200.22,17.55 198.07,17.55 197.78,17.84 196.52,17.84 196.37,17.99 196.37,21.64 196.39,21.66 197.3,21.66
+1.5V on IN3 (solid shape): outline of 382 points within 196.12,20.18 200.13,29.84
+1.05V_LAN on TOP (solid shape): 52.08,110.25 52.08,109.33 51.97,109.22 51.96,109.19 51.94,109.17 51.83,109.11 51.73,109.03 50.81,108.11 50.68,107.92 50.63,107.68 50.63,107.36 50.52,107.25 49.09,107.25 48.94,107.1 48.94,106.19 48.87,106.13 48.87,105.93 48.29,105.36 47.84,105.36 47.65,105.55 47.65,105.9 47.68,105.93 47.96,105.93 47.96,105.94 48.03,106 48.13,106.13 48.17,106.29 48.15,106.42 48.08,106.53 48.08,107.45 48.29,107.67 48.34,107.68 48.59,107.79 48.7,108.04 48.71,108.08 48.73,108.11 48.89,108.27 49.54,108.27 49.92,108.65 50.13,108.65 50.22,108.68 50.26,108.77 50.26,110.32 50.34,110.4 51.93,110.4
+1.05V_LAN on IN1 (solid shape): outline of 660 points within 40.07,101.42 52.25,110.82
+1.05V_LAN_REGOUT on TOP (solid shape): 49.64,110.06 49.64,108.74 49.42,108.52 48.22,108.52 47.85,108.15 47.85,106.83 47.71,106.69 47.23,106.69 46.29,106.69 46.26,106.73 46.26,106.89 46.6,107.23 46.6,108.05 47.48,108.93 47.48,109.07 47.76,109.35 48.43,109.35 48.64,109.56 48.64,110.11 48.67,110.14 48.72,110.15 49.56,110.15
+1.8V on TOP (solid shape): 134.94,21.33 134.94,20.94 134.7,20.71 134.7,19.51 134.5,19.3 133.34,19.3 133.21,19.44 133.21,21.58 133.35,21.73 134.54,21.73
+1.8V on TOP (solid shape): 199.9,33.29 199.9,32.9 200.15,32.64 200.15,32.36 200.14,32.35 199.37,32.35 199.11,32.62 199.11,33.23 199.23,33.35 199.84,33.35
+1.8V on TOP (solid shape): 25.85,33.63 25.85,32.8 26.33,32.33 26.33,31.53 25.92,31.13 25.92,30.87 25.77,30.72 25.16,30.72 24.6,31.28 24.6,31.28 24.29,31.59 24.29,32.6 24.6,32.9 24.6,33.46 24.8,33.67 25.82,33.67
+1.8V on TOP (solid shape): outline of 279 points within 72.45,14.59 82.65,25.39
+1.8V on BOTTOM (solid shape): 16.1,22.37 16.1,21.51 15.95,21.36 15.64,21.36 15.6,21.37 15.56,21.37 15.51,21.37 15.47,21.36 15.19,21.36 15.1,21.27 14.1,21.27 14.07,21.31 14.07,22.39 14.15,22.48 15.62,22.48 15.64,22.5 15.98,22.5
+1.8V on BOTTOM (solid shape): outline of 465 points within 78.47,8.03 99.76,21.51
+1.8V on IN2 (solid shape): 167.6,18.3 167.6,17.97 167.02,17.39 166.97,17.39 166.64,17.72 166.64,17.99 167.09,18.45 167.45,18.45
+1.8V on IN2 (solid shape): outline of 881 points within 97.49,14.84 136.25,22.62
+1.8V on SVCC (solid shape): outline of 109 points within 21.4,7.99 80.83,33.77
+1.8V on IN3 (solid shape): outline of 578 points within 14.55,21.06 26.88,25.71
+1.8V_GFX on TOP (solid shape): outline of 603 points within 95.66,95.19 107.68,101.85
+1.8V_GFX on BOTTOM (solid shape): 109.87,89.95 109.87,88.97 109.59,88.69 108.07,88.69 107.44,88.05 107.44,86.86 107.27,86.69 105.82,86.69 105.54,86.98 105.54,89.65 106.33,90.45 109.38,90.45
+1.8V_GFX on BOTTOM (solid shape): 106.04,101.18 106.06,101.17 106.08,101.16 106.84,100.4 106.84,100.16 106.61,99.93 106.21,99.52 106.21,99.2 106.1,99.09 105.8,99.09 105.68,99.21 105.68,99.39 104.85,100.22 104.28,100.22 104.18,100.33 104.18,100.51 104.45,100.78 104.45,101 104.63,101.18
+1.8V_GFX on IN2 (solid shape): outline of 6516 points within 103.67,87.06 123.72,125.53
+1.8V_S5 on TOP (solid shape): 94.25,31.59 94.33,31.55 94.35,31.47 94.35,31.41 94.39,31.23 94.54,31.08 94.54,31.06 94.54,29.31 94.31,29.08 94.27,29.05 94.24,29.01 93.35,28.12 93.35,27.84 92.8,27.29 92.14,27.29 92.01,27.42 92.01,28.27 92.03,28.32 92.85,29.14 93.18,29.14 93.25,29.16 93.31,29.2 93.64,29.53 93.66,29.55 93.68,29.6 93.71,29.62 93.71,30.38 93.71,30.38 93.71,31.48 93.81,31.59
+1.8V_S5 on TOP (solid shape): outline of 90 points within 116.48,17.53 136.02,26.47
+1.8V_S5 on TOP (solid shape): 26.88,31.48 27.24,31.23 27.6,31.48 29,31.48 29.08,31.46 29.14,31.46 29.21,31.46 29.29,31.48 29.99,31.48 30.26,31.22 30.26,28.54 30.14,28.54 30.05,28.5 30.01,28.41 30.01,24.65 30.03,24.58 30.08,24.54 30.26,24.36 30.26,23.91 30.18,23.83 29.78,23.83 29.61,24.01 28.92,24.01 28.26,24.68 28.26,25.25 28.36,25.35 28.4,25.41 28.42,25.48 28.42,25.79 28.44,25.83 28.57,25.97 28.62,26.16 28.53,26.4 28.27,26.55 28.26,26.58 28.26,27.67 28.27,27.7 28.29,27.71 28.51,28.05 28.26,28.45 28.26,28.88 28.27,28.9 28.27,29.73 27.79,30.21 26.22,30.21 26.1,30.34 26.1,31.05 26.53,31.48
+1.8V_S5 on TOP (solid shape): outline of 305 points within 104.12,30.17 114.91,34.51
+1.8V_S5 on BOTTOM (solid shape): 85.95,28.57 85.95,27.93 85.93,27.9 85.91,27.9 85.8,27.86 85.7,27.8 85.58,27.66 85.54,27.48 85.64,27.22 85.89,27.1 85.89,27.04 85.87,27 84.75,25.88 82.61,25.88 82.39,25.66 82.39,25.48 82.39,25.46 82.32,25.36 82.3,25.26 82.3,25.19 82.02,24.9 81.69,24.9 81.59,25 81.59,25.74 82.78,26.93 84.12,26.93 85.55,28.35 85.55,28.59 85.59,28.63 85.9,28.63
+1.8V_S5 on IN2 (solid shape): outline of 1647 points within 28.79,25.67 105.1,34.94
+1.8V_S5 on IN3 (solid shape): 114.73,34.53 114.81,34.48 114.81,34.38 114.78,34.29 114.77,34.2 114.87,33.95 115.12,33.84 115.36,33.93 115.48,34.15 115.54,34.23 115.65,34.2 116.18,33.67 116.18,28.76 116.17,28.74 116.06,28.59 116.02,28.42 116.09,28.19 116.27,28.04 116.28,28.04 116.38,27.95 116.38,27.91 116.37,27.9 116.32,27.79 116.3,27.67 116.42,27.38 116.71,27.27 116.83,27.28 116.93,27.33 116.97,27.34 117,27.33 117.08,27.25 117.47,27.25 118.17,26.54 118.17,25.82 118.01,25.66 116.78,25.66 115.27,27.17 115.27,31.35 115.26,31.41 115.23,31.46 113.85,32.84 113.85,34.19 114.18,34.53
+1.8V_SW on TOP (solid shape): 33.03,17.84 33.03,16.84 33.02,16.83 33.02,16.43 32.8,16.21 31.05,16.21 30.38,16.87 30.38,17.31 30.57,17.5 31.69,17.5 32.14,17.95 32.91,17.95
+1.8V_SW on BOTTOM (solid shape): 13.44,22.06 13.44,21.13 13.62,20.95 14.9,20.95 15,20.86 15,19.76 14.93,19.7 14.25,19.7 14.15,19.75 14.03,19.77 13.91,19.75 13.81,19.7 13.61,19.7 13.16,20.15 12.41,20.15 12.02,20.54 11.59,20.54 11.49,20.65 11.49,21.95 11.64,22.11 13.39,22.11
+1.8V_TPM on TOP (solid shape): 132.65,23.06 132.65,20.81 132.53,20.7 131.67,20.7 131.61,20.76 131.61,21.02 131.08,21.55 129.3,21.55 128.79,22.06 127.8,22.06 127.75,22.11 127.75,22.52 127.95,22.72 130.26,22.72 130.36,22.82 131.26,22.82 131.6,23.15 132.55,23.15
+1.8V_TPM on TOP (solid shape): 121.65,23.3 122.11,23.3 122.34,23.53 122.74,23.53 122.79,23.49 122.79,23.08 122.77,23.04 122.73,23.02 122.62,23.02 122.51,23 122.41,22.94 121.5,22.94 121.04,23.4 121.04,23.68 121.07,23.71 121.25,23.71
+1.8V_TPM on TOP (solid shape): 122.37,19.99 122.41,19.96 122.46,19.93 122.52,19.87 122.59,19.87 122.59,19.86 123.53,19.86 123.58,19.8 123.58,19.62 123.53,19.57 122.59,19.57 122.57,19.59 122.45,19.67 122.32,19.69 121.81,19.69 121.74,19.71 121.68,19.72 121.41,19.61 121.3,19.34 121.3,19.27 121.32,19.2 121.32,19.06 121.35,18.92 121.43,18.81 121.47,18.76 121.47,17.64 121.48,17.58 121.49,17.51 121.49,16.98 121.4,16.88 120.96,16.88 120.71,17.13 120.71,19.59 121.25,20.13 122.24,20.13
+1.8V_TPM_VSB on TOP (solid shape): 132.65,19.9 132.65,17.93 132.4,17.68 131.57,17.68 130.88,18.36 127.78,18.36 127.73,18.42 127.73,18.81 127.78,18.86 128.81,18.86 128.94,18.99 128.94,19.45 129.26,19.77 131.18,19.77 131.51,20.1 132.45,20.1
+1.35V_GFX on TOP (solid shape): outline of 1018 points within 107.89,92.09 120.65,100.22
+1.35V_GFX on TOP (solid shape): outline of 3686 points within 136.11,78.45 149.23,117.83
+1.35V_GFX on BOTTOM (solid shape): outline of 8791 points within 128.18,77.43 149.1,119.53
+1.35V_GFX on IN1 (solid shape): outline of 7331 points within 107.23,76.48 149.22,117.35
+1.35V_GFX on IN3 (solid shape): outline of 7849 points within 107.63,75.1 149.22,110.73
+2.5V_SUS on TOP (solid shape): 48,45.59 48,42.77 47.99,42.76 47.99,41.45 47.94,41.41 47.02,41.41 46.93,41.5 46.93,45.5 47.16,45.72 47.87,45.72
+2.5V_SUS on TOP (solid shape): 50.85,90.45 50.85,88.78 50.4,88.33 47.08,88.33 46.91,88.5 46.91,89.04 48.58,89.04 48.58,89.01 48.58,88.96 48.6,88.9 48.62,88.86 48.65,88.81 48.69,88.77 48.73,88.73 48.77,88.7 48.82,88.68 48.88,88.67 48.93,88.66 48.99,88.66 49.05,88.67 49.1,88.69 49.16,88.71 49.21,88.75 49.23,88.77 49.41,88.95 49.86,88.96 49.9,88.96 49.94,88.98 49.98,89.01 50.01,89.04 50.03,89.07 50.05,89.12 50.06,89.16 50.07,89.26 50.07,89.31 50.07,89.36 50.07,89.4 50.06,89.5 50.05,89.55 50.03,89.59 50.01,89.63 49.98,89.66 49.94,89.68 49.9,89.7 49.86,89.71 49.25,89.71 49.22,89.71 49.16,89.7 49.1,89.68 49.05,89.66 49,89.62 48.98,89.6 48.69,89.31 48.67,89.29 48.63,89.24 48.6,89.18 48.59,89.13 48.58,89.07 48.58,89.04 46.91,89.04 46.91,89.9 47.7,90.69 50.61,90.69
+2.5V_SUS on TOP (solid shape): outline of 411 points within 33.32,26.54 58.2,30.59
+2.5V_SUS on BOTTOM (solid shape): 34.77,29.72 34.77,29.26 34.64,29.13 33.45,29.13 33.32,29.26 33.32,30.73 33.42,30.84 33.65,30.84
+2.5V_SUS on BOTTOM (solid shape): 59.78,123.28 59.78,122.33 59.77,122.29 59.77,122.25 59.77,121.76 59.77,121.72 59.78,121.68 59.78,117.68 59.62,117.52 58.38,117.52 58.3,117.59 58.3,122.18 58.14,122.35 58.14,123.36 58.18,123.4 59.66,123.4
+2.5V_SUS on BOTTOM (solid shape): 59.81,30.1 59.81,29.3 59.64,29.14 58.85,29.14 58.24,28.53 56.92,28.53 56.64,28.81 56.64,29.75 56.73,29.83 59.33,29.83 59.33,30.08 57.57,30.08 57.57,29.83 56.73,29.83 57.23,30.33 59.57,30.33
+2.5V_SUS on BOTTOM (solid shape): 29.53,78.85 29.53,78.4 29.48,78.32 29.39,78.31 29.32,78.33 29.25,78.34 28.87,77.96 29.25,77.57 29.32,77.58 29.39,77.6 29.48,77.59 29.53,77.51 29.53,76.46 28.63,75.56 27.38,75.56 27.28,75.66 27.28,78.76 27.49,78.98 29.4,78.98
+2.5V_SUS on IN3 (solid shape): 59.72,118.34 59.72,117.44 59.36,117.08 57.67,117.08 57.4,117.35 57.4,118.39 57.72,118.7 59.35,118.7
+2.5V_SUS on IN3 (solid shape): 29.87,90.96 29.87,76.62 29.6,76.35 27.53,76.35 27.32,76.56 27.32,77.98 28.89,77.98 28.89,77.93 28.9,77.88 28.91,77.82 28.94,77.78 28.97,77.73 29,77.69 29.05,77.66 29.09,77.63 29.14,77.61 29.19,77.6 29.25,77.6 29.3,77.6 29.35,77.61 29.4,77.63 29.45,77.66 29.49,77.69 29.53,77.73 29.56,77.78 29.58,77.82 29.59,77.88 29.6,77.93 29.6,77.98 29.59,78.03 29.58,78.09 29.56,78.13 29.53,78.18 29.49,78.22 29.45,78.25 29.4,78.28 29.35,78.3 29.3,78.31 29.25,78.31 29.19,78.31 29.14,78.3 29.09,78.28 29.05,78.25 29,78.22 28.97,78.18 28.94,78.13 28.91,78.09 28.9,78.03 28.89,77.98 27.32,77.98 27.32,90.84 27.72,91.23 29.6,91.23
+3V on TOP (solid shape): 189.34,30.56 189.34,28.91 189.23,28.8 187.59,28.8 187.28,29.11 187.28,30.03 187.3,30.06 187.32,30.06 187.55,30.19 187.64,30.44 187.64,30.49 187.65,30.51 187.85,30.72 189.18,30.72
+3V on TOP (solid shape): 20.6,83.44 20.6,82.75 20.55,82.65 20.54,82.54 20.6,82.32 20.77,82.18 20.78,82.18 20.81,82.15 21.02,82.15 21.12,82.05 21.12,81.28 20.99,81.15 19.56,81.15 19.48,81.23 19.48,81.97 18.18,81.97 18.13,82.02 18.13,82.62 18.23,82.72 19.89,82.72 20.09,82.93 20.09,83.39 20.2,83.5 20.55,83.5
+3V on TOP (solid shape): 22.96,76.26 22.96,74.79 23.07,74.69 23.07,74.68 23.13,74.6 23.22,74.53 23.25,74.51 23.34,74.49 23.4,74.48 23.47,74.49 23.53,74.51 24.84,74.51 24.85,74.5 25.03,74.46 25.21,74.5 25.22,74.51 25.62,74.51 25.88,74.25 25.88,73.32 25.7,73.14 21.69,73.14 21.41,73.42 21.41,76.29 21.52,76.4 22.82,76.4
+3V on TOP (solid shape): 148.06,28.69 148.65,28.69 148.78,28.56 148.78,24.15 148.49,23.86 147.16,23.86 146.9,24.11 146.9,24.42 146.89,24.48 146.85,24.54 146.18,25.22 146.18,28.25 146.5,28.57 146.52,28.57 146.58,28.56 146.62,28.56 146.89,28.67 147,28.94 147,29 147.02,29.08 147.1,29.12 147.63,29.12
+3V on TOP (solid shape): 172.58,28.77 173.25,28.77 173.36,28.66 173.36,27.38 173.38,27.36 173.38,23.34 172.18,22.13 171.72,22.13 170.68,23.17 170.68,24.15 170.95,24.42 170.95,25.89 170.95,25.89 171.64,25.89 171.64,25.84 171.65,25.78 171.67,25.73 171.7,25.68 171.74,25.64 171.78,25.6 171.82,25.57 171.87,25.54 171.92,25.52 171.98,25.51 172.03,25.51 172.09,25.52 172.14,25.53 172.19,25.55 172.24,25.58 172.29,25.62 172.32,25.66 172.35,25.71 172.38,25.76 172.39,25.81 172.4,25.87 172.4,25.92 172.39,25.98 172.38,26.03 172.35,26.08 172.32,26.13 172.29,26.17 172.24,26.2 172.19,26.23 172.14,26.26 172.09,26.27 172.03,26.28 171.98,26.27 171.92,26.26 171.87,26.25 171.82,26.22 171.78,26.19 171.74,26.15 171.7,26.1 171.67,26.06 171.65,26 171.64,25.95 171.64,25.89 170.95,25.89 170.41,26.44 170.41,27 171.03,27.62 171.03,28.77 171.14,28.88 172.47,28.88
+3V on TOP (solid shape): outline of 106 points within 65.28,89.62 69.52,94.72
+3V on TOP (solid shape): 65.27,34.08 65.36,34.04 65.37,33.95 65.36,33.91 65.36,33.87 65.61,33.62 65.87,33.87 65.87,33.91 65.86,33.95 65.87,34.04 65.95,34.08 66.09,34.08 66.37,33.8 66.37,33.79 66.43,33.69 66.53,33.63 66.54,33.63 67.31,32.86 67.32,32.83 67.32,32.8 67.28,32.72 67.27,32.63 67.37,32.37 67.63,32.27 67.67,32.26 67.71,32.21 67.79,32.16 67.88,32.15 68,32.15 68.04,32.13 68.07,32.11 68.72,32.11 68.85,31.97 68.85,31.74 68.65,31.54 68.33,31.54 68.31,31.54 68.21,31.61 68.11,31.63 67.93,31.56 67.86,31.38 67.86,31.35 67.86,31.32 67.85,31.31 67.82,31.28 67.43,31.28 67.38,31.32 67.37,31.34 67.37,31.38 67.29,31.56 67.11,31.63 67.07,31.64 65.88,32.82 65.87,32.84 65.87,32.87 65.79,33.05 65.61,33.13 65.58,33.13 65.56,33.14 65.52,33.19 65.2,33.19 64.85,33.54 64.85,33.78 64.86,33.83 64.87,33.87 64.86,33.94 64.87,33.96 64.99,34.08
+3V on TOP (solid shape): outline of 1022 points within 25.41,2.09 37.32,15.34
+3V on BOTTOM (solid shape): 41.08,115.43 41.08,114.79 41.01,114.72 39.93,114.72 39.83,114.82 39.83,115.58 39.89,115.63 40.88,115.63
+3V on BOTTOM (solid shape): 172.15,22.98 172.15,22.24 172.02,22.11 171.44,22.11 171.22,22.33 171.22,22.53 171.18,22.62 171.09,22.66 170.89,22.66 170.67,22.87 170.67,23.02 170.75,23.1 171.24,23.1 171.57,23.43 171.7,23.43
+3V on BOTTOM (solid shape): 66.95,90.82 66.95,88.85 66.44,88.34 66.16,88.34 66.1,88.32 66.03,88.26 66.01,88.25 64.2,88.25 64.07,88.38 64.07,90.16 64.2,90.28 64.45,90.28 64.79,90.63 64.79,91.72 65,91.93 65.83,91.93
+3V on BOTTOM (solid shape): 22.92,75 22.92,74.8 23.28,74.44 23.28,73.18 22.93,72.83 20.5,72.83 20.17,73.15 20.17,73.48 20.19,73.51 20.22,73.53 22.37,73.53 22.55,73.71 22.55,73.97 22.34,74.18 22.31,74.24 22.29,74.28 22.21,74.35 22.21,75.05 22.31,75.15 22.76,75.15
+3V on BOTTOM (solid shape): 23.71,86.48 23.71,85.19 23.55,85.04 22.76,85.04 22.09,84.37 22.09,83.73 21.94,83.58 21.59,83.58 21.5,83.5 21.5,82.93 21.45,82.89 21.07,82.89 20.99,82.91 20.92,82.92 20.85,82.91 20.78,82.89 20.69,82.89 20.54,82.74 20.54,82.26 20.4,82.12 20.37,82.08 20.34,82.03 20.32,82.01 20.29,82 20.25,82 20.22,82.01 20.2,82.04 20.16,82.13 20.11,82.2 19.88,82.43 19.88,83.52 20.62,84.26 20.64,84.26 22.95,86.56 23.62,86.56
+3V on BOTTOM (solid shape): 59.68,104.54 59.68,103.51 59.69,103.52 60.44,102.77 60.44,101.72 60.38,101.67 59.02,101.67 58.99,101.7 58.99,101.72 58.88,101.98 58.61,102.09 58.52,102.08 58.44,102.06 58.34,102.06 58.3,102.15 58.3,103.51 58.31,103.54 58.32,103.54 58.47,103.68 58.53,103.88 58.47,104.08 58.3,104.24 58.3,104.27 58.3,104.48 58.45,104.64 59.58,104.64
+3V on BOTTOM (solid shape): 24.55,39.66 24.55,38.21 24.44,38.11 23.28,38.11 23.22,38.13 23.18,38.14 20.71,38.14 20.46,38.39 20.27,38.39 20.23,38.4 20.2,38.4 20,38.4 19.97,38.4 19.93,38.39 19.82,38.39 19.78,38.4 19.75,38.4 19.55,38.4 19.52,38.4 19.48,38.39 19.26,38.39 19.1,38.55 19.09,38.56 18.99,38.73 18.81,38.82 18.8,38.82 18.8,39.67 18.95,39.82 19.06,39.82 19.08,39.81 19.09,39.8 19.37,39.69 19.64,39.8 19.66,39.81 19.68,39.82 20.41,39.82 20.64,39.59 20.64,39.57 20.77,39.33 21.02,39.24 21.14,39.26 21.25,39.32 22.55,39.32 23.09,39.85 24.35,39.85
+3V on BOTTOM (solid shape): outline of 112 points within 194.88,29.5 197.92,32.63
+3V on IN1 (solid shape): outline of 412 points within 171.98,27.54 188.7,32.94
+3V on IN2 (solid shape): outline of 618 points within 100.42,73.52 118.15,82.92
+3V on SVCC (solid shape): outline of 1107 points within 22.03,13.32 179.13,114.54
+3V on IN3 (solid shape): 107.75,83.29 107.75,81.64 107.53,81.42 105.72,81.42 104.42,82.72 104.42,83.69 104.35,83.76 104.34,83.77 104.21,83.96 104,84.04 103.9,84.02 103.81,83.98 103.79,83.97 103.76,83.97 103.66,84.07 103.66,85.1 103.72,85.16 105.87,85.16
+3V on IN3 (solid shape): outline of 518 points within 187.3,28.94 200.63,33.94
+3V on IN3 (solid shape): outline of 1672 points within 18.01,29.56 28.3,84.39
+3V_CCD_PWR1_C on BOTTOM (solid shape): 59.32,107.54 59.36,107.52 59.38,107.48 59.38,106.71 59.57,106.71 59.57,107.48 59.59,107.52 59.62,107.54 59.76,107.54 59.79,107.52 59.81,107.48 59.81,105.33 59.61,105.14 58.57,105.14 58.56,105.15 58.53,105.29 58.45,105.42 58.44,105.44 58.44,105.88 58.47,105.9 58.49,105.91 58.72,106.04 58.81,106.29 58.81,106.33 58.8,106.38 58.82,106.46 58.9,106.5 59,106.5 59.07,106.58 59.07,107.51 59.1,107.54
+3V_EC on TOP (solid shape): 167.02,24.86 167.05,24.84 167.07,24.81 167.07,24.2 166.85,23.98 166.59,23.98 166.49,24.04 166.38,24.06 166.32,24.06 166.31,24.07 166.29,24.07 166.28,24.06 164.89,24.06 164.87,24.09 164.87,24.25 164.87,24.25 164.99,24.25 165,24.25 166.31,24.25 166.42,24.36 166.42,24.38 166.44,24.42 166.44,24.46 166.44,24.66 166.45,24.69 166.46,24.71 166.61,24.86
+3V_EC on BOTTOM (solid shape): 169.61,25.67 169.91,25.51 170.22,25.67 170.74,25.67 171.6,24.8 171.6,23.82 171.21,23.43 170.62,23.43 170.55,23.51 170.55,24.15 170.58,24.17 170.76,24.31 170.83,24.52 170.72,24.79 170.45,24.9 170.35,24.89 170.25,24.85 169.87,24.85 169.74,24.95 169.58,24.98 169.43,24.95 169.31,24.87 169.3,24.85 169.23,24.85 169.22,24.87 169.09,24.95 168.95,24.98 168.68,24.87 168.56,24.6 168.57,24.55 168.34,24.32 167.88,24.32 167.65,24.09 167.65,23.78 167.13,23.26 166.8,23.26 166.68,23.26 165.37,23.26 165.25,23.38 165.25,24.16 164.94,24.48 164.94,24.87 165.06,25 165.3,25 165.43,24.87 166.06,24.87 166.15,24.81 166.25,24.78 166.27,24.77 167.16,24.77 167.82,25.43 167.85,25.43 167.96,25.37 168.08,25.35 168.31,25.43 168.45,25.63 168.46,25.67
+3V_GFX on BOTTOM (solid shape): 118.4,123.7 118.4,123.15 118.3,123.05 117.64,123.05 117.55,123.14 117.55,123.37 117.26,123.66 115.26,123.66 115.07,123.85 115.07,124.27 115.17,124.37 117.73,124.37
+3V_GFX on BOTTOM (solid shape): 112.08,125.69 112.08,125.08 111.94,124.94 110.92,124.94 110.91,124.95 110.1,124.95 110.03,125.02 110.03,125.37 110.04,125.42 110.04,125.46 110.04,125.5 110.03,125.55 110.03,125.78 110.08,125.83 111.94,125.83
+3V_GFX on BOTTOM (solid shape): 112.06,122.5 112.06,122.45 112.03,122.42 111.97,122.32 111.94,122.21 111.94,121.98 111.85,121.88 111.6,121.88 111.57,121.91 111.4,122.06 111.19,122.11 111.07,122.09 110.96,122.05 109.7,122.05 109.64,122.11 109.64,122.59 109.68,122.62 111.94,122.62
+3V_GFX on BOTTOM (solid shape): 76.48,105.44 76.48,105.01 76.15,104.68 75.74,104.68 75.61,104.56 75.15,104.56 75.15,104.74 75.41,105 75.49,105 75.54,104.99 75.59,104.99 75.73,104.99 75.77,104.99 75.9,105 76.05,105.16 76.06,105.39 76.07,105.43 76.11,105.44 76.47,105.44
+3V_GFX on BOTTOM (solid shape): 120.01,88.23 120.01,88.23 120.38,87.86 120.38,86.91 120.34,86.87 119.7,86.87 119.62,86.87 119.57,86.93 119.57,87.52 119.51,87.58 119.51,87.74 119.38,88.06 119.06,88.19 119.02,88.19 118.94,88.21 118.91,88.29 118.91,88.48 119.06,88.63 119.61,88.63
+3V_GFX on BOTTOM (solid shape): 109.7,120.38 109.69,119.9 109.66,119.82 109.59,119.8 109.56,119.8 109.35,119.72 109.22,119.53 109.22,119.51 109.19,119.49 108.98,119.49 108.96,119.5 108.94,119.52 108.85,119.64 108.73,119.71 108.6,119.83 108.6,120.43 108.63,120.46 109.61,120.46
+3V_GFX on IN1 (solid shape): outline of 1910 points within 105.06,109.44 128.32,125.97
+3V_LAN on TOP (solid shape): 41.69,110.63 41.69,108.74 42,108.43 43.24,108.43 43.33,108.33 43.33,107.07 43.28,107.01 43.09,107.01 43.06,107.02 42.84,107.27 42.54,107.36 42.2,107.36 42.03,107.45 41.85,107.48 41.82,107.48 41.7,107.7 41.46,107.78 41.25,107.71 41.1,107.49 41.07,107.48 40.58,107.48 40.42,107.64 40.42,110.96 40.57,111.11 41.21,111.11
+3V_LAN on TOP (solid shape): 54.27,112.57 54.27,110.72 54.14,110.58 53.15,110.58 53.15,110.63 52.77,110.98 52.39,110.63 52.38,110.58 47.61,110.58 47.16,111.04 46.96,111.04 46.88,111.08 46.86,111.16 46.88,111.26 46.89,111.36 46.89,111.67 46.9,111.7 46.94,111.72 49.73,111.72 49.92,111.91 51.68,111.91 52.18,112.41 52.18,112.61 52.21,112.68 52.28,112.71 52.52,112.76 52.73,112.89 53.95,112.89
+3V_LDO_EC on TOP (solid shape): 181.72,32.84 181.8,32.8 181.82,32.73 181.82,32.71 181.91,32.46 182.14,32.33 182.15,32.33 182.19,32.29 182.19,31.8 182.12,31.73 181.76,31.73 181.67,31.82 181.67,32.04 181.23,32.48 181.23,32.62 181.24,32.66 181.24,32.76 181.25,32.78 181.31,32.84
+3V_LDO_EC on TOP (solid shape): 174.92,32.41 174.92,32.27 174.93,32.17 174.98,32.08 174.99,32.07 174.99,32.06 175.37,31.68 175.37,30.84 175.25,30.72 175.11,30.72 175.09,30.74 175.06,30.78 175.03,30.81 174.9,30.95 174.9,31.27 174.8,31.36 174.75,31.42 174.7,31.47 174.53,31.63 174.54,31.79 174.54,31.99 174.53,32.13 174.41,32.26 174.04,32.26 173.98,32.2 173.89,32.2 173.87,32.21 173.79,32.26 173.7,32.27 173.24,32.27 173.21,32.28 173.19,32.32 173.19,32.95 173.32,33.07 174.26,33.07
+3V_S5 on TOP (solid shape): 100.62,37.11 101.1,37.11 101.16,37.05 101.16,36.54 101.03,36.41 100.29,36.41 99.93,36.77 98.44,36.77 98.44,37.11 100.62,37.11
+3V_S5 on TOP (solid shape): 153.22,25.77 153.22,23.74 153.11,23.62 150.17,23.62 149.95,23.84 149.95,25.77 150.08,25.89 150.59,25.89 150.59,25.89 153.1,25.89
+3V_S5 on TOP (solid shape): 50.66,23.44 50.66,22.49 49.84,21.68 46.92,21.68 46.32,22.29 46.32,25.87 46.33,25.9 46.37,25.92 48.18,25.92
+3V_S5 on TOP (solid shape): 86.17,114.16 87.49,114.16 87.49,113.91 86.29,113.91 86.07,113.68 83.32,113.68 83.02,113.98 83.02,114.34 83.12,114.44 84.26,114.44 84.44,114.62 85.71,114.62
+3V_S5 on TOP (solid shape): 93.32,30.69 93.32,29.72 93.16,29.55 92.61,29.55 92.56,29.6 92.56,29.62 92.53,29.73 92.46,29.83 92.46,30.74 92.53,30.8 93.2,30.8
+3V_S5 on TOP (solid shape): 51.62,114.06 51.64,113.93 51.67,113.84 51.67,112.62 51.47,112.42 50.04,112.42 49.91,112.55 49.91,113.49 49.76,113.64 49.76,114.03 49.86,114.14 51.54,114.14
+3V_S5 on TOP (solid shape): 198.52,33.79 198.52,31.79 198.42,31.69 197.44,31.69 197.34,31.79 197.34,31.79 197.34,31.93 197.24,32.03 197.21,32.12 197.28,32.19 197.38,32.84 196.76,32.62 196.76,32.6 196.75,32.59 196.71,32.57 196.68,32.59 196.65,32.61 195.5,32.61 195.06,32.64 194.89,32.23 194.89,32.22 194.88,32.2 194.8,32.12 193.72,32.12 193.66,32.13 193.66,32.13 193.42,32.13 193.22,31.93 193.22,31.34 193.07,31.19 192.51,31.19 192.49,31.19 192.47,31.2 192.35,31.33 191.82,31.33 191.79,31.34 191.77,31.36 191.76,31.39 191.76,33.24 191.83,33.3 191.84,33.3 193.45,33.54 195.05,33.84 198.46,33.84
+3V_S5 on BOTTOM (solid shape): 100.24,79.87 100.24,79.76 100.23,79.72 100.23,79.66 99.88,79.31 99.82,79.22 99.8,79.12 99.8,79.1 99.8,78.64 99.63,78.48 99.16,78.48 99.09,78.54 99.09,79.79 99.27,79.97 100.14,79.97
+3V_S5 on BOTTOM (solid shape): outline of 109 points within 68.64,17.13 87.43,31.4
+3V_S5 on IN2 (solid shape): 172.34,33.22 172.36,33.19 172.35,33.16 172.6,32.63 173,33.05 173.02,33.14 173.1,33.18 173.47,33.18 173.57,33.11 173.55,33 173.47,32.89 173.44,32.75 173.8,32.4 174.15,32.75 174.13,32.89 174.05,33 174.03,33.11 174.12,33.18 174.7,33.18 174.78,33.14 174.8,33.05 174.97,32.67 175.39,32.72 175.46,32.75 175.53,32.72 175.81,32.63 176.07,32.77 176.11,32.79 176.15,32.77 176.51,32.66 176.77,32.95 176.78,32.98 176.82,32.99 176.92,32.99 176.93,32.98 176.93,32.11 176.93,32.1 176.92,32.08 176.89,32.05 176.86,32 176.71,31.85 171.78,31.85 171.64,32 171.64,32.56 171.61,32.58 171.61,32.6 171.52,32.75 171.37,32.84 171.35,32.84 171.04,33.15 171.04,33.7 171.27,33.92 171.64,33.92
+3V_S5 on IN2 (solid shape): outline of 357 points within 190.58,27.45 197.96,34.14
+3V_S5 on IN2 (solid shape): outline of 414 points within 86.22,27.52 101.28,37.19
+3V_S5 on IN2 (solid shape): outline of 6979 points within 20.31,19.05 85.64,122.86
+3V_S5 on SVCC (solid shape): outline of 168 points within 47.31,16.75 197.8,30.34
+3V_SSD on TOP (solid shape): 23.78,6.35 23.78,5.16 24.05,4.89 24.05,4.7 24.05,4.69 24.05,4.35 24.51,3.89 24.51,2.08 24.49,2.05 24.46,2.03 21.56,2.03 21.45,2.14 21.45,3.12 22,3.66 22,6.36 22.2,6.57 23.56,6.57
+3V_SSD on TOP (solid shape): 33.85,4.27 35.61,4.27 35.63,4.27 35.69,4.28 35.76,4.3 36.26,4.3 36.3,4.3 38.88,4.3 38.97,4.3 39.47,4.3 39.65,4.12 39.67,4.06 39.69,4.01 39.69,3.29 39.42,3.02 35.63,3.02 35.61,3.04 34.39,3.04 32.5,4.94 31.46,4.94 30.77,4.25 30.26,4.25 30.19,4.33 30.19,4.79 30.69,5.29 32.83,5.29
+3V_SSD on BOTTOM (solid shape): 39.63,4.24 39.64,4.22 39.68,4.04 39.75,3.87 39.75,1.31 39.73,1.29 39.5,1.29 39.46,1.3 39.45,1.34 39.45,2.85 39.25,2.85 39.25,1.34 39.24,1.3 39.2,1.29 39,1.29 38.95,1.34 38.95,2.78 38.95,2.78 38.95,2.92 38.85,3.03 37.33,3.03 37.26,2.95 37.26,2.85 37.25,2.85 37.25,1.4 37.18,1.33 37,1.33 36.96,1.34 36.95,1.38 36.95,2.85 36.75,2.85 36.75,1.38 36.74,1.34 36.7,1.33 36.5,1.33 36.46,1.34 36.45,1.38 36.45,2.85 36.25,2.85 36.25,1.38 36.24,1.34 36.2,1.33 36,1.33 35.96,1.34 35.95,1.38 35.95,2.85 35.75,2.85 35.75,1.38 35.74,1.34 35.7,1.33 35.48,1.33 35.45,1.36 35.45,2.85 35.36,2.94 35.36,4.13 35.51,4.28 35.53,4.28 35.58,4.28 35.62,4.27 35.71,4.29 35.8,4.32 35.81,4.32 39.55,4.32
+3V_SSD on BOTTOM (solid shape): 24.66,9.03 24.66,7.63 24.62,7.56 24.55,7.53 24.52,7.53 24.22,7.4 24.09,7.1 24.12,6.93 24.22,6.79 24.25,6.72 24.22,6.64 24.12,6.5 24.09,6.34 24.13,6.15 24.26,5.98 24.27,5.96 24.27,4.43 22.88,3.05 22.84,3 22.81,2.93 22.73,2.85 22.73,1.33 22.7,1.3 22.5,1.3 22.46,1.31 22.45,1.35 22.45,2.85 22.25,2.85 22.25,1.35 22.24,1.31 22.2,1.3 22,1.3 21.96,1.31 21.95,1.35 21.95,2.85 21.75,2.85 21.75,1.35 21.74,1.31 21.7,1.3 21.5,1.3 21.45,1.35 21.45,1.8 21.44,1.82 21.44,3.11 22.01,3.68 22.01,6.44 23.72,8.15 23.72,9.02 23.95,9.25 24.44,9.25
+3V_SSD on IN1 (solid shape): outline of 357 points within 22.23,2.03 39.69,5.96
+3V_USB on BOTTOM (solid shape): 100.94,83.74 100.94,83.73 101.02,83.62 101.12,83.55 101.13,83.54 101.26,83.41 101.26,80.56 101.25,80.52 101.21,80.5 101.03,80.5 100.91,80.48 100.81,80.42 100.67,80.28 99.77,80.28 99.61,80.43 99.61,80.46 99.62,80.48 99.8,80.67 99.86,80.89 99.83,81.06 99.73,81.2 99.68,81.25 99.68,82.54 99.67,82.66 99.62,82.77 99.61,82.78 99.61,82.87 98.78,83.7 98.78,84.44 98.8,84.47 98.83,84.49 99.8,84.49 99.8,84.49 100.18,84.49
+3V_USB on BOTTOM (solid shape): outline of 92 points within 95.73,88.51 102.11,93.2
+3V_USB on IN2 (solid shape): outline of 390 points within 92.3,81.27 103.13,89.22
+3V_USB_D on BOTTOM (solid shape): 97.64,90.94 97.64,90.57 98.92,89.29 98.92,88.05 98.77,87.91 98.11,87.91 98.07,87.92 98.06,87.96 98.06,88.93 98.05,88.93 98.05,89.06 96.95,90.16 96.95,90.8 96.95,90.8 96.95,91.1 97.02,91.16 97.43,91.16
+3V_WLAN_P on TOP (solid shape): outline of 448 points within 187.97,10.78 194.75,32.63
+3V_WLAN_P on BOTTOM (solid shape): 193.28,31.12 193.28,30.9 193.29,30.89 193.29,30.81 193.43,30.67 193.46,30.64 193.82,30.64 193.84,30.62 193.84,29.59 193.81,29.57 193.27,29.57 193.04,29.34 193.04,28.81 193.05,28.81 193.05,28.44 192.93,28.32 191.89,28.32 191.8,28.41 191.8,30.18 191.74,30.24 190.03,30.24 190,30.27 190,30.53 191.55,30.53 191.55,30.72 191.55,30.73 190,30.73 190,31.04 191.78,31.04 191.95,31.2 193.2,31.2
+3V_WLAN_P on BOTTOM (solid shape): 191.68,13.5 191.78,13.4 191.78,13.37 191.79,13.32 191.81,13.27 191.84,13.22 191.87,13.17 191.91,13.13 191.96,13.1 192.01,13.07 192.06,13.05 192.11,13.04 192.14,13.04 192.28,12.91 192.32,12.88 192.36,12.85 192.37,12.82 192.37,12.33 192.52,12.18 194.35,12.18 194.58,12.41 195.01,12.41 195.05,12.37 195.05,11.68 194.81,11.44 194.02,11.44 193.96,11.38 193.96,10.85 193.91,10.8 193.46,10.8 193.06,11.21 191.51,11.21 191.46,11.15 190.52,11.15 190.51,11.16 189.86,11.16 189.64,11.38 189.63,11.41 189.66,11.47 189.68,11.56 189.71,11.66 189.72,11.75 189.73,11.85 189.72,11.95 189.72,12.05 189.7,12.14 189.67,12.24 189.64,12.33 189.6,12.42 189.57,12.47 189.57,13.02 189.57,13.03 191.55,13.03 191.55,13.23 190,13.23 190,13.03 189.57,13.03 189.58,13.06 189.6,13.07 189.64,13.08 189.7,13.1 189.75,13.12 189.79,13.16 189.84,13.2 189.87,13.25 189.9,13.3 189.92,13.35 189.92,13.39 190.05,13.52 191.64,13.52
+3V_WLAN_P on BOTTOM (solid shape): 181.6,20.82 181.6,20.15 181.47,20.02 181.01,20.02 180.88,19.89 180.88,19.85 180.86,19.83 180.83,19.79 180.83,19.74 180.83,19.36 180.83,19.31 180.86,19.27 180.88,19.26 180.88,19.13 181.2,18.81 181.2,17.47 181.03,17.3 180.85,17.3 180.63,17.08 180.63,16.46 180.84,16.26 181.62,16.26 182.29,15.59 182.29,12.23 182.12,12.06 181.62,12.06 181.55,12.13 181.55,12.74 181.75,12.93 181.75,14.39 181.65,14.49 181.65,14.96 180.92,15.7 180,15.7 179.85,15.86 179.85,16.95 179.87,17.02 180.2,17.17 180.3,17.43 180.28,17.57 180.21,17.69 180.18,17.76 180.21,17.83 180.42,18.04 180.42,18.85 180.5,18.92 180.5,19.87 180.52,19.96 180.52,20.05 180.52,20.14 180.5,20.24 180.5,20.63 180.8,20.94 181.49,20.94
+3V_WLAN_P on IN1 (solid shape): 188.15,14.16 189.77,14.16 189.82,14.21 190.87,14.21 191.95,13.13 191.95,11.82 191.31,11.17 190.22,11.17 189.71,11.68 189.71,11.71 189.36,12.76 188.3,13.09 187.76,12.86 187.39,12.4 181.59,12.4 181.55,12.45 181.55,12.89 181.56,12.92 181.57,12.93 181.62,13.02 181.65,13.12 181.66,13.14 181.81,13.3 184.11,13.3 184.16,13.27 184.16,13.26 184.29,13.14 184.47,13.09 184.6,13.12 184.71,13.19 184.78,13.22 184.85,13.19 184.97,13.12 185.1,13.09 185.27,13.14 185.4,13.26 185.41,13.27 185.45,13.3 185.51,13.3 185.55,13.27 185.56,13.26 185.69,13.14 185.86,13.09 186.11,13.2 186.22,13.45 186.22,13.51 186.92,14.21 188.1,14.21
+3VLCD_CON on TOP (solid shape): 64.69,105.35 64.69,104.81 64.56,104.68 64.56,104.36 64.33,104.13 63.89,104.13 63.85,104.17 62.61,104.17 62.56,104.21 62.56,104.42 62.55,104.44 62.55,105.42 62.59,105.46 62.69,105.46 62.96,105.74 64.3,105.74
+3VLCD_CON on BOTTOM (solid shape): 65.47,94.86 65.47,94.09 65.85,93.71 65.85,92.44 65.72,92.32 63.56,92.32 63.43,92.44 63.43,94.86 63.56,94.98 65.34,94.98
+3VLCD_CON on SVCC (solid shape): 66.1,104.78 66.1,101.08 66.12,100.98 66.18,100.9 67.24,99.83 67.24,93.82 66.94,93.51 66.92,93.49 66.9,93.46 64.05,93.46 63.87,93.64 63.79,93.69 63.69,93.71 60.37,93.71 60.01,94.07 60.01,104.27 60.73,105 60.81,104.97 60.89,104.96 61.2,105.09 61.33,105.4 61.32,105.48 61.29,105.56 61.64,105.9 64.98,105.9
+3VLCD_CON_R on TOP (solid shape): 61.91,106.78 62.64,106.78 62.71,106.71 62.71,105.87 62.56,105.73 62.4,105.73 61.94,105.27 61.94,104.21 61.83,104.1 61.16,104.1 60.63,104.63 60.63,106.42 60.89,106.68 60.89,106.68 60.99,106.79 61.9,106.79
+3VLCD_CON_R on BOTTOM (solid shape): 61.37,107.52 61.37,106.61 61.99,105.99 61.99,104.7 61.83,104.53 60.15,104.53 60.06,104.62 60.06,106.71 61.07,106.71 61.07,107.54 60.87,107.54 60.87,106.71 60.57,106.71 60.57,107.54 60.37,107.54 60.37,106.71 60.07,106.71 60.07,107.61 60.14,107.67 61.22,107.67
+3VLCD_CON_R_C on TOP (solid shape): 62.68,108.39 62.68,107.21 62.63,107.16 61.71,107.16 61.6,107.27 61.6,107.91 61.44,108.07 61.44,108.54 61.54,108.63 62.43,108.63
+3VLCD_CON_R_C on BOTTOM (solid shape): 62.24,108.61 62.24,107.96 61.87,107.59 61.87,106.75 61.83,106.71 61.64,106.71 61.63,106.71 61.63,107.63 61.44,107.82 61.44,108.02 61.45,108.03 61.45,108.43 61.45,108.44 61.45,108.6 61.54,108.69 62.16,108.69
+3VPCU on TOP (solid shape): 99.94,32.54 99.94,31.66 99.88,31.61 98.68,31.61 98.49,31.8 98.49,32.5 98.64,32.65 99.82,32.65
+3VPCU on TOP (solid shape): 58.88,101.83 58.88,100.96 58.31,100.39 57.68,100.39 57.57,100.5 57.57,100.84 57.66,100.93 57.97,100.93 58.24,101.2 58.24,101.69 58.23,101.7 58.23,101.84 58.36,101.97 58.74,101.97
+3VPCU on TOP (solid shape): 53.3,108.01 53.3,107.79 53.06,107.56 53.06,107.4 52.97,107.32 51.89,107.32 51.79,107.42 51.79,107.63 51.91,107.75 51.98,107.75 52,107.74 52.12,107.66 52.26,107.63 52.48,107.7 52.62,107.89 52.62,107.9 52.93,108.21 53.1,108.21
+3VPCU on TOP (solid shape): 138.22,29.19 138.23,29.13 138.23,29.09 138.23,28.21 138.21,28.18 138.19,28.18 138.1,28.16 138.02,28.11 138.01,28.1 137.94,28.1 137.67,28.38 137.57,28.45 137.45,28.47 136.82,28.47 136.71,28.45 136.61,28.38 136.12,27.89 135.66,27.89 135.57,27.97 135.57,28.82 135.59,28.84 135.59,29.3 135.71,29.41 138,29.41
+3VPCU on TOP (solid shape): outline of 94 points within 152.46,29.69 164.51,36.31
+3VPCU on BOTTOM (solid shape): 138.84,30.19 138.84,28.84 138.19,28.2 138.15,28.2 138.12,28.17 137.81,28.17 137.69,28.3 137.69,28.55 137.81,28.68 138.15,28.68 138.36,28.89 138.36,30.06 138.37,30.06 138.37,30.18 138.45,30.26 138.77,30.26
+3VPCU on BOTTOM (solid shape): 51.38,24.42 51.65,24.42 51.9,24.17 51.9,22.82 51.88,22.8 51.88,22.41 51.86,22.38 51.83,22.36 51.65,22.36 51.62,22.39 51.62,22.82 51.05,23.39 50.76,23.39 50.7,23.45 50.7,23.69 50.69,23.7 50.69,24.46 50.86,24.63 51.17,24.63
+3VPCU on BOTTOM (solid shape): 122.44,83.08 122.45,83.05 122.45,80.28 122.31,80.13 120.9,80.13 120.78,80.26 120.78,82.71 120.79,82.73 120.9,82.88 120.94,83.04 120.94,83.1 120.96,83.18 121.04,83.21 122.31,83.21
+3VPCU on BOTTOM (solid shape): 193.03,24.35 193.04,24.35 193.04,23.05 192.98,22.99 192.94,22.96 192.89,22.92 192.63,22.92 192.56,22.99 192.56,22.99 192.56,23.13 192.47,23.22 192.3,23.22 192.29,23.22 191.91,23.22 191.77,23.36 191.77,23.99 191.82,24.08 191.93,24.08 192.03,24.03 192.14,24.01 192.4,24.12 192.53,24.4 192.57,24.41 192.97,24.41
+3VPCU on IN2 (solid shape): 124.01,83.04 125.05,81.91 126.53,81.49 127.54,81.68 128.42,82.22 129.73,82.22 130.2,81.74 130.2,81.68 130.61,81.27 130.61,81.04 130.57,80.94 130.55,80.83 130.56,80.76 130.59,80.67 130.59,79.38 130.2,78.99 130.2,78.05 130.04,77.89 129.14,77.89 129.08,77.95 129.07,77.99 129.09,78 129.14,78.11 129.15,78.23 129.11,78.41 128.97,78.58 128.96,78.6 128.96,78.64 128.97,78.67 129.1,78.83 129.15,79.01 129.1,79.19 128.97,79.35 128.96,79.38 128.96,79.42 128.97,79.44 129.11,79.61 129.15,79.79 129.03,80.08 128.74,80.2 128.56,80.15 128.41,80.03 127.87,79.49 121.53,79.49 120.49,80.53 120.49,82.59 120.52,82.66 120.59,82.69 120.8,82.78 120.91,82.99 120.93,83.02 120.96,83.04
+3VPCU on SVCC (solid shape): outline of 1120 points within 98.87,18.02 212.53,81.01
+3VPCU_EC on TOP (solid shape): 169.32,31.6 169.43,31.6 169.43,31.61 169.61,31.6 169.79,31.6 169.8,31.6 169.8,31.41 170.11,31.09 170.11,29.09 170.09,29.07 169.94,29.07 169.92,29.09 169.92,29.81 169.92,29.86 169.92,30.57 169.87,30.62 169.84,30.62 169.77,30.67 169.72,30.68 168.86,30.68 168.78,30.72 168.75,30.8 168.76,30.83 168.76,31.79 168.77,31.83 168.81,31.84 169.07,31.84
+3VPCU_EC on TOP (solid shape): 164.02,18.96 164.03,18.94 164.02,18.86 164.13,18.59 164.4,18.48 164.48,18.48 164.5,18.48 164.72,18.25 165.55,18.25 165.57,18.25 166.27,18.25 166.31,18.21 166.31,18.12 166.25,18.06 165.75,18.06 165.66,18.1 165.57,18.11 164.65,18.11 164.59,18.11 164.52,18.09 164.13,18.09 163.83,18.4 162.62,18.4 162.57,18.45 162.57,18.63 162.59,18.67 162.62,18.7 162.7,18.82 162.72,18.95 162.72,19.05 162.99,19.32 163.65,19.32
+3VPCU_EC on TOP (solid shape): 181.27,26.65 182.99,26.65 183.03,26.66 183.28,26.66 183.47,26.46 183.47,26.41 183.45,26.34 183.45,26.28 183.45,26.21 183.47,26.14 183.47,26.07 183.61,25.93 183.73,25.93 183.77,25.92 183.8,25.92 184.11,25.92 184.15,25.92 184.19,25.93 184.61,25.93 184.68,25.85 184.68,25.48 184.62,25.41 183.33,25.41 182.3,26.44 182.03,26.44 182.02,26.46 181.46,26.46 181.37,26.5 181.27,26.51 180.54,26.51 180.5,26.53 180.49,26.56 180.49,26.61 180.5,26.64 180.54,26.66 181.2,26.66
+3VPCU_EC on SVCC (solid shape): 167.88,32.85 167.82,32.74 167.8,32.63 167.91,32.36 168.18,32.24 168.3,32.26 168.41,32.32 169.43,31.3 169.51,31.25 169.61,31.23 172.8,31.23 173.06,30.97 173.06,30.95 173.17,30.7 173.42,30.59 173.44,30.59 175.47,28.56 175.59,28.33 175.81,28.22 175.88,28.19 175.96,28.18 184.36,28.18 184.72,27.82 184.72,24.53 184.63,24.4 184.59,24.24 184.63,24.09 184.72,23.96 184.72,21.68 184.36,21.32 180,21.32 179.64,21.68 179.64,22.59 179.73,22.72 179.77,22.87 179.73,23.03 179.64,23.16 179.64,24.28 179.8,24.42 179.86,24.62 179.75,24.89 179.48,25.01 179.43,25 179.38,24.99 179.06,25.31 178.98,25.37 178.88,25.39 165.01,25.39 164.53,25.87 164.53,27.8 164.71,27.94 164.78,28.16 164.71,28.38 164.53,28.52 164.53,32.9 164.89,33.26 167.47,33.26
+3VPCU_ECPLL on TOP (solid shape): 166.72,31.61 166.99,31.61 167.03,31.61 167.07,31.6 167.1,31.61 167.14,31.61 167.39,31.61 167.58,31.42 167.61,31.4 167.65,31.37 167.71,31.31 167.71,31.03 167.71,29.81 167.71,29.78 167.71,29.24 167.7,29.2 167.66,29.19 167.57,29.19 167.53,29.2 167.52,29.24 167.52,29.74 167.52,29.81 167.52,30.44 167.52,30.56 167.51,30.56 167.51,30.66 167.15,31.01 167.03,31.01 166.98,31.02 166.94,31.03 166.03,31.03 165.91,31.15 165.91,31.6 166,31.69 166.65,31.69
+3VRTC on TOP (solid shape): 98.23,31.74 98.23,31.34 98.23,30.87 98.23,30.85 98.49,30.59 98.49,29.3 98.21,29.02 98.18,29.02 97.91,28.91 97.8,28.64 97.81,28.57 97.83,28.5 97.83,28.28 97.72,28.18 96.71,28.18 96.45,28.43 96.45,29.14 96.46,29.2 96.46,29.33 96.69,29.56 96.7,29.58 96.77,29.61 96.84,29.59 96.96,29.53 97.09,29.51 97.4,29.64 97.53,29.96 97.5,30.13 97.4,30.27 97.28,30.4 97.13,30.5 96.96,30.53 96.44,30.53 96.38,30.53 96.3,30.51 96.28,30.52 96.07,30.72 95.17,30.72 95,30.88 95,31.21 95.06,31.41 95,31.6 95,31.85 95.14,31.99 97.98,31.99
+5V on TOP (solid shape): 216.52,16.87 216.52,16.28 217.07,15.72 217.07,14.48 216.69,14.1 215.4,14.1 215.23,13.93 214.04,13.93 213.82,14.15 213.82,16.18 213.9,16.26 214.27,16.26 215,17 216.39,17
+5V on TOP (solid shape): 16.18,86.33 16.36,86.21 16.57,86.17 16.98,86.17 17.07,86.08 17.07,84.69 16.99,84.6 15.74,84.6 15.35,84.99 15.34,85.01 15.34,85.03 15.34,85.49 15.2,85.63 15.2,86.35 15.39,86.53 15.98,86.53
