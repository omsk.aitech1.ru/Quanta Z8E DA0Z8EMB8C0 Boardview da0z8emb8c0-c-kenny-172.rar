# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_A7: length 145.6
  TOP w0.102: v2(34.52,80.9) 34.52,80.91 v2(31.68,80.91) 31.02,80.91 30.8,81.14 R2330.2
  TOP w0.165: U2014.R8 v2(34.55,45.95) ; v2(34.55,35.36) 34.55,35.33 U2013.R8 ; U2017.R8 v2(34.55,69.55) ; U2018.R8 v2(34.52,80.9)
  IN2 w0.089: v2(34.52,80.9) 34.48,80.95 34.48,81.14 34.61,81.27 34.99,81.27 35.11,81.14 35.11,77.71 33.08,75.68 33.08,74.96 34.1,73.95 34.1,70.34 34.55,69.89 v2(34.55,69.55) 34.61,69.49 34.61,64.5 35.37,63.74 35.37,57.39 35.62,57.14 35.62,55.23 35.75,55.1 36.38,55.1 36.51,54.98 36.51,54.72 36.38,54.6 35.75,54.6 35.62,54.47 35.62,53.71 35.49,53.58 33.84,53.58 33.72,53.45 33.72,53.2 33.84,53.07 34.48,53.07 34.61,52.95 34.61,52.69 34.48,52.56 33.84,52.56 33.72,52.44 33.72,48.81 34.73,47.8 34.73,46.13 v2(34.55,45.95) 34.86,45.64 34.86,40.88 34.22,40.25 33.72,40.25 33.59,40.12 33.59,38.21 33.97,37.83 34.35,37.83 34.48,37.71 34.48,37.45 34.35,37.32 33.81,37.32 33.72,37.24 33.72,36.9 33.81,36.82 34.35,36.82 34.48,36.69 34.48,36.44 34.35,36.31 34.1,36.31 33.97,36.18 33.97,35.93 v2(34.55,35.36)
  IN3 w0.133: v2(76.36,60.13) 75.77,60.72 75.77,60.89 76.22,61.33 76.22,61.5 76.1,61.62 75.93,61.62 75.49,61.17 75.32,61.17 75.07,61.43 73.91,61.43 73.37,61.96 72.01,62.53 69.42,63.04 68.25,63.53 66.45,63.88 60.22,63.88 57.49,65.01 51.73,65.01 51.3,64.58 48.15,64.58 47.58,64.01 41.76,64.01 33.3,60.5 28.88,56.08 28.04,54.07 27.51,51.41 27.27,48.94 27.27,44.84 27.57,43.34 27.74,42.92 27.95,42.71 29.22,40.81 29.22,40.81 31.28,37.72 32.14,36.87 33.64,36.87 33.95,36.56 33.95,35.96 v2(34.55,35.36)
  BOTTOM w0.089: 79,59.31 79.35,59.31 79.52,59.14 79.88,59.14 U2030.Y30
  BOTTOM w0.102: 79,59.31 78.97,59.28 77.81,59.28 77.66,59.42 77.26,59.42
  BOTTOM w0.165: 77.26,59.42 77.15,59.42 76.44,60.13 v2(76.36,60.13)
M_B_A8: length 146.7
  TOP w0.102: v2(33.34,89.52) R2302.2
  TOP w0.165: v2(34.56,50.73) 34.56,50.76 U2014.R2 ; U2013.R2 35.32,39.36 v2(35.32,39.36) ; v2(34.53,85.71) 34.92,86.11 U2018.R2 ; U2017.R2 34.54,74.34 v2(34.54,74.33)
  IN1 w0.089: v2(34.53,85.71) 34.73,85.5 34.73,82.92 34.99,82.66 34.99,78.22 34.86,78.09 34.22,78.09 34.1,77.96 34.1,77.71 34.22,77.58 34.86,77.58 34.99,77.46 34.99,77.2 34.86,77.08 34.22,77.08 34.1,76.95 34.1,74.66 34.43,74.33 v2(34.54,74.33) 34.9,73.97 34.9,72.92 34.48,72.5 34.48,70.6 35.23,69.85 35.23,68.32 36.26,67.3 36.26,57.77 36.38,57.64 37.53,57.64 37.65,57.52 37.65,57.26 37.53,57.14 36.38,57.14 36.26,57.01 36.26,56.76 36.38,56.63 36.76,56.63 36.89,56.5 36.89,53.96 34.86,51.93 34.35,51.93 34.1,51.68 34.1,51.19 v2(34.56,50.73) 34.99,50.73 35.11,50.6 35.11,49.77 34.61,49.26 34.61,47.1 35.24,46.47 35.24,40.75 34.86,40.37 34.86,39.08 35.16,38.78 35.41,38.78 35.56,38.93 35.56,39.11 v2(35.32,39.36)
  IN3 w0.089: v2(33.34,89.52) 33.72,89.14 33.72,86.52 v2(34.53,85.71)
  IN3 w0.133: v2(35.32,39.36) 35.32,39.57 35.06,39.82 34.89,39.82 34.71,39.64 34.55,39.64 34.43,39.76 34.43,39.93 34.61,40.11 34.61,40.27 34.34,40.54 34.34,41.11 32.34,43.11 32.34,43.63 31.14,44.83 31.14,48.66 30.79,49.01 30.79,51.05 31.42,52.56 32.6,53.75 32.6,53.91 32.42,54.1 32.42,54.26 32.54,54.38 32.7,54.38 32.89,54.2 33.05,54.2 33.17,54.31 33.17,54.48 32.61,55.04 32.61,55.21 32.73,55.32 32.89,55.32 33.45,54.76 33.62,54.76 33.74,54.88 33.74,55.04 33.46,55.33 33.46,55.49 33.57,55.61 33.74,55.61 34.02,55.33 34.19,55.33 34.35,55.49 34.35,55.74 34.48,55.87 34.72,55.87 34.9,56.04 34.9,56.77 36.21,58.08 40.3,59.77 49.69,59.77 51.24,61.32 56.85,61.32 58.27,60.74 59.05,59.96 65.74,59.96 66.85,58.85 68.32,58.85 68.44,58.74 68.44,58.53 68.57,58.4 68.77,58.4 68.9,58.53 68.9,58.9 69.02,59.03 69.18,59.03 69.31,58.9 69.31,58.03 69.43,57.91 69.63,57.91 69.76,58.03 69.76,58.77 69.88,58.89 70.06,58.89 70.18,58.77 70.18,57.79 70.29,57.68 70.49,57.68 70.61,57.8 70.61,58.78 70.73,58.89 70.89,58.89 71.01,58.78 71.01,57.8 71.13,57.68 71.29,57.68 71.41,57.8 71.41,58.78 71.53,58.89 71.69,58.89 71.81,58.78 71.81,57.8 71.93,57.68 72.16,57.68 72.28,57.81 72.28,58.77 72.41,58.89 72.71,58.89 72.83,58.77 72.83,58.66 72.96,58.53 72.96,58.53 73.64,58.53 73.98,58.2 v2(73.98,58.1)
  BOTTOM w0.089: U2030.AA31 78.97,58.51
  BOTTOM w0.102: 78.97,58.51 78.83,58.66 78.04,58.66 77.86,58.48 76.31,58.48
  BOTTOM w0.165: 76.31,58.48 76.08,58.48 75.7,58.1 v2(73.98,58.1)
M_B_A9: length 147.7
  TOP w0.102: v2(34.52,82.51) 33.73,83.3 33.21,83.3 31.56,84.95 R2329.2
  TOP w0.165: U2014.R7 34.31,47.74 v2(34.2,47.74) ; U2017.R7 34.17,71.49 v2(33.65,71.49) ; v2(34.52,82.51) U2018.R7 ; U2013.R7 34.25,36.44 v2(33.46,36.44)
  IN2 w0.089: v2(34.52,82.51) 34.76,82.51 34.86,82.41 34.86,81.65 34.73,81.52 34.19,81.52 34.1,81.43 34.1,80.59 34.19,80.5 34.77,80.5 34.86,80.41 34.86,77.84 32.83,75.81 32.83,74.88 33.46,74.24 33.46,73.15 33.08,72.76 33.08,72.06 v2(33.65,71.49) 33.08,70.92 33.08,69.46 34.35,68.19 34.35,64.38 35.11,63.61 35.11,57.26 35.37,57.01 35.37,54.98 35.24,54.85 34.22,54.85 34.1,54.72 34.1,54.47 34.22,54.34 35.24,54.34 35.37,54.22 35.37,53.96 35.24,53.83 33.59,53.83 33.46,53.71 33.46,48.47 v2(34.2,47.74) 33.84,47.38 33.62,47.38 33.21,46.98 33.21,45.41 33.3,45.33 34.52,45.33 34.61,45.24 34.61,41.01 34.1,40.5 33.46,40.5 33.34,40.37 33.34,36.56 v2(33.46,36.44)
  IN3 w0.133: v2(75.5,62.22) 75.5,61.96 75.33,61.79 74.05,61.79 73.58,62.27 72.12,62.87 69.53,63.39 68.36,63.87 66.49,64.24 60.3,64.24 57.18,65.54 56.89,65.82 51.46,65.82 50.81,65.18 48.23,65.18 47.43,64.37 41.69,64.37 33.09,60.81 28.57,56.29 27.69,54.18 27.15,51.46 26.91,48.96 26.91,44.8 27.22,43.23 27.43,42.72 27.67,42.48 28.9,40.64 28.9,40.64 31,37.49 32.03,36.46 33.44,36.46 v2(33.46,36.44)
  BOTTOM w0.089: 78.88,59.71 78.88,59.71 79.36,59.71 79.51,59.86 79.72,59.86 80.07,59.51 U2030.W29
  BOTTOM w0.102: 78.88,59.71 78.13,59.71 77.68,60.16 77.56,60.16
  BOTTOM w0.165: 77.56,60.16 v2(75.5,62.22)
M_B_A10: length 148.1
  TOP w0.102: v2(35.62,89.52) R2317.2
  TOP w0.165: v2(35.98,37.71) 36.08,37.71 U2013.M3 ; v2(36.93,73.47) 36.93,73.53 U2017.M3 ; v2(36.82,49.85) 36.85,49.85 U2014.M3 ; v2(36.93,84.91) U2018.M3
  IN2 w0.089: v2(36.93,84.91) 37.42,84.91 37.53,84.81 37.53,84.57 37.4,84.44 36.26,84.44 36.14,84.33 36.14,77.55 36.64,77.06 36.64,75.93 36.13,75.42 36.13,74.17 36.83,73.47 v2(36.93,73.47) 37.02,73.38 37.02,71.99 35.88,70.85 35.88,68.31 36.38,67.8 36.38,57.9 37.53,56.76 38.42,56.76 38.54,56.63 38.54,55.61 38.42,55.49 37.91,55.49 37.78,55.36 37.78,55.1 37.91,54.98 38.42,54.98 38.54,54.85 38.54,54.6 38.42,54.47 37.91,54.47 37.78,54.34 37.78,54.09 37.91,53.96 38.42,53.96 38.54,53.83 38.54,53.58 38.42,53.45 37.91,53.45 37.78,53.33 37.78,52.82 37.53,52.56 37.53,50.61 36.83,49.91 36.83,49.86 v2(36.82,49.85) 36.39,49.42 36.39,47.24 35.88,46.72 35.88,43.13 35.97,43.04 36.76,43.04 36.89,42.91 36.89,38.09 36.51,37.71 v2(35.98,37.71)
  IN3 w0.089: v2(36.93,84.91) 35.62,86.22 v2(35.62,89.52)
  IN3 w0.133: v2(75.25,54.72) 75.02,54.72 74.62,55.12 74.62,55.29 75.22,55.89 75.22,56.05 75.1,56.17 74.94,56.17 74.33,55.57 74.17,55.57 74.05,55.69 74.05,55.85 74.86,56.66 74.86,56.83 74.75,56.95 74.58,56.95 73.77,56.14 73.6,56.14 73.49,56.25 73.49,56.42 74.39,57.32 74.39,57.49 74.27,57.6 74.11,57.6 73.2,56.7 73.04,56.7 72.78,56.96 69.36,56.96 68.64,57.68 67.75,57.68 67.3,58.13 66.54,58.13 65.44,59.23 58.75,59.23 57.92,60.06 51,60.06 49.99,59.05 40.44,59.05 36.62,57.47 35.63,56.47 35.63,55.74 32.04,52.15 31.52,50.9 31.52,49.31 31.86,48.96 31.86,45.13 33.06,43.93 33.06,43.41 35.11,41.36 35.11,40.97 35.75,40.33 35.75,37.93 v2(35.98,37.71)
  BOTTOM w0.102: U2030.AH29 80.04,52.51 79.74,52.81 79.48,52.81 79.38,52.7 78.53,52.7 78.29,52.95 77.7,52.95
  BOTTOM w0.165: v2(75.25,54.72) 75.37,54.6 75.37,53.2 75.5,53.07 75.88,53.07 76.01,53.2 76.01,54.09 76.13,54.22 76.39,54.22 76.53,54.07 76.53,53.22 76.68,53.07 77.1,53.07 77.23,52.95 77.7,52.95
M_B_A11: length 149.1
  TOP w0.102: v2(33.29,86.79) 32.83,87.26 32.83,87.74 31.81,88.76 v2(31.81,89.14) R2303.2
  TOP w0.165: v2(33.29,86.79) 33.44,86.79 U2018.T2 ; U2013.T2 32.84,39.75 v2(32.8,39.74) ; U2017.T2 33.3,73.9 v2(32.68,73.9) ; U2014.T2 33.12,51.13 v2(32.66,50.67)
  IN1 w0.089: v2(32.8,39.74) 32.8,43.93 32.68,44.06 32.22,44.06 32.09,44.18 32.09,44.44 32.22,44.56 32.7,44.56 32.83,44.69 32.83,44.94 32.7,45.07 32.19,45.07 32.07,45.2 32.07,45.45 32.19,45.58 32.7,45.58 32.83,45.71 32.83,45.96 32.7,46.09 32.19,46.09 32.07,46.21 32.07,50.07 v2(32.66,50.67) 32.83,50.84 32.83,57.64 32.95,57.77 34.61,57.77 34.73,57.9 34.73,58.15 34.61,58.28 33.34,58.28 33.21,58.41 33.21,58.66 33.34,58.79 34.61,58.79 34.73,58.91 34.73,63.74 32.19,66.28 32.19,73.42 v2(32.68,73.9) 32.19,74.38 32.19,77.33 32.57,77.71 32.57,79.87 32.19,80.25 32.19,81.77 32.83,82.41 32.83,86.7 32.92,86.79 v2(33.29,86.79)
  IN3 w0.133: v2(72.53,60.16) 72.2,60.49 71.56,60.75 71.21,60.82 71.07,60.73 71.06,60.68 70.92,60.59 70.76,60.62 70.67,60.76 70.68,60.81 70.58,60.95 68.28,61.41 66.37,61.41 66.25,61.52 66.25,61.72 66.14,61.84 65.97,61.84 65.85,61.72 65.85,61.52 65.74,61.41 65.57,61.41 65.45,61.52 65.45,61.72 65.34,61.84 65.17,61.84 65.05,61.72 65.05,61.52 64.94,61.41 59.67,61.41 59.13,61.95 57.14,62.77 50.29,62.77 49.23,61.72 41.2,61.72 34.15,58.8 30.81,55.46 30.81,54.76 30.49,54.44 30.49,53.68 30.19,53.38 29.34,51.34 29.34,47.91 29.08,47.65 29.08,45.66 29.69,45.05 29.69,44.23 30.89,43.03 30.89,42.51 32.8,40.6 v2(32.8,39.74)
  BOTTOM w0.102: U2030.Y32 79.16,59.06 77.26,59.06
  BOTTOM w0.165: v2(72.53,60.16) 73.09,60.16 73.26,60.32 73.26,61.07 73.13,61.2 71.05,61.2 70.88,61.38 70.88,61.78 71.05,61.96 73.75,61.96 73.92,61.8 73.92,59.98 74.08,59.82 74.48,59.82 74.6,59.94 74.6,61.19 74.77,61.36 75.1,61.36 75.27,61.19 75.27,59.75 75.46,59.55 76.39,59.55 76.88,59.06 77.26,59.06
M_B_A12: length 155.5
  TOP w0.102: v2(34.86,89.52) R2343.2
  TOP w0.165: U2014.M7 36.93,47.52 v2(36.92,47.52) ; v2(36.87,36.16) 36.92,36.16 U2013.M7 ; v2(36.92,71.29) 36.92,71.14 U2017.M7 ; U2018.M7 36.62,82.81 36.62,83.53 v2(37.09,84)
  IN2 w0.089: v2(37.09,84) 36.38,83.29 36.38,77.66 36.89,77.15 36.89,75.81 36.48,75.39 36.48,74.16 36.74,73.9 37.07,73.9 37.33,73.64 37.33,73.32 37.29,73.28 37.29,71.93 36.92,71.55 v2(36.92,71.29) 36.13,70.5 36.13,68.4 36.64,67.89 36.64,58.15 36.76,58.03 38.67,58.03 38.8,57.9 38.8,57.64 38.67,57.52 37.65,57.52 37.53,57.39 37.53,57.14 37.65,57.01 38.67,57.01 38.8,56.88 38.8,53.45 37.78,52.44 37.78,50.52 37.22,49.97 37.22,49.56 36.92,49.25 v2(36.92,47.52) 36.92,47.38 36.13,46.59 36.13,44.44 36.26,44.31 36.89,44.31 37.02,44.18 37.02,43.93 36.89,43.8 36.26,43.8 36.13,43.67 36.13,43.42 36.26,43.29 37.02,43.29 37.15,43.17 37.15,36.43 v2(36.87,36.16)
  IN3 w0.089: v2(34.86,89.52) 35.11,89.27 35.11,85.97 v2(37.09,84)
  IN3 w0.133: v2(74.23,62.22) 73.93,62.52 72.22,63.22 69.63,63.74 68.46,64.23 66.53,64.61 60.75,64.61 57.01,66.16 51.28,66.16 50.66,65.54 41.27,65.54 40.7,64.97 40.7,64.9 39.78,63.97 38.51,63.45 32.89,61.12 28.26,56.49 27.34,54.28 26.79,51.52 26.54,48.98 26.54,44.76 26.87,43.13 27.13,42.51 27.39,42.25 30.72,37.26 31.89,36.1 33.04,36.1 34.61,34.53 36.76,34.53 37.32,35.08 37.32,35.72 v2(36.87,36.16)
  BOTTOM w0.089: 78.88,59.48 78.9,59.51 U2030.W31
  BOTTOM w0.102: 78.88,59.48 77.98,59.48 77.66,59.8 77.36,59.8
  BOTTOM w0.165: 77.36,59.8 75.41,61.75 74.67,61.75 74.23,62.2 v2(74.23,62.22)
M_B_A13: length 144.5
  TOP w0.102: v2(32.93,81.39) 32.42,81.9 R2332.2
  TOP w0.165: U2013.T8 33.39,34.95 v2(33.32,35.03) ; U2018.T8 33.02,81.31 v2(32.93,81.39) ; v2(33.65,69.55) 33.75,69.55 U2017.T8 ; U2014.T8 v2(33.75,45.95)
  IN1 w0.089: v2(33.32,35.03) 33.32,34.39 33.43,34.28 33.72,34.28 33.84,34.4 33.84,35.67 34.1,35.93 34.1,37.45 33.46,38.09 33.46,40.5 34.22,41.26 34.22,42.79 33.34,43.67 33.34,45.54 v2(33.75,45.95) 33.6,45.95 32.57,46.98 32.57,49.01 33.34,49.77 33.34,53.58 33.46,53.71 34.61,53.71 34.73,53.83 34.73,54.09 34.61,54.22 33.46,54.22 33.34,54.34 33.34,54.6 33.46,54.72 35.11,54.72 35.24,54.85 35.24,63.99 34.48,64.76 34.48,68.57 33.65,69.4 v2(33.65,69.55) 32.7,70.5 32.7,72.59 33.34,73.23 33.34,74.18 32.7,74.81 32.7,77.08 32.83,77.2 33.21,77.2 33.34,77.33 33.34,81.52 33.21,81.65 33.02,81.65 32.93,81.56 v2(32.93,81.39)
  IN3 w0.133: v2(77.79,49.54) 77.79,49.82 76.8,50.81 74.24,50.81 73.88,51.17 73.88,51.63 73.35,52.15 71.31,52.15 71.18,52.28 71.18,52.47 71.28,52.56 71.99,52.56 72.11,52.69 72.11,53.57 70.9,54.79 68.46,54.79 67.73,55.51 66.85,55.51 66.4,55.95 65.64,55.95 65.27,56.33 57.89,56.33 57.53,56.69 55.12,56.69 54.98,56.83 51.36,56.83 51,56.46 41.02,56.46 39.66,55.9 38.24,54.48 38.24,54.04 36.02,51.83 36.02,50.2 35.19,49.36 35.19,47.74 36.12,46.81 36.12,44.8 36.86,44.06 36.86,43.46 37.25,43.07 37.25,38.87 38.38,37.73 38.38,37.43 38.11,37.15 37.74,37.15 37.48,36.9 37.48,36.5 37.91,36.07 37.91,35.42 38.23,35.1 38.23,34.42 37.94,34.13 34.21,34.13 v2(33.32,35.03)
  BOTTOM w0.102: 78.91,49.27 79.65,50.01 U2030.AL30
  BOTTOM w0.165: 78.91,49.27 78.65,49.01 76.34,49.01 76.21,49.14 76.21,49.41 76.34,49.54 v2(77.79,49.54)
M_B_ACT#: length 151.9
  TOP w0.102: v2(37.91,89.52) R2319.2
  TOP w0.165: v2(38.56,74.33) 38.53,74.33 U2017.L3 ; U2018.L3 38.78,84.65 v2(39.07,84.65) ; U2014.L3 38.5,50.7 v2(39.33,50.7) ; U2013.L3 38.53,39.36 v2(38.53,39.36)
  IN2 w0.089: v2(38.53,39.36) 38.13,39.76 38.13,42.88 38.42,43.17 38.67,43.17 38.92,43.42 38.92,46.21 38.16,46.98 38.16,47.99 38.42,48.25 39.18,48.25 39.95,49.02 39.95,50.57 39.83,50.7 v2(39.33,50.7) 39.31,50.7 38.8,51.22 38.8,51.8 39.81,52.82 39.81,61.96 39.69,62.09 38.76,62.09 38.67,62.18 38.67,62.51 38.76,62.6 39.69,62.6 39.81,62.72 39.81,63.02 39.72,63.11 37.74,63.11 37.65,63.19 37.65,67.42 38.67,68.44 38.67,71.87 39.05,72.25 39.05,73.83 38.56,74.32 v2(38.56,74.33) 38.55,74.33 38.03,74.84 38.03,76.35 38.12,76.44 39.43,76.44 39.81,76.82 39.81,83.3 39.69,83.43 39.05,83.43 38.92,83.55 38.92,83.81 39.05,83.93 39.69,83.93 39.81,84.06 39.81,84.31 39.69,84.44 39.28,84.44 v2(39.07,84.65)
  IN3 w0.089: v2(39.07,84.65) 39.01,84.65 38.15,85.51 38.15,89.28 v2(37.91,89.52)
  IN3 w0.133: v2(38.53,39.36) 38.09,39.8 38.09,43.37 37.97,43.48 37.97,44.12 38.52,44.67 38.52,46.36 38.31,46.57 38.31,51.74 39.33,52.75 39.33,54.03 40.28,54.98 41.24,55.38 50.84,55.38 51.05,55.16 52.95,55.16 53.01,55.22 57.48,55.22 57.51,55.25 64.82,55.25 v2(65.34,54.72)
  BOTTOM w0.089: U2030.V30 79.83,60.83 79.49,60.83 79.37,60.71 79.09,60.71
  BOTTOM w0.102: 78.29,61.2 78.56,61.2 79.05,60.71 79.09,60.71
  BOTTOM w0.165: v2(65.34,54.72) 65.34,54.98 65.59,55.23 66.61,55.23 66.74,55.36 66.74,55.82 66.61,55.94 63.6,55.94 63.43,56.11 63.43,56.44 63.6,56.6 66.57,56.6 66.74,56.77 66.74,57.26 66.61,57.39 63.56,57.39 63.43,57.52 63.43,58.41 63.71,58.68 63.71,58.92 63.44,59.19 63.44,59.43 63.67,59.66 63.91,59.66 64.18,59.39 64.41,59.39 64.65,59.62 64.65,59.85 64.37,60.13 64.37,60.36 64.61,60.59 64.84,60.59 65.12,60.32 65.35,60.32 65.58,60.55 65.58,60.79 65.31,61.06 65.31,61.3 65.54,61.53 65.78,61.53 66.05,61.25 66.28,61.25 66.52,61.49 66.52,61.72 66.24,62 66.24,62.23 66.48,62.46 66.71,62.46 67.05,62.12 67.25,62.12 67.52,62.39 67.52,62.59 67.18,62.93 67.18,63.16 67.41,63.4 67.64,63.4 68.17,62.87 68.41,62.87 68.64,63.1 68.64,63.34 68.11,63.86 68.11,64.1 68.34,64.33 68.58,64.33 68.85,64.06 69.09,64.06 69.39,64.36 75.77,64.36 76.31,63.82 76.31,63.19 78.29,61.2
M_B_ALERT#: length 162.8
  TOP w0.102: v2(33.84,43.8) 34,43.8 U2014.P9 ; U2017.P9 34,67.4 v2(33.84,67.4) ; U2013.P9 35.73,33.87 v2(35.49,33.64) ; R2683.1 33.05,78.57 33.72,79.23 v2(34.35,79.23) 34.45,79.23 U2018.P9
  TOP w0.165: v2(74.74,63.49) 74.46,63.77 73.93,63.77 65.83,71.86 52.48,71.86 52.08,72.27 51.39,72.27 48.42,69.3 48.42,64.86 45.65,62.09 v2(30.03,62.09)
  IN1 w0.089: v2(35.49,33.64) 35.24,33.9 34.61,33.9 34.48,34.02 34.48,34.28 34.61,34.4 35.37,34.4 35.49,34.53 35.49,34.82 35.41,34.91 34.19,34.91 34.1,35 34.1,35.55 34.35,35.8 34.35,37.58 33.72,38.21 33.72,40.37 34.48,41.13 34.48,43.17 v2(33.84,43.8)
  IN1 w0.133: v2(30.03,62.09) 30.03,58.28 32.07,56.25 32.07,51.42 31.3,50.66 31.3,44.18 31.94,43.55 31.94,35.42 32.45,34.91 32.45,34.02 33.46,33.01 35.11,33.01 35.49,33.39 v2(35.49,33.64)
  IN2 w0.089: v2(33.84,43.8) 32.95,44.69 32.95,49.27 33.21,49.52 33.21,54.98 33.34,55.1 34.99,55.1 35.11,55.23 35.11,55.49 34.99,55.61 33.34,55.61 33.21,55.74 33.21,56.76 33.49,57.03 34.38,57.03 34.86,57.52 34.86,63.49 34.11,64.24 34.11,67.14 v2(33.84,67.4) 33.23,67.4 32.83,67.8 32.83,72.86 33.21,73.24 33.21,74.15 32.57,74.79 32.57,75.93 33.72,77.08 33.72,79.11 33.84,79.23 v2(34.35,79.23)
  BOTTOM w0.089: 78.88,60.31 79.34,60.31 79.52,60.13 79.89,60.13 U2030.W30
  BOTTOM w0.102: 78.88,60.31 78.85,60.31 78.57,60.59 77.79,60.59 77.68,60.7
  BOTTOM w0.165: 77.68,60.7 75.66,62.72 75.37,62.72 74.74,63.36 v2(74.74,63.49)
M_B_BG#0: length 148.8
  TOP w0.102: R2318.2 36.38,88.89 36.95,88.32 36.95,86.48 U2018.M2
  TOP w0.165: U2013.M2 36.91,40.17 36.91,41.1 v2(36.31,41.69) ; U2018.M2 v2(36.91,85.69) ; v2(36.93,50.73) U2014.M2 ; v2(36.88,74.33) 36.93,74.33 U2017.M2
  IN1 w0.089: v2(36.91,85.69) 36.91,86.33 36.83,86.42 36.6,86.42 36.51,86.33 36.51,75.68 36.64,75.55 37.27,75.55 37.4,75.42 37.4,74.85 v2(36.88,74.33) 36.64,74.08 36.51,73.95 36.51,72.76 36.26,72.5 36.26,68.81 37.27,67.79 37.27,60.78 37.36,60.69 38.58,60.69 38.67,60.6 38.67,60.27 38.58,60.18 37.36,60.18 37.27,60.1 37.27,59.76 37.36,59.68 38.58,59.68 38.67,59.59 38.67,53.07 37.91,52.31 37.91,51.48 37.15,50.73 v2(36.93,50.73) 36.93,50.88 36.77,51.04 36.38,51.04 36.13,50.79 36.13,49.56 36.26,49.43 36.26,45.59 36.35,45.51 37.22,45.51 37.4,45.33 37.4,44.44 37.27,44.31 37.27,41.01 37.15,40.88 36.89,40.88 36.76,41.01 36.76,41.85 36.67,41.94 36.4,41.94 36.31,41.85 v2(36.31,41.69)
  IN3 w0.133: v2(64.13,58.09) 63.82,57.78 58.66,57.78 57.47,58.97 51.45,58.97 50.44,57.96 40.66,57.96 37.56,56.68 37.23,56.34 37.23,55.81 33.37,51.96 33.37,49.64 33.05,49.32 33.05,47.21 32.95,47.1 32.95,45.58 33.39,45.14 33.73,45.14 35.41,43.46 35.41,42.6 v2(36.31,41.69)
  BOTTOM w0.089: 78.96,60.51 79.61,60.51 U2030.V31
  BOTTOM w0.102: 77.96,60.97 78.09,60.84 78.62,60.84 78.96,60.51
  BOTTOM w0.165: v2(64.13,58.09) 64.13,58.34 65.34,59.55 65.59,59.55 66.81,58.33 67.04,58.33 67.33,58.62 67.33,58.85 66.11,60.08 66.11,60.32 66.34,60.55 66.57,60.55 67.48,59.64 67.72,59.64 67.95,59.87 67.95,60.11 67.17,60.89 67.17,61.12 67.4,61.36 67.63,61.36 68.42,60.57 68.65,60.57 68.88,60.81 68.88,61.04 68.23,61.7 68.23,61.93 68.46,62.16 68.7,62.16 69.9,60.96 70.22,60.96 70.48,61.22 70.48,61.4 69.4,62.49 69.4,62.72 69.63,62.95 69.87,62.95 70.59,62.23 70.77,62.23 71,62.47 71,62.75 70.46,63.29 70.46,63.53 70.69,63.76 70.93,63.76 72.33,62.36 72.85,62.36 73.12,62.63 73.12,62.87 72.6,63.4 72.6,63.63 72.83,63.86 73.06,63.86 73.59,63.34 73.83,63.34 74.46,63.97 75.6,63.97 75.91,63.66 75.91,63.02 77.96,60.97
M_B_BG#1: length 151.1
  TOP w0.165: R2346.1 38.01,79.18 v2(38.16,79.34) ; v2(36.62,32.83) 36.72,32.73 R2695.1 ; R2691.1 v2(38.44,43.67) ; R2344.2 34.07,78.32 v2(34.35,78.6) ; R2687.1 v2(38.44,67.3)
  IN1 w0.089: v2(36.62,32.83) 38.04,33.18 38.71,33.35 38.93,33.56 38.93,34.62 37.53,36.01 37.53,36.83 37.77,37.07 37.99,37.07 38.33,37.41 38.33,38.16 37.78,38.71 37.78,39.99 38.29,40.5 38.29,43.52 v2(38.44,43.67) 38.44,44.08 38.57,44.21 38.57,46.06 37.8,46.83 37.8,48.01 38.92,49.14 38.92,51.8 39.69,52.56 39.69,65.14 39.56,65.26 38.67,65.26 38.54,65.39 38.54,65.65 38.67,65.77 39.56,65.77 39.69,65.9 39.69,66.15 39.56,66.28 39.05,66.28 38.92,66.41 38.92,66.66 39.05,66.79 39.56,66.79 39.69,66.92 39.69,67.17 39.56,67.3 v2(38.44,67.3) 38.8,67.65 38.8,69.71 37.8,70.71 37.8,71.51 39.56,73.27 39.56,77.08 37.91,78.73 37.91,79.08 v2(38.16,79.34)
  IN3 w0.089: v2(38.16,79.34) 37.43,78.6 v2(34.35,78.6)
  IN3 w0.133: v2(36.62,32.83) 35.92,32.98 34.04,33.81 32.82,34.65 30.44,37.03 27.11,42.02 26.82,42.31 26.52,43.02 26.18,44.73 26.18,49 26.44,51.57 27,54.39 27.95,56.7 32.66,61.4 32.7,61.43 40.61,65.66 41.19,65.9 45.57,65.9 50.38,66.37 51.09,66.51 51.1,66.52 57.33,66.52 60.46,65.22 61.72,64.97 66.58,64.97 70.39,64.21 71.57,63.72 73.24,63.39 74.5,63.08 75.24,63.04 75.84,63.13 v2(76.77,63.46)
  BOTTOM w0.102: U2030.V29 80.41,61.05 80.2,61.26 80.04,61.33 79.98,61.33 79.69,61.2 79.55,61.2 79.41,61.26 79.14,61.53 78.32,61.87 78.07,62.12
  BOTTOM w0.165: v2(76.77,63.46) 76.77,63.42 78.07,62.12
M_B_BG#1_R0: length 2.6
  TOP w0.165: U2018.M9 37.56,80.28 R2346.2 R2685.1
M_B_BG#1_R1: length 2.4
  TOP w0.165: R2688.1 R2687.2 37.43,69.02 U2017.M9
M_B_BG#1_R2: length 2.5
  TOP w0.165: R2692.1 R2691.2 37.43,45.42 U2014.M9
M_B_BG#1_R3: length 2.5
  TOP w0.165: U2013.M9 37.25,34.08 37.25,32.73 37.17,32.65 R2695.2 R2696.1
M_B_BS#0: length 147.5
  TOP w0.102: v2(36.14,86.49) 36.14,87.25 34.1,89.29 R2316.2 ; U2013.N2 35.96,40.84 35.91,40.99 35.91,41.78 35.96,41.91 36.3,42.32 v2(36.3,42.33)
  TOP w0.165: U2017.N2 36.87,75.07 v2(36.88,75.13) ; U2018.N2 36.52,86.11 v2(36.14,86.49) ; v2(36.93,51.53) 36.93,51.53 U2014.N2
  IN1 w0.089: v2(36.14,86.49) 36.14,86.09 36.02,85.97 35.49,85.97 35.37,85.84 35.37,85.58 35.49,85.46 36.13,85.46 36.26,85.33 36.26,76.95 35.62,76.31 35.62,75.42 35.92,75.13 v2(36.88,75.13) 36.87,75.11 36.26,74.49 36.26,73.14 35.23,72.11 35.23,70.99 36,70.22 36,68.69 37.02,67.68 37.02,59.51 37.11,59.42 38.07,59.42 38.16,59.33 38.16,59 38.07,58.91 37.11,58.91 37.02,58.83 37.02,58.49 37.11,58.41 38.33,58.41 38.42,58.32 38.42,53.2 37.65,52.44 37.65,51.8 37.38,51.53 v2(36.93,51.53) 36.51,51.53 35.88,50.9 35.88,49.47 36,49.35 36,48.92 35.86,48.77 35.53,48.77 35.37,48.62 35.37,47.48 36,46.85 36,44.82 36.13,44.69 36.89,44.69 37.02,44.56 37.02,44.31 36.89,44.18 36.13,44.18 36,44.06 36,43.8 36.13,43.67 36.93,43.67 37.02,43.59 37.02,42.37 36.93,42.28 36.36,42.28 v2(36.3,42.33)
  IN3 w0.133: v2(74.89,53.39) 74.81,53.39 72.33,55.87 68.91,55.87 68.19,56.59 67.3,56.59 66.85,57.04 66.09,57.04 65.72,57.42 58.51,57.42 57.3,58.64 54.44,58.64 54.42,58.61 51.6,58.61 50.59,57.6 40.73,57.6 37.77,56.38 37.59,56.19 37.59,55.66 33.74,51.81 33.74,49.49 33.42,49.17 33.42,47.06 33.31,46.95 33.31,45.73 33.54,45.5 33.88,45.5 35.77,43.61 35.77,43.01 36.3,42.48 v2(36.3,42.33)
  BOTTOM w0.102: U2030.AH31 79.6,52.5 77.7,52.5
  BOTTOM w0.165: 77.7,52.5 77.68,52.52 76.47,52.52 74.23,50.28 69.28,50.28 69.14,50.42 69.14,52.25 69.29,52.41 69.95,52.41 70.11,52.24 70.11,51.59 70.28,51.42 70.61,51.42 70.77,51.59 70.77,52.24 70.94,52.41 71.27,52.41 71.43,52.24 71.43,51.66 71.6,51.5 71.93,51.5 72.09,51.66 72.09,52.24 72.26,52.41 72.59,52.41 72.75,52.24 72.75,51.79 72.92,51.62 73.25,51.62 73.41,51.79 73.41,52.24 73.58,52.41 74.2,52.41 74.89,53.1 v2(74.89,53.39)
M_B_BS#1: length 149.4
  TOP w0.102: v2(31.3,79.62) R2334.2
  TOP w0.165: v2(36.92,79.36) 36.12,80.16 36.12,80.9 U2018.N8 ; U2017.N8 v2(36.92,69.54) ; U2013.N8 36.16,35.32 v2(36.16,35.36) ; U2014.N8 v2(36.92,45.93)
  IN1 w0.089: v2(36.92,79.36) 36.76,79.2 36.76,78.43 36.85,78.35 37.15,78.35 37.65,77.84 37.65,77.46 37.53,77.33 36.89,77.33 36.76,77.2 36.76,76.95 36.89,76.82 37.53,76.82 37.65,76.69 37.65,76.44 37.53,76.31 36.89,76.31 36.76,76.19 36.76,75.93 36.89,75.81 37.53,75.81 37.65,75.68 37.65,73.52 36.51,72.38 36.51,69.94 v2(36.92,69.54) 37.53,68.93 37.53,62.05 37.62,61.96 38.84,61.96 38.92,61.87 38.92,61.54 38.84,61.45 37.62,61.45 37.53,61.37 37.53,61.03 37.62,60.95 38.84,60.95 38.92,60.86 38.92,52.95 38.16,52.18 38.16,51.4 37.08,50.31 36.72,50.31 36.38,49.98 36.38,49.67 36.51,49.55 36.51,46.34 v2(36.92,45.93) 37.15,45.93 37.65,45.43 37.65,44.31 37.53,44.18 37.53,40.88 37.02,40.37 37.02,36.94 35.75,35.67 35.75,34.49 35.84,34.4 36.07,34.4 36.16,34.49 v2(36.16,35.36)
  IN3 w0.089: v2(36.92,79.36) 36.16,80.12 33.46,80.12 32.96,79.62 v2(31.3,79.62)
  IN3 w0.133: v2(78.06,53.39) 79.84,53.39 79.96,53.52 79.96,53.78 79.84,53.91 76.98,53.91 76.86,53.79 76.86,52.96 76.75,52.84 76.58,52.84 76.46,52.96 76.46,53.79 76.35,53.91 76.18,53.91 76.06,53.79 76.06,53.09 75.95,52.97 75.78,52.97 75.66,53.09 75.66,53.79 75.55,53.91 74.8,53.91 72.48,56.23 69.06,56.23 68.34,56.96 67.45,56.96 67,57.4 66.24,57.4 65.14,58.51 63.45,58.51 63.33,58.39 63.33,58.26 63.21,58.14 63.05,58.14 62.93,58.26 62.93,58.39 62.81,58.51 62.65,58.51 62.53,58.39 62.53,58.26 62.41,58.14 62.25,58.14 62.13,58.26 62.13,58.39 62.01,58.51 61.85,58.51 61.73,58.39 61.73,58.26 61.61,58.14 61.45,58.14 61.33,58.26 61.33,58.39 61.21,58.51 61.05,58.51 60.93,58.39 60.93,58.26 60.81,58.14 60.65,58.14 60.53,58.26 60.53,58.39 60.41,58.51 60.25,58.51 60.13,58.39 60.13,58.26 60.01,58.14 59.85,58.14 59.73,58.26 59.73,58.39 59.61,58.51 59.45,58.51 59.33,58.39 59.33,58.26 59.21,58.14 59.05,58.14 58.93,58.26 58.93,58.39 58.81,58.51 58.45,58.51 57.62,59.34 51.3,59.34 50.29,58.33 40.59,58.33 37.36,56.99 36.86,56.49 36.86,55.96 32.65,51.74 32.24,50.76 32.24,49.61 32.59,49.26 32.59,45.43 33.24,44.78 33.58,44.78 35.05,43.31 35.05,42.45 35.88,41.62 35.88,40.89 36.38,40.38 36.38,38.47 36.76,38.09 36.76,36.66 36.16,36.05 v2(36.16,35.36)
  BOTTOM w0.102: v2(78.06,53.39) 78.35,53.39 78.74,53.01 U2030.AG32
M_B_CAS#: length 147.7
  TOP w0.102: R2335.2 v2(31.3,80.38)
  TOP w0.165: U2014.M8 v2(37.74,45.92) ; U2013.M8 v2(37.73,34.55) ; v2(36.92,80.9) U2018.M8 ; U2017.M8 v2(37.74,69.52)
  IN1 w0.089: v2(36.92,80.9) 36.92,81.58 37.01,81.67 37.27,81.67 37.4,81.55 37.4,78.47 37.91,77.96 37.91,73.42 37.15,72.66 37.15,71.74 37.32,71.57 37.32,70.43 37.74,70.01 v2(37.74,69.52) 38.2,69.52 38.29,69.43 38.29,68.19 37.78,67.68 37.78,63.36 37.91,63.23 38.84,63.23 38.92,63.14 38.92,62.81 38.84,62.72 37.87,62.72 37.78,62.64 37.78,62.3 37.87,62.22 39.09,62.22 39.18,62.13 39.18,52.82 38.42,52.06 38.42,51.31 37.33,50.22 37.33,49.79 36.76,49.22 36.76,48.25 37.32,47.69 37.32,46.33 v2(37.74,45.92) 37.91,45.74 37.91,44.18 37.78,44.06 37.78,40.75 37.27,40.25 37.27,35.65 37.5,35.42 37.78,35.42 38.67,34.53 38.67,34.28 38.54,34.15 37.74,34.15 37.65,34.24 37.65,34.48 v2(37.73,34.55)
  IN3 w0.089: v2(31.3,80.38) 31.81,79.87 32.86,79.87 33.37,80.38 36.4,80.38 v2(36.92,80.9)
  IN3 w0.133: v2(37.73,34.55) 37.63,34.65 37.63,36.01 37.15,36.49 37.15,38.09 36.76,38.47 36.76,42.53 36.14,43.16 36.14,43.76 35.4,44.5 35.4,45.07 35.28,45.19 34.77,45.19 34.65,45.3 34.65,45.47 34.77,45.59 35.28,45.59 35.4,45.7 35.4,46.44 35.24,46.6 34.91,46.6 34.73,46.42 34.35,46.42 34.22,46.54 34.22,47.03 34.05,47.2 33.94,47.2 33.78,47.37 33.78,49.02 34.1,49.34 34.1,51.66 38.04,55.6 38.3,55.6 38.43,55.72 38.43,56.11 38.54,56.22 40.88,57.19 50.69,57.19 51.28,57.77 54.8,57.77 54.85,57.83 57.6,57.83 58.36,57.06 65.57,57.06 65.94,56.68 66.7,56.68 67.15,56.23 68.03,56.23 68.76,55.51 72.18,55.51 73.27,54.42 73.27,54.26 72.92,53.91 72.92,53.74 73.04,53.63 73.21,53.63 73.55,53.97 73.72,53.97 73.85,53.84 73.85,53.53 73.98,53.41 74.28,53.41 74.72,52.97 75.27,52.97 75.63,52.61 75.92,52.61 76.05,52.48 76.75,52.48 76.88,52.35 76.88,51.91 77.16,51.63 77.66,51.63 77.78,51.51 77.78,51.41 77.9,51.29 78.06,51.29 78.18,51.41 78.18,51.51 78.3,51.63 78.46,51.63 78.58,51.51 78.58,51.41 78.7,51.29 78.86,51.29 79.06,51.49 79.06,52 79.18,52.12 79.31,52.12 79.46,51.97 79.46,51.55 79.59,51.42 79.77,51.42 79.89,51.55 79.89,52 80.02,52.12 80.2,52.12 80.33,52 80.33,51.13 80.2,51 79.44,51 79.31,50.87 79.31,50.53 78.81,50.03 78.42,50.03 78.29,50.16 78.29,50.39 78.69,50.78 v2(78.72,50.78)
  BOTTOM w0.102: v2(78.72,50.78) 78.8,50.86 79.06,50.86 U2030.AK32
M_B_CKE0: length 149.5
  TOP w0.102: v2(39.43,89.52) R2322.2
  TOP w0.165: v2(38.53,40.15) U2013.K2 ; U2017.K2 38.56,75.09 v2(38.56,75.13) ; v2(39.33,51.53) U2014.K2 ; U2018.K2 v2(39.33,85.71)
  IN2 w0.089: v2(39.33,85.71) 40.33,85.71 40.45,85.58 40.45,85.33 40.32,85.2 39.66,85.2 39.53,85.08 39.53,84.82 39.66,84.7 40.32,84.7 40.45,84.57 40.45,84.31 40.32,84.19 40.19,84.19 40.07,84.06 40.07,76.64 38.56,75.14 v2(38.56,75.13) 38.56,75.12 39.3,74.37 39.3,72.12 38.92,71.74 38.92,68.34 37.91,67.33 37.91,64.5 38.03,64.38 39.09,64.38 39.18,64.28 39.18,63.96 39.09,63.87 38.03,63.87 37.91,63.74 37.91,63.49 38.03,63.36 39.98,63.36 40.07,63.27 40.07,52.69 39.33,51.95 v2(39.33,51.53) 40.07,51.53 40.19,51.4 40.19,48.88 39.3,47.99 38.54,47.99 38.42,47.87 38.42,47.06 39.18,46.3 39.18,43.29 38.42,42.53 38.42,40.26 v2(38.53,40.15)
  IN3 w0.089: v2(39.43,89.52) 38.91,89 38.91,86.13 v2(39.33,85.71)
  IN3 w0.133: v2(64.07,54.72) 63.91,54.89 53.18,54.89 53.1,54.8 50.86,54.8 50.64,55.02 41.31,55.02 40.48,54.67 39.69,53.88 39.69,52.6 38.67,51.59 38.67,46.72 38.88,46.51 38.88,44.82 38.92,44.78 38.92,43.18 38.53,42.79 v2(38.53,40.15)
  BOTTOM w0.102: U2030.U29 80.24,61.68 79.91,61.68 79.59,61.99 79.59,62.06 79.31,62.35
  BOTTOM w0.165: v2(64.07,54.72) 63.05,54.72 62.8,54.98 62.8,59.55 63.08,59.83 63.08,60.06 62.49,60.65 62.49,60.89 62.72,61.12 62.95,61.12 63.55,60.53 63.78,60.53 64.01,60.76 64.01,61 62.84,62.17 62.84,62.38 63.07,62.61 63.33,62.61 64.48,61.46 64.71,61.46 64.95,61.7 64.95,61.93 63.85,63.03 63.85,63.26 64.08,63.5 64.31,63.5 65.41,62.4 65.65,62.4 65.88,62.63 65.88,62.86 64.78,63.96 64.78,64.2 65.02,64.43 65.25,64.43 66.35,63.33 66.58,63.33 66.82,63.56 66.82,63.8 66.1,64.52 66.1,64.75 66.33,64.98 66.56,64.98 67.28,64.27 67.52,64.27 68.13,64.88 71.98,64.88 72.15,65.05 72.15,65.73 72.31,65.9 72.64,65.9 72.81,65.73 72.81,65.05 72.97,64.88 73.3,64.88 73.47,65.05 73.47,65.99 73.63,66.15 73.96,66.15 74.13,65.99 74.13,65.05 74.29,64.88 76.64,64.88 77.84,63.68 77.84,63.05 78.17,62.72 78.93,62.72 79.31,62.35
M_B_CLKN0: length 152
  TOP w0.102: R2697.2 39.81,78.69 39.5,78.69 v2(39.28,78.92)
  TOP w0.165: U2014.K8 v2(39.33,46.73) ; v2(39.33,35.33) 39.3,35.33 U2013.K8 ; v2(39.33,81.68) 39.3,81.68 U2018.K8 ; U2017.K8 v2(39.33,70.33)
  IN1 w0.089: v2(39.33,35.33) 39.33,35.58 39.24,35.67 38.94,35.67 38.75,35.86 38.75,36.51 39.18,36.94 39.98,36.94 40.14,37.11 40.14,37.36 39.51,38 39.51,46.16 39.81,46.47 39.81,46.91 39.72,47 39.6,47 v2(39.33,46.73) 39.01,47.04 38.74,47.04 38.54,47.23 38.54,47.74 39.86,49.06 39.86,51.34 40.57,52.05 40.57,66.61 40.76,66.79 42.01,66.79 42.1,66.88 42.1,67.28 42.01,67.37 40.5,67.37 39.89,67.98 39.89,70.51 39.76,70.64 39.64,70.64 v2(39.33,70.33) 38.99,70.66 38.86,70.66 38.58,70.95 38.58,71.27 39.23,71.92 39.76,71.92 40.27,72.42 40.27,81.83 40.08,82.01 39.45,82.01 39.33,81.89 v2(39.33,81.68)
  IN3 w0.089: v2(39.28,78.92) 39.28,78.76 39.37,78.67 39.63,78.67 39.94,78.98 39.94,81.91 39.76,82.09 39.27,82.09 39.18,82 39.18,81.83 v2(39.33,81.68)
  IN3 w0.14: v2(39.33,35.33) 38.81,35.48 38.45,35.84 38.45,36.47 39.3,37.32 39.3,37.83 39.47,37.99 39.47,38.8 39.42,38.85 39.42,42.61 39.88,43.07 39.88,43.7 39.42,44.17 39.42,46.2 39.77,46.55 39.77,47.73 39.51,47.99 39.51,49.34 39.8,49.63 39.8,51.66 40.44,52.29 40.44,53.57 40.91,54.04 46.51,54.04 46.72,54.25 48.24,54.25 48.46,54.04 55.43,54.04 55.73,53.74 55.73,53.12 55.87,52.98 56.36,52.98 56.5,53.12 56.5,53.74 56.8,54.04 57.52,54.04 57.81,53.74 57.81,53.12 57.95,52.98 58.45,52.98 58.59,53.12 58.59,53.74 58.88,54.04 59.6,54.04 59.89,53.74 59.89,53.12 60.03,52.98 60.53,52.98 60.67,53.12 60.67,53.74 60.96,54.04 61.68,54.04 61.98,53.74 61.98,52.55 62.1,52.42 62.56,52.42 62.75,52.62 62.75,53.74 63.05,54.04 63.66,54.04 63.95,53.74 63.95,52.55 64.08,52.42 64.56,52.42 64.73,52.59 64.73,53.74 65.03,54.04 65.74,54.04 66.04,53.74 66.04,52.59 66.18,52.45 66.67,52.45 66.81,52.59 66.81,53.73 67.11,54.03 67.82,54.03 68.12,53.73 68.12,52.59 68.26,52.45 68.76,52.45 68.9,52.59 68.9,53.74 69.19,54.04 70.59,54.04 70.9,53.73 v2(71.05,53.2)
  BOTTOM w0.102: U2030.AD30 79.25,56.33 79.1,56.33 78.65,55.89 78.29,55.74 76.13,55.74 76.07,55.68 76.04,55.68
  BOTTOM w0.165: 76.04,55.68 73.53,55.68 73.36,55.52 73.36,54.39 72.99,54.02 72.26,54.02 71.93,54.35 71.93,55.52 71.76,55.68 70.04,55.68 69.75,55.97 69.29,55.97 69.04,55.71 69.04,54.52 69.25,54.31 69.56,54.31 70.07,54.82 70.56,54.82 70.93,54.46 70.93,53.58 v2(71.05,53.2)
M_B_CLKP0: length 151.9
  TOP w0.102: v2(39.28,78.28) 39.5,78.5 39.81,78.5 R2698.2
  TOP w0.165: U2018.K7 v2(39.33,82.51) ; U2014.K7 v2(39.33,47.53) ; U2013.K7 v2(39.33,36.15) ; U2017.K7 v2(39.33,71.13)
  IN1 w0.089: v2(39.33,82.51) 39.33,82.28 39.42,82.19 40.16,82.19 40.45,81.9 40.45,72.35 39.84,71.74 39.3,71.74 38.76,71.2 38.76,71.02 38.94,70.84 39.04,70.84 v2(39.33,71.13) 39.64,70.82 39.84,70.82 40.07,70.59 40.07,68.06 40.57,67.55 42.08,67.55 42.28,67.36 42.28,66.8 42.08,66.61 40.83,66.61 40.75,66.53 40.75,51.98 40.04,51.27 40.04,48.98 38.72,47.66 38.72,47.31 38.81,47.21 39.01,47.21 v2(39.33,47.53) 39.68,47.18 39.8,47.18 39.99,46.98 39.99,46.39 39.69,46.09 39.69,38.07 40.32,37.44 40.32,37.03 40.05,36.77 39.25,36.77 38.92,36.44 38.92,35.94 39.01,35.85 39.19,35.85 39.33,35.99 v2(39.33,36.15)
  IN3 w0.089: v2(39.28,78.28) 39.49,78.49 39.71,78.49 40.12,78.9 40.12,81.99 39.84,82.27 39.56,82.27 v2(39.33,82.51)
  IN3 w0.14: v2(70.29,53.2) 70.33,53.16 70.51,53.16 70.64,53.29 70.64,53.62 70.48,53.77 69.3,53.77 69.16,53.63 69.16,52.48 68.87,52.18 68.15,52.18 67.85,52.48 67.85,53.62 67.71,53.76 67.22,53.76 67.08,53.62 67.08,52.48 66.78,52.18 66.07,52.18 65.77,52.48 65.77,53.63 65.63,53.77 65.14,53.77 65,53.63 65,52.48 64.68,52.16 63.97,52.16 63.69,52.44 63.69,53.63 63.55,53.77 63.16,53.77 63.02,53.63 63.02,52.51 62.67,52.16 61.99,52.16 61.71,52.44 61.71,53.63 61.57,53.77 61.08,53.77 60.94,53.63 60.94,53.01 60.64,52.72 59.92,52.72 59.63,53.01 59.63,53.63 59.49,53.77 58.99,53.77 58.85,53.63 58.85,53.01 58.56,52.72 57.84,52.72 57.54,53.01 57.54,53.63 57.4,53.77 56.91,53.77 56.77,53.63 56.77,53.01 56.47,52.72 55.76,52.72 55.46,53.01 55.46,53.63 55.32,53.77 48.35,53.77 48.13,53.99 46.83,53.99 46.62,53.77 41.02,53.77 40.7,53.46 40.7,52.18 40.07,51.55 40.07,49.52 39.78,49.23 39.78,48.1 40.04,47.84 40.04,46.44 39.69,46.09 39.69,44.28 40.15,43.81 40.15,42.96 39.69,42.5 39.69,38.96 39.74,38.91 39.74,37.88 39.57,37.72 39.57,37.21 39.33,36.97 39.33,36.92 39.08,36.66 39.03,36.66 38.72,36.36 38.72,35.95 38.92,35.75 39.27,35.75 39.41,35.89 39.41,36.07 v2(39.33,36.15)
  BOTTOM w0.102: U2030.AC31 79.61,56.58 79.48,56.71 79.3,56.71 79.13,56.53 79.01,56.53 78.54,56.06 78.25,55.94 76.13,55.94 76.07,56 76.04,56
  BOTTOM w0.165: v2(70.29,53.2) 70.47,53.2 70.61,53.34 70.61,54.33 70.43,54.51 70.2,54.51 69.69,53.99 69.12,53.99 68.72,54.39 68.72,55.84 69.16,56.29 69.88,56.29 70.17,56 71.89,56 72.25,55.65 72.25,54.48 72.39,54.34 72.86,54.34 73.05,54.52 73.05,55.65 73.4,56 76.04,56
M_B_CS#0: length 153.7
  TOP w0.102: R2336.2 v2(31.3,82.66)
  TOP w0.165: v2(37.93,36.66) 38.12,36.48 38.12,35.76 U2013.L7 ; U2018.L7 38.13,82.45 v2(37.91,82.66) ; U2017.L7 38.13,72.06 v2(37.93,72.25) ; v2(37.73,49.02) 38.13,48.62 U2014.L7
  IN2 w0.089: v2(37.93,36.66) 38.35,36.66 38.44,36.75 38.44,37.83 38.3,37.98 37.73,37.98 37.64,38.07 37.64,44.04 38.29,44.69 38.29,46.09 37.65,46.72 37.65,48.95 v2(37.73,49.02) 37.89,49.02 38.42,49.55 38.42,50.12 38.29,50.25 38.29,52.06 39.3,53.07 39.3,59.42 39.18,59.55 38.03,59.55 37.91,59.68 37.91,59.93 38.03,60.06 39.18,60.06 39.3,60.18 39.3,60.44 39.18,60.57 37.27,60.57 37.15,60.69 37.15,67.68 38.16,68.69 38.16,72.02 v2(37.93,72.25) 38.29,72.25 38.54,72.5 38.54,72.88 38.03,73.39 38.03,73.9 37.53,74.41 37.53,76.82 37.65,76.95 37.91,76.95 38.03,77.07 38.03,78.86 37.76,79.13 37.76,80.29 37.85,80.38 38.29,80.38 38.42,80.5 38.42,80.76 38.29,80.89 37.89,80.89 37.76,81.01 37.76,81.25 37.91,81.39 38.29,81.39 38.42,81.52 38.42,81.77 38.29,81.9 37.74,81.9 37.65,81.99 37.65,82.41 v2(37.91,82.66)
  IN3 w0.089: v2(31.3,82.66) 34.11,82.66 34.36,82.91 34.85,82.91 35.25,82.51 37.76,82.51 v2(37.91,82.66)
  IN3 w0.133: v2(37.93,36.66) 37.95,36.66 38.62,37.33 38.62,37.84 37.49,38.97 37.49,43.34 37.22,43.61 37.22,44.21 36.49,44.95 36.49,49.54 36.38,49.64 36.38,51.68 38.6,53.89 38.6,54.33 39.87,55.59 41.09,56.1 51.15,56.1 51.51,56.47 54.83,56.47 54.94,56.36 57.25,56.36 57.63,55.97 65.12,55.97 65.49,55.59 66.25,55.59 66.7,55.15 67.58,55.15 67.88,54.85 v2(67.88,54.72)
  BOTTOM w0.089: U2030.AJ31 79.61,51.51 78.89,51.51
  BOTTOM w0.102: 77.7,51.43 78.82,51.43 78.89,51.51
  BOTTOM w0.165: v2(67.88,54.72) 67.88,53.69 67.71,53.52 65.38,53.52 65.21,53.36 65.21,53.03 65.38,52.86 68.48,52.86 68.64,52.7 68.64,52.37 68.48,52.2 65.38,52.2 65.21,52.04 65.21,51.71 65.38,51.54 67.71,51.54 67.88,51.38 67.88,50.58 67.75,50.45 65.79,50.45 65.64,50.3 65.64,49.9 65.77,49.77 74.61,49.77 76.27,51.43 77.7,51.43
M_B_DM0: length 74.2
  TOP w0.102: U2018.E7 41.71,83.32 v2(41.71,83.65)
  IN3 w0.089: v2(41.71,83.65) 42.12,84.05 42.12,84.45 43.49,85.82 43.49,87.24 44.29,88.05 50.39,88.05 50.85,88.51 58.96,88.51 59.44,88.99 60.06,88.99 60.54,88.51 63.83,88.51 69.21,83.13 71.54,83.13 71.64,83.24 71.64,86.98 71.75,87.08 71.89,87.08 72,86.98 72,85.56 72.1,85.46 72.25,85.46 72.35,85.56 72.35,86.98 72.46,87.08 72.6,87.08 72.71,86.98 72.71,85.71 72.81,85.6 72.96,85.6 73.06,85.71 73.06,86.98 73.17,87.08 80.26,87.08 82.66,84.68 82.66,81.04 83.64,80.06 84.45,80.06 84.85,79.67 v1(85.38,79.67)
  BOTTOM w0.102: v1(85.38,79.67) 85.76,79.28 86.52,78.52 86.52,74.49 86.94,74.07 86.94,73.3 86.66,73.01 86.66,72.65 U2030.C21
M_B_DM1: length 58
  TOP w0.102: v2(43.88,84.19) U2018.E2
  IN3 w0.089: v2(43.88,84.19) 43.88,83.36 43.98,83.26 44.13,83.26 44.23,83.36 44.23,83.8 44.34,83.9 44.48,83.9 44.59,83.8 44.59,83.58 44.69,83.48 47.13,83.48 47.33,83.68 48.97,83.68 49.46,84.17 54.19,84.17 54.4,83.96 54.92,83.96 55.13,84.17 63.78,84.17 63.88,84.06 63.88,80.14 63.98,80.03 64.13,80.03 64.24,80.14 64.24,82.69 64.34,82.79 64.49,82.79 64.59,82.69 64.59,80.14 64.69,80.03 73.99,80.03 75.66,78.36 78.91,78.36 80.75,76.52 81.09,76.52 81.58,76.03 81.58,75.92 81.75,75.75 81.93,75.75 82.05,75.88 v1(82.05,76.08)
  BOTTOM w0.089: U2030.C25 83.32,72.7 83.32,73.06 83.21,73.16 83.21,73.44
  BOTTOM w0.102: v1(82.05,76.08) 83.21,74.93 83.21,73.44
M_B_DM2: length 57.6
  TOP w0.102: U2017.E7 41.73,71.93 v2(41.72,72.25)
  IN3 w0.089: v1(79.57,71.86) 79.1,72.34 79.1,72.46 79.33,72.69 79.33,72.84 79.24,72.92 79.06,72.92 78.84,72.71 78.67,72.71 78.49,72.89 78.49,74.49 77.65,75.33 73.13,75.33 73.04,75.42 73.04,76.69 72.73,77 61.27,77 61.16,77.1 61.16,78.08 60.86,78.39 57.59,78.39 57.49,78.49 57.49,79.02 57.38,79.12 55.24,79.12 55.13,79.02 55.13,78.49 55.03,78.39 54.88,78.39 54.78,78.49 54.78,79.02 54.67,79.12 54.53,79.12 54.42,79.02 54.42,78.49 54.32,78.39 54.17,78.39 54.07,78.49 54.07,79.02 53.96,79.12 50.9,79.12 50.69,79.33 42.02,79.33 40.18,77.5 40.18,73.7 40.76,73.13 41.09,73.13 41.33,72.89 41.33,72.64 v2(41.72,72.25)
  BOTTOM w0.102: U2030.E32 v1(79.57,71.86)
M_B_DM3: length 58.1
  TOP w0.102: v2(43.88,72.81) U2017.E2
  IN3 w0.089: v2(43.88,72.81) 43.97,72.71 43.97,72.06 44.44,71.59 44.66,71.59 44.87,71.38 44.87,70.9 44.97,70.79 51.41,70.79 51.51,70.69 51.51,69.96 51.62,69.86 51.76,69.86 51.87,69.96 51.87,70.69 51.97,70.79 52.12,70.79 52.22,70.69 52.22,69.96 52.33,69.86 52.51,69.86 52.76,69.61 57.29,69.61 57.5,69.83 57.73,69.83 57.94,69.61 58.89,69.61 59.15,69.87 59.33,69.87 59.59,69.61 65.47,69.61 65.57,69.51 65.57,67.72 65.68,67.62 65.83,67.62 65.93,67.72 65.93,69.51 66.03,69.61 66.18,69.61 66.29,69.51 66.29,67.72 66.39,67.62 66.54,67.62 66.64,67.72 66.64,69.51 66.75,69.61 66.89,69.61 67,69.51 67,67.72 67.1,67.62 67.25,67.62 67.35,67.72 67.35,69.51 67.46,69.61 67.6,69.61 67.71,69.51 67.71,67.72 67.81,67.62 69.09,67.62 69.31,67.84 69.49,67.84 69.71,67.62 70.49,67.62 71.52,66.58 74.7,66.58 74.91,66.37 75.65,66.37 75.75,66.48 v1(75.75,66.74)
  BOTTOM w0.089: 78.86,68.31 79.39,68.31 79.49,68.21 79.81,68.21 U2030.K30
  BOTTOM w0.102: 78.86,68.31 78.67,68.31 78.55,68.19 76.29,68.19 75.75,67.65 v1(75.75,66.74)
M_B_DM4: length 58.3
  TOP w0.102: U2014.E2 v1(43.33,51.53)
  IN3 w0.089: v2(75.19,46.85) 74.3,46.85 74.21,46.93 74.21,48.61 74.1,48.72 73.94,48.72 73.85,48.62 73.85,46.93 73.76,46.85 73.6,46.85 73.5,46.95 73.5,48.63 73.39,48.74 73.24,48.74 73.14,48.64 73.14,46.93 73.05,46.85 72.89,46.85 72.78,46.95 72.78,47.39 72.69,47.48 72.54,47.48 72.45,47.57 72.45,47.75 72.54,47.83 72.69,47.83 72.78,47.92 72.78,49.3 72.66,49.42 72.44,49.42 72.35,49.33 72.35,48.28 72.26,48.19 72.08,48.19 71.99,48.28 71.99,49.33 71.9,49.42 71.73,49.42 71.64,49.33 71.64,48.49 71.55,48.4 71.37,48.4 71.28,48.49 71.28,49.33 71.19,49.42 71.02,49.42 70.93,49.33 70.93,48.49 70.84,48.4 70.66,48.4 70.57,48.49 70.57,49.33 70.48,49.42 70.3,49.42 70.22,49.33 70.22,48.49 70.13,48.4 69.95,48.4 69.86,48.49 69.86,49.33 69.77,49.42 51.38,49.42 49.78,51.03 47.37,51.03 47.27,50.92 47.27,50.42 46.83,49.98 45.49,49.98 45.15,49.64 44.48,49.64 43.73,50.4 43.73,51.13 v1(43.33,51.53)
  BOTTOM w0.089: U2030.AP30 79.82,46.82 79.46,46.82 79.35,46.7 79.08,46.7 78.95,46.83
  BOTTOM w0.102: 78.95,46.83 77.1,46.83 76.66,46.39 75.62,46.39 75.19,46.82 v2(75.19,46.85)
M_B_DM5: length 58.3
  TOP w0.102: U2014.E7 v2(43.33,46.73)
  IN3 w0.089: v2(43.33,46.73) 43.84,46.21 43.84,45.48 44.45,44.87 48.04,44.87 48.17,44.99 48.17,45.29 48.3,45.41 48.72,45.41 48.88,45.25 49.06,45.25 49.22,45.41 49.43,45.41 49.52,45.32 49.52,45.2 49.44,45.12 49.44,44.99 49.57,44.87 49.69,44.87 49.77,44.95 49.9,44.95 50.86,43.99 63.77,43.99 63.83,43.93 64.22,43.93 64.29,43.99 64.55,43.99 64.8,43.75 64.8,43.62 64.32,43.14 64.32,43.02 64.44,42.89 64.57,42.89 64.84,43.17 65.05,43.37 65.17,43.37 65.3,43.25 65.3,43.12 64.96,42.78 64.82,42.64 64.82,42.52 64.95,42.39 65.07,42.39 65.55,42.87 65.68,42.87 66.21,42.33 66.21,42.15 66.09,42.02 65.46,42.02 65.33,41.9 65.33,41.75 65.42,41.65 66.41,41.65 66.52,41.54 66.52,41.41 66.42,41.31 65.51,41.31 65.42,41.22 65.42,41.07 65.53,40.96 66.46,40.96 66.57,40.84 66.57,40.7 66.44,40.57 65.59,40.57 65.5,40.48 65.5,40.33 65.63,40.21 70.39,40.21 70.52,40.33 70.52,40.62 70.63,40.74 70.78,40.74 70.87,40.65 70.87,40.31 70.98,40.21 71.19,40.21 71.28,40.3 71.28,41.05 71.42,41.19 71.55,41.19 71.63,41.1 71.63,40.3 71.72,40.21 71.9,40.21 71.99,40.3 71.99,41.1 72.08,41.19 72.22,41.19 72.35,41.06 72.35,40.3 72.43,40.21 73.2,40.21 73.29,40.3 73.29,40.5 73.21,40.58 72.84,40.58 72.74,40.68 72.74,41.01 72.87,41.13 v2(73.09,41.13)
  BOTTOM w0.102: v2(73.09,41.13) 73.55,40.67 74.8,40.67 75.74,41.61 76.87,41.61 78.34,43.09 79.19,43.09 U2030.AW31
M_B_DM6: length 62.7
  TOP w0.102: U2013.E7 v2(41.84,37.39)
  IN3 w0.089: v2(61.05,37.68) 60.79,37.93 50.28,37.93 48.14,40.08 44.62,40.08 44.46,39.91 44.46,39.91 44.29,39.74 43.44,39.74 41.84,38.14 v2(41.84,37.39)
  BOTTOM w0.102: v2(61.05,37.68) 61.05,38.16 61.17,38.29 62.22,38.29 62.74,38.81 63.16,38.81 63.32,38.98 63.57,38.98 63.74,38.81 63.91,38.81 64.05,38.96 64.05,43.37 64.18,43.5 64.36,43.5 64.49,43.37 64.49,41.91 64.58,41.82 64.76,41.82 64.91,41.96 64.91,43.39 65.01,43.5 65.21,43.5 65.31,43.39 65.31,42 65.43,41.89 65.61,41.89 65.76,42.04 65.76,43.37 65.89,43.5 70.1,43.5 70.75,42.84 70.75,40.44 73.54,37.65 76.44,37.65 76.81,37.81 80.07,37.81 81.58,39.31 81.58,39.92 81.97,40.31 81.97,40.63 82.34,41 82.34,41.34 U2030.BB26
M_B_DM7: length 57.9
  TOP w0.102: U2013.E2 43.45,38.77 v2(44.15,37.94)
  IN3 w0.089: v2(85.23,37.71) 85.23,37.14 84.42,36.33 76.35,36.33 74.19,34.17 69.49,34.17 69.36,34.05 69.36,33.34 68.97,32.95 68.97,32.47 68.75,32.25 68.61,32.25 67.19,32.25 67.07,32.38 67.07,33.43 66.94,33.56 66.66,33.56 66.55,33.45 66.55,32.36 66.46,32.27 66.22,32.27 66.11,32.38 66.11,32.75 66,32.85 65.82,32.85 65.7,32.73 65.7,32.36 65.58,32.25 56.71,32.25 56.29,31.83 50.9,31.83 50.16,32.57 50.04,32.57 49.68,32.22 49.51,32.22 49.42,32.31 49.42,32.45 49.79,32.82 49.79,32.95 49.09,33.64 48.62,33.64 48.43,33.83 48.43,34.71 47.02,36.12 44.98,36.12 44.15,36.95 v2(44.15,37.94)
  BOTTOM w0.102: U2030.BD22 85.49,40.69 85.49,37.97 v2(85.23,37.71)
M_B_DQ0: length 74.5
  TOP w0.102: v2(40.91,86.53) 40.91,86.49 U2018.H2
  IN3 w0.089: v2(40.91,86.53) 41.31,86.93 41.31,87.81 42.86,89.36 48.22,89.36 48.61,89.75 48.61,90.77 48.72,90.87 48.87,90.87 48.97,90.77 48.97,89.89 49.07,89.78 49.22,89.78 49.33,89.89 49.33,90.77 49.43,90.87 49.58,90.87 49.68,90.77 49.68,89.89 49.79,89.78 49.93,89.78 50.04,89.89 50.04,90.77 50.14,90.87 50.29,90.87 50.39,90.77 50.39,90.26 50.5,90.16 50.64,90.16 50.75,90.26 50.75,90.77 50.85,90.87 61.9,90.87 62.31,91.29 64.2,91.29 66.63,88.85 67.65,88.85 67.75,88.75 67.75,87.47 67.86,87.36 68,87.36 68.11,87.47 68.11,88.13 68.21,88.23 68.36,88.23 68.46,88.13 68.46,87.47 68.57,87.36 69.34,87.36 69.44,87.47 69.44,88.75 69.54,88.85 75.41,88.85 75.52,88.75 75.52,88.5 75.62,88.39 75.77,88.39 75.87,88.5 75.87,88.75 75.98,88.85 76.12,88.85 76.23,88.75 76.23,88.5 76.33,88.39 76.48,88.39 76.58,88.5 76.58,88.75 76.69,88.85 76.84,88.85 76.94,88.75 76.94,88.5 77.04,88.39 77.19,88.39 77.29,88.5 77.29,88.75 77.4,88.85 80.34,88.85 84.62,84.57 84.62,83.15 v2(84.39,82.92)
  BOTTOM w0.102: v2(84.39,82.92) 84.39,81.23 86.88,78.74 86.88,74.42 87.16,74.14 87.16,73.06 U2030.B21
M_B_DQ1: length 74.3
  TOP w0.102: U2018.H3 40.91,85.69 v2(40.91,85.73)
  IN3 w0.089: v2(85.76,81.55) 85.94,81.55 86.04,81.65 86.04,81.83 84.97,82.91 84.97,84.71 80.48,89.2 66.77,89.2 64.34,91.63 61.96,91.63 61.86,91.53 61.86,91.32 61.76,91.22 61.61,91.22 61.5,91.32 61.5,91.77 61.4,91.87 61.25,91.87 61.15,91.77 61.15,91.32 61.04,91.22 60.9,91.22 60.79,91.32 60.79,91.77 60.69,91.87 60.54,91.87 60.44,91.77 60.44,91.32 60.33,91.22 60.19,91.22 60.08,91.32 60.08,91.77 59.98,91.87 59.83,91.87 59.73,91.77 59.73,91.32 59.62,91.22 59.48,91.22 59.37,91.32 59.37,91.77 59.27,91.87 59.12,91.87 59.02,91.77 59.02,91.32 58.91,91.22 58.76,91.22 58.66,91.32 58.66,91.77 58.56,91.87 58.41,91.87 58.3,91.77 58.3,91.32 58.2,91.22 58.05,91.22 57.95,91.32 57.95,91.77 57.84,91.87 57.7,91.87 57.59,91.77 57.59,91.3 57.51,91.22 48.45,91.22 48.27,91.04 48.27,89.89 48.17,89.78 48.02,89.78 47.92,89.89 47.92,90.33 47.81,90.43 47.66,90.43 47.56,90.33 47.56,89.8 47.46,89.7 42.72,89.7 40.51,87.5 40.51,86.13 v2(40.91,85.73)
  BOTTOM w0.102: U2030.D21 87.01,72.45 87.39,72.83 87.47,72.83 87.82,73.18 87.82,73.43 87.59,73.66 87.59,79.04 85.76,80.87 v2(85.76,81.55)
M_B_DQ2: length 73.8
  TOP w0.102: U2018.H7 v2(40.93,82.51)
  IN3 w0.089: v2(40.93,82.51) 39.83,83.6 39.83,87.78 42.92,90.87 47.14,90.87 48.82,92.56 61.8,92.56 62.04,92.32 65.74,92.32 68.17,89.88 80.77,89.88 87.08,83.58 87.08,80.47 85.84,79.23 84.79,79.23 84.54,79.49 v2(83.53,79.49)
  BOTTOM w0.089: 85.02,73.63 85.02,72.92 U2030.B23
  BOTTOM w0.102: 85.02,73.63 85.13,73.74 85.13,74.17 84.81,74.48 84.81,77.59 83.53,78.88 v2(83.53,79.49)
M_B_DQ3: length 74.4
  TOP w0.102: v2(40.96,83.3) 40.92,83.3 U2018.J7
  IN3 w0.089: v2(82.61,80.4) 82.32,80.69 82.32,84.54 80.12,86.74 73.51,86.74 73.41,86.64 73.41,82.89 73.3,82.79 73.16,82.79 73.05,82.89 73.05,84.7 72.95,84.8 72.8,84.8 72.7,84.7 72.7,82.89 72.59,82.79 72.44,82.79 72.34,82.89 72.34,84.84 72.24,84.95 72.09,84.95 71.98,84.84 71.98,82.89 71.88,82.79 69.07,82.79 63.69,88.17 60.4,88.17 59.92,88.65 59.59,88.65 59.1,88.17 50.99,88.17 50.53,87.71 45.89,87.71 44.29,86.11 44.26,86.11 42.46,84.31 42.46,83.83 41.88,83.25 41,83.25 v2(40.96,83.3)
  BOTTOM w0.089: 84.83,73.72 84.83,73.19 84.71,73.07 84.71,72.77 85.01,72.47 U2030.D23
  BOTTOM w0.102: 84.83,73.72 84.9,73.8 84.9,74.1 84.45,74.55 84.45,77.45 82.61,79.29 v2(82.61,80.4)
M_B_DQ4: length 74.2
  TOP w0.102: U2018.G2 41.71,86.49 v2(41.71,86.53)
  IN3 w0.089: v2(41.71,86.53) 42.11,86.93 42.11,87.81 43.32,89.01 48.37,89.01 48.79,89.44 50.41,89.44 51.5,90.53 62.04,90.53 62.45,90.94 64.05,90.94 66.7,88.3 66.7,87.72 66.8,87.62 66.95,87.62 67.05,87.72 67.05,88.41 67.16,88.51 67.31,88.51 67.41,88.41 67.41,86.97 67.51,86.87 69.68,86.87 69.78,86.97 69.78,88.41 69.89,88.51 70.03,88.51 70.14,88.41 70.14,87.35 70.24,87.25 70.39,87.25 70.49,87.35 70.49,88.41 70.6,88.51 74.62,88.51 74.72,88.41 74.72,88.15 74.83,88.05 77.33,88.05 77.8,88.51 80.2,88.51 83.63,85.08 83.63,82.03 85.33,80.32 85.48,80.32 85.58,80.43 85.58,80.58 84.02,82.14 84.02,82.29 84.12,82.39 84.27,82.39 84.89,81.77 85.07,81.77 v2(85.3,82)
  BOTTOM w0.102: v2(85.3,82) 85.3,80.82 87.23,78.89 87.23,74.35 87.37,74.22 87.37,73.45 U2030.A20
M_B_DQ5: length 74.3
  TOP w0.102: v2(40.91,84.93) 40.1,84.93 U2018.J3
  IN3 w0.089: v2(86.68,80.63) 86.73,80.69 86.73,83.43 86.63,83.54 86.48,83.54 86.38,83.43 86.38,82.48 86.27,82.37 86.13,82.37 86.02,82.48 86.02,84.14 85.92,84.25 85.77,84.25 85.67,84.14 85.67,83.05 85.56,82.94 85.41,82.94 85.31,83.05 85.31,84.86 80.63,89.54 66.91,89.54 64.48,91.97 61.9,91.97 61.66,92.21 54.3,92.21 53.65,91.56 48.31,91.56 46.79,90.04 42.57,90.04 40.17,87.64 40.17,85.23 40.47,84.93 v2(40.91,84.93)
  BOTTOM w0.102: U2030.C20 88.05,72.51 88.33,72.78 88.33,73.04 88.07,73.29 88.07,73.52 87.95,73.65 87.95,79.36 v2(86.68,80.63)
M_B_DQ6: length 73.7
  TOP w0.102: U2018.F7 v2(41.73,82.51)
  IN3 w0.089: v2(83.98,79.03) 83.42,79.03 82.45,80 81.57,80 81.47,80.1 81.47,80.25 81.57,80.35 81.87,80.35 81.98,80.46 81.98,80.6 81.87,80.71 81.57,80.71 81.47,80.81 81.47,80.96 81.57,81.06 81.87,81.06 81.98,81.17 81.98,84.4 79.98,86.4 74.57,86.4 74.46,86.29 74.46,82.55 74.36,82.45 74.21,82.45 74.11,82.55 74.11,86.29 74,86.4 73.85,86.4 73.75,86.29 73.75,82.55 73.65,82.45 68.92,82.45 63.55,87.83 51.13,87.83 50.65,87.34 48.11,87.34 47.37,86.6 47.01,86.6 46.7,86.91 45.57,86.91 44.43,85.76 44.4,85.76 42.8,84.16 42.8,83.16 42.15,82.51 v2(41.73,82.51)
  BOTTOM w0.102: v2(83.98,79.03) 84.59,79.03 85.52,78.11 85.52,74.35 85.66,74.21 85.66,73.46 U2030.A22
M_B_DQ7: length 73.6
  TOP w0.102: U2018.H8 v2(40.93,81.71)
  IN3 w0.089: v2(40.93,81.71) 41.33,82.11 42.24,82.11 43.15,83.01 43.15,84.02 44.54,85.42 44.57,85.42 45.26,86.11 47.36,86.11 48.26,87 50.79,87 51.28,87.48 63.4,87.48 68.78,82.1 74.5,82.1 74.8,82.41 74.8,85.95 74.91,86.05 75.06,86.05 75.16,85.95 75.16,82.21 75.26,82.1 75.41,82.1 75.52,82.21 75.52,85.95 75.62,86.05 79.84,86.05 81.62,84.27 81.62,81.6 81.13,81.1 81.13,79.96 81.43,79.65 82.31,79.65 83.85,78.12 v2(84.9,78.12)
  BOTTOM w0.089: 85.35,73.58 85.21,73.44 85.21,73.18 85.39,73 85.39,72.63 U2030.C22
  BOTTOM w0.102: v2(84.9,78.12) 85.16,77.85 85.16,74.42 85.35,74.23 85.35,73.58
M_B_DQ8: length 58.1
  TOP w0.102: U2018.C2 44.93,85.71 44.93,85.24 45.26,84.91 v2(45.74,84.91)
  IN3 w0.089: v1(82.69,77.38) 82.75,77.32 82.75,76.95 82.62,76.82 82.33,76.82 81.48,77.67 81.06,77.67 79.34,79.39 76.09,79.39 74.42,81.06 68.35,81.06 64.22,85.2 62.48,85.2 62.38,85.3 62.38,86.34 62.27,86.44 62.13,86.44 62.02,86.34 62.02,85.3 61.92,85.2 61.77,85.2 61.67,85.3 61.67,86.34 61.56,86.44 61.42,86.44 61.31,86.34 61.31,85.3 61.21,85.2 61.06,85.2 60.96,85.3 60.96,86.34 60.85,86.44 60.7,86.44 60.6,86.34 60.6,85.3 60.5,85.2 60.35,85.2 60.24,85.3 60.24,86.34 60.14,86.44 57.98,86.44 57.23,85.69 50.61,85.69 50.48,85.57 50.48,85.35 50.35,85.22 48.41,85.22 48.17,84.98 48.17,84.83 48.04,84.71 46.91,84.71 46.7,84.51 45.87,84.51 45.74,84.63 v2(45.74,84.91)
  BOTTOM w0.089: 83.66,73.59 83.81,73.44 83.81,73.15 83.68,73.02 83.68,72.79 84.01,72.46 U2030.D24
  BOTTOM w0.102: v1(82.69,77.38) 82.69,76.8 83.66,75.84 83.66,73.59
