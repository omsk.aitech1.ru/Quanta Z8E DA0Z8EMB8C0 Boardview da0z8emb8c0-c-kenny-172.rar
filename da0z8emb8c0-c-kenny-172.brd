# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DQA1_16: length 30.8
  IN1 w0.114: v2(127.94,98.82) 128.32,99.19 137.05,99.19 139.4,96.84 143.99,96.84 146.87,93.95 146.87,92.29 v2(146.38,91.79)
  BOTTOM w0.102: v2(127.94,98.82) 127.47,98.34 125.81,98.34 125.44,98.72 125.44,98.98 124.43,99.99 123.63,99.99 123.5,100.12 123.13,100.12 123.06,100.19 122.8,100.19 122.6,100.38 U2029.B15
  BOTTOM w0.127: VRAM2002.U4 v2(146.38,91.79)
DQA1_17: length 27.7
  IN1 w0.114: v2(146.38,93.39) 146.38,93.91 143.82,96.47 139.28,96.47 136.97,98.78 v2(129.21,98.78)
  BOTTOM w0.102: U2029.A14 123.46,99.87 123.55,99.78 124.34,99.78 125.23,98.89 125.23,98.64 125.73,98.14 128.58,98.14 v2(129.21,98.78)
  BOTTOM w0.127: VRAM2002.U2 v2(146.38,93.39)
DQA1_18: length 29.2
  IN1 w0.114: v2(146.38,92.59) 145.88,93.09 145.88,93.87 143.65,96.1 139.17,96.1 136.92,98.35 127.04,98.35 v2(126.17,97.48)
  BOTTOM w0.102: v2(126.17,97.48) 125.98,97.48 125.02,98.44 125.02,98.81 124.26,99.58 123.47,99.58 123.38,99.67 123.2,99.67 123.09,99.56 122.79,99.56 122.48,99.87 U2029.B14
  BOTTOM w0.127: VRAM2002.T2 v2(146.38,92.59)
DQA1_19: length 31.7
  IN1 w0.114: v2(146.38,90.99) 147.25,91.87 147.25,94.11 144.15,97.22 139.51,97.22 137.19,99.53 130.2,99.53 130.11,99.62 125.33,99.62 v2(124.49,98.78)
  BOTTOM w0.102: v2(124.49,98.78) 124.34,98.63 123.95,98.63 123.6,98.98 123.18,98.98 122.84,99.32 U2029.B13
  BOTTOM w0.127: VRAM2002.T4 v2(146.38,90.99)
DQA1_20: length 24.9
  IN1 w0.114: v2(126.61,96.08) 126.61,95.54 127.33,94.82 131.51,94.82 131.98,94.35 133.03,94.35 133.5,94.82 133.96,94.82 134.81,93.97 136.82,93.97 137.22,93.56 137.22,92.44 138.17,91.5 142.73,91.5 v2(143.22,91)
  BOTTOM w0.102: v2(126.61,96.08) 126.34,96.08 124.47,97.96 123.76,97.96 123.49,98.22 U2029.A11
  BOTTOM w0.127: v2(143.22,91) 142.83,91.39 VRAM2002.M4
DQA1_21: length 24.9
  IN1 w0.114: v2(143.18,91.79) 143.14,91.84 138.55,91.84 137.73,92.66 137.73,93.59 137.48,93.84 137.45,93.84 136.89,94.4 136.89,94.68 136.32,95.25 128.6,95.25 v2(127.88,95.98)
  BOTTOM w0.102: v2(127.88,95.98) 127.47,95.57 126.54,95.57 124.36,97.75 123.68,97.75 123.6,97.83 123.23,97.83 122.84,98.22 U2029.B11
  BOTTOM w0.127: VRAM2002.N4 v2(143.18,91.79)
DQA1_22: length 23.8
  IN1 w0.114: v2(143.18,92.59) 142.77,92.18 140.28,92.18 136.86,95.59 128.91,95.59 v2(128.51,96)
  BOTTOM w0.102: v2(128.51,96) 128.51,95.9 127.98,95.36 126.46,95.36 124.27,97.55 123.59,97.55 123.51,97.63 123,97.63 U2029.A10
  BOTTOM w0.127: VRAM2002.N2 v2(143.18,92.59)
DQA1_23: length 23.6
  IN1 w0.114: v2(129.79,96.02) 136.93,96.02 139.11,93.84 141.16,93.84 142.38,92.62 v2(142.38,92.59)
  BOTTOM w0.102: U2029.B10 122.5,97.67 122.83,97.35 123.09,97.35 123.16,97.43 123.43,97.43 123.51,97.35 124.19,97.35 126.38,95.16 128.93,95.16 v2(129.79,96.02)
  BOTTOM w0.127: VRAM2002.M2 v2(142.38,92.59)
DQA1_24: length 26.4
  IN1 w0.114: v2(127.49,92.77) 127.5,92.77 127.5,92.44 127.85,92.08 133.77,92.08 134.45,91.41 135.35,91.41 135.59,91.16 135.59,90.51 136.33,89.78 137.68,89.78 138.7,88.76 140.51,88.76 141.92,87.34 141.92,86.68 v2(142.38,86.22)
  BOTTOM w0.102: U2029.B8 122.49,96.57 122.79,96.27 123.11,96.27 123.16,96.33 123.43,96.33 123.67,96.08 124.42,96.08 126.25,94.25 126.6,94.25 127.49,93.35 v2(127.49,92.77)
  BOTTOM w0.127: v2(142.38,86.22) 142.38,86.19 VRAM2002.M11
DQA1_25: length 25.8
  IN1 w0.114: v2(143.18,86.19) 142.94,86.19 142.55,85.81 142.18,85.81 141.25,86.73 140.77,86.73 140.4,87.1 140.4,87.24 139.22,88.42 138.56,88.42 137.53,89.44 135.35,89.44 133.97,90.82 133.97,91.4 133.63,91.74 132.44,91.74 132.42,91.72 127.66,91.72 126.55,92.83 v2(126.55,93.6)
  BOTTOM w0.102: U2029.A7 123.45,95.88 124.33,95.88 126.27,93.94 126.27,93.88 v2(126.55,93.6)
  BOTTOM w0.127: VRAM2002.N11 v2(143.18,86.19)
DQA1_26: length 27.4
  IN1 w0.114: v2(143.18,83.77) 143.09,83.86 142.88,83.86 142.38,84.35 141.67,84.35 141.39,84.64 136.99,84.64 136.37,85.26 136.37,85.93 135.82,86.47 134.41,86.47 133.94,86.95 133.94,87.49 132.92,88.51 132.8,88.51 131.15,90.16 v2(129.02,90.16)
  BOTTOM w0.102: U2029.B7 122.86,96.02 123.2,95.68 124.25,95.68 126.02,93.9 126.02,93.15 v2(129.02,90.16)
  BOTTOM w0.127: v2(143.18,83.77) 143.18,83.79 VRAM2002.N13
DQA1_27: length 26.4
  IN1 w0.114: v2(142.36,83.79) 141.75,83.79 141.32,84.22 136.92,84.22 136.5,84.64 135.39,84.64 134.19,85.84 134.19,86.21 133.54,86.86 133.54,87.41 133.07,87.87 132.95,87.87 131.81,89.01 128.79,89.01 v2(127.65,90.16)
  BOTTOM w0.102: U2029.A6 124.13,95.47 125.82,93.79 125.82,92.98 127.65,91.15 v2(127.65,90.16)
  BOTTOM w0.127: v2(142.36,83.79) 142.38,83.79 VRAM2002.M13
DQA1_28: length 27.7
  IN1 w0.114: v2(124.23,93.93) 124.89,93.93 127.56,91.25 132.07,91.25 132.19,91.38 133.34,91.38 133.54,91.17 133.54,90.77 135.21,89.1 137.39,89.1 138.42,88.07 138.67,88.07 139.47,87.27 139.47,86.9 139.99,86.38 141.11,86.38 142.03,85.46 142.8,85.46 143.12,85.78 145.17,85.78 v2(145.58,86.19)
  BOTTOM w0.102: U2029.A4 123.49,94.37 123.93,93.93 v2(124.23,93.93)
  BOTTOM w0.127: VRAM2002.T11 v2(145.58,86.19)
DQA1_29: length 33.8
  IN1 w0.114: v2(145.58,83.79) 145.68,83.69 145.68,82.7 145.13,82.16 143.2,82.16 142.8,81.75 142.78,81.75 142.39,81.35 134.57,81.35 132.26,83.66 132.26,85.7 130.24,87.72 128.13,87.72 127.73,88.11 127.07,88.11 124.93,90.26 v2(124.93,91.22)
  BOTTOM w0.102: U2029.B4 122.52,94.37 122.86,94.03 123.04,94.03 123.14,94.13 123.44,94.13 123.72,93.85 123.72,93.8 124.93,92.59 v2(124.93,91.22)
  BOTTOM w0.127: VRAM2002.T13 v2(145.58,83.79)
DQA1_30: length 33.7
  IN1 w0.114: v2(147.17,83.81) 146.65,83.29 146.34,83.29 146.05,83 146.03,83 146.03,82.56 145.28,81.81 143.35,81.81 142.94,81.4 142.93,81.4 142.53,81.01 134.42,81.01 131.91,83.52 131.91,85.55 130.09,87.37 127.98,87.37 127.59,87.77 126.91,87.77 124.47,90.21 v2(124.47,91.93)
  BOTTOM w0.102: U2029.A3 123.37,93.77 124.47,92.67 v2(124.47,91.93)
  BOTTOM w0.127: v2(147.17,83.81) 146.78,84.19 VRAM2002.U13
DQA1_31: length 29.2
  IN1 w0.114: v2(146.38,86.19) 145.63,85.44 143.26,85.44 142.95,85.12 141.88,85.12 140.96,86.04 139.81,86.04 139.25,86.6 137.61,86.6 137.09,87.12 137.09,88 136.34,88.75 135.07,88.75 134.08,89.74 132.73,89.74 131.56,90.91 127.35,90.91 125.77,92.49 v2(123.91,92.49)
  BOTTOM w0.102: v2(123.91,92.49) 123.91,92.92 123.43,93.41 123.02,93.41 U2029.B3
  BOTTOM w0.127: VRAM2002.U11 v2(146.38,86.19)
DRAM_RST_A: length 67.1
  TOP w0.127: v2(124.52,122.82) R2223.2 ; v2(140.93,105.29) 140.73,105.08 140.73,98.69 v2(139.92,97.89)
  IN1 w0.114: v2(149.67,116.45) 148.07,118.04 134.14,123.81 129.47,123.81 129.22,123.56 125.26,123.56 v2(124.52,122.82)
  IN3 w0.114: v2(149.67,116.45) 149.16,115.94 149.16,104.89 147.51,103.24 146.24,103.24 144.97,101.97 143.06,101.97 139.92,98.83 v2(139.92,97.89)
  BOTTOM w0.127: VRAM2002.J2 139.92,93.45 v2(139.92,97.89) ; VRAM2001.J2 140.78,106.18 140.78,105.44 v2(140.93,105.29)
DRAM_RST_A_R: length 15.8
  TOP w0.102: R2222.2 R2232.2 123.81,118.12 121.07,118.12 119.59,116.65 118.35,116.65 116.5,114.79 116.5,111.39 v1(116.95,110.93)
  BOTTOM w0.102: U2029.L32 117.05,110.17 117.05,110.83 v1(116.95,110.93)
EC_FPBACK#: length 188.4
  TOP w0.102: U13.86 179.94,24.16 v2(179.48,24.62) ; Q3.2 v2(57.35,110.68)
  IN3 w0.089: v2(179.48,24.62) 179.08,24.22 178.04,24.22 177.39,24.88 174.24,24.88 170.18,28.94 165.59,28.94 164.76,29.77 162.93,29.77 161.81,30.9 156.51,30.9 155.63,30.01 148.72,30.01 145.65,33.08 145.65,37.27 145.42,37.5 144.63,38.29 136.1,38.29 135.41,37.6 131.76,37.6 131.15,38.21 130.55,38.21 129.69,37.35 124.58,37.35 124.16,37.78 124.16,38.89 121.47,41.57 121.47,43.1 119.13,45.44 119.13,52.89 120,53.76 120,64.04 118.5,65.53 118.5,67.76 117.67,68.59 117.67,69.87 114.7,72.84 113.15,72.84 112.84,73.15 111.89,73.15 110.79,74.25 109.3,75.74 109.3,76.42 106.54,79.19 106.54,80.13 103.16,83.51 102.82,83.51 100.21,86.12 100.21,91.5 99.12,92.59 99.12,93.88 98.42,94.57 95.62,94.57 95.06,95.13 92.98,95.13 91.24,96.87 85,96.87 82.89,98.98 82.89,98.98 82.41,99.45 82.41,103.15 81.7,103.86 78.29,103.86 78.09,103.67 74.42,103.67 71.95,106.14 68.47,106.14 66.26,108.34 63.54,108.34 61.65,110.23 59.75,110.23 59.57,110.05 57.99,110.05 v2(57.35,110.68)
EC_ODD_EJ#: length 82.3
  TOP w0.102: R393.1 v2(185.23,28.89) ; v2(129.5,16.69) 129.5,16.4 129.22,16.12 R463.1
  IN1 w0.089: v2(129.5,16.69) 130.02,17.21 137.39,17.21 138.23,18.06 142.33,18.06 143.17,17.22 143.17,16.53 143.41,16.3 148.62,16.3 149.78,15.14 165.24,15.14 167.95,12.43 179,12.43 180.42,13.85 185.46,13.85 v2(185.86,13.45)
  BOTTOM w0.102: v2(185.23,28.89) 185.23,27.93 187.04,26.11 187.04,25.48 187.39,25.14 187.39,23.24 188.2,22.43 188.2,21.24 187.58,20.62 187.58,20.04 187.29,19.75 186.73,19.75 185.48,18.5 185.48,17.77 185.74,17.51 185.74,13.58 v2(185.86,13.45) ; v2(129.5,16.69) 129.35,16.84 CN15.16
EC_ODD_EJ_R#: length 4.3
  TOP w0.102: R393.2 184.46,27.95 v2(184.44,27.93) 184.08,27.93 183.97,28.04 C384.1 183.31,28.04 182.63,27.36 U13.94
EC_PECR_R: length 1.7
  TOP w0.102: U13.117 171.62,30.62 171.33,30.9 TP9083.1
EC_PWROK: length 98.6
  TOP w0.102: U13.33 167.22,15.12 167.37,15.28 168.34,15.28 169.23,16.17 169.4,16.17 v2(169.43,16.19) ; D2025.1 116.51,39.29 117.66,38.14 117.66,36.31 117.03,35.67 116.52,35.67 116.01,35.17 116.01,33.89 109.54,27.42 109.54,27.22 109.2,26.88 v2(106.64,26.88) 106.11,27.42 v1(106.11,27.57)
  IN3 w0.089: v1(106.11,27.57) 106.11,23.93 105.09,22.92 105.09,19.54 106.36,18.27 145.94,18.27 147.31,16.9 158.25,16.9 158.87,17.51 164.77,17.51 165.48,16.8 168.82,16.8 v2(169.43,16.19)
EC_SPI1_CLK: length 20.1
  TOP w0.102: R312.1 v2(160.46,30.31) 160.47,30.3 C373.1 ; R319.2 177.54,32.32 177.38,32.47 v1(177.38,32.73)
  IN1 w0.102: v2(160.46,30.31) 160.65,30.49 170.9,30.49 171.99,31.58 173.67,31.58 174.33,32.24 176.9,32.24 v1(177.38,32.73)
EC_SPI1_CLK_ER: length 2.7
  TOP w0.102: R319.1 177.76,31.8 176.8,30.85 176.72,30.85 176.42,30.55 U13.105
EC_SPI1_CLK_R: length 3.1
  TOP w0.102: R312.2 v2(160.46,32.85)
  BOTTOM w0.102: U33.6 v2(160.46,32.85) 160.46,33.13 v2(160.08,33.51)
EC_SPI1_SI: length 25
  TOP w0.102: R323.1 159.19,30.46 v2(159.04,30.31) 158.92,30.18 R698.1 ; v2(180.21,32.57) 180.38,32.41 R321.2
  IN1 w0.102: v2(159.04,30.31) 160.22,31.48 168.21,31.48 168.59,31.1 170.29,31.1 171.13,31.94 173.56,31.94 174.2,32.57 176.61,32.57 177.23,33.19 179.59,33.19 v2(180.21,32.57)
EC_SPI1_SI_ER: length 4
  TOP w0.102: R321.1 179.05,31.64 178.81,31.41 178.35,31.41 177.62,30.67 U13.102
EC_SPI1_SI_R: length 2.3
  TOP w0.102: R323.2 v2(159.19,32.85)
  BOTTOM w0.102: U33.5 v2(159.19,32.85)
EC_SPI1_SO: length 22.1
  TOP w0.102: v1(178.09,32.75) 178.5,32.35 R320.2
  BOTTOM w0.102: v1(178.09,32.75) 177.61,32.27 176.83,32.27 176.75,32.19 174.52,32.19 174.31,31.99 172.14,31.99 170.9,30.75 168.59,30.75 165.66,27.82 165.66,27.22 163.26,24.82 v2(163.26,24.24) 163.26,23.99 162.62,23.35 R700.1 162.34,23.82 162.38,23.86 R382.1
EC_SPI1_SO_ER: length 2.7
  TOP w0.102: R320.1 178.34,31.87 177.22,30.74 U13.103
EC_SPI1_SO_R: length 1.8
  BOTTOM w0.102: R382.2 161.6,25 161.73,25.13 U33.2
EC_SPI_CS0#: length 23.1
  TOP w0.102: R322.2 180.86,32.34 v2(180.86,32.7) ; v2(165.03,28.66) 165.03,29.7 164.77,29.96 164.15,29.96 163.64,30.47 R6594.2
  BOTTOM w0.102: v2(180.86,32.7) 180.55,33.01 179.89,33.01 179.74,33.16 177.2,33.16 176.59,32.55 174.36,32.55 174.13,32.32 172,32.32 170.76,31.08 168.45,31.08 166.04,28.66 v2(165.03,28.66) 165.03,27.3 R384.2
EC_SPI_CS0#_ER: length 4.4
  TOP w0.102: U13.101 178.02,30.61 178.49,31.08 178.95,31.08 179.18,31.3 180.99,31.3 181.11,31.43 R322.1
EC_SPI_CS0#_R: length 3.2
  BOTTOM w0.102: v2(164.15,26.4) 164.26,26.52 R384.1 163.26,27.29 163,27.04 U33.1
EC_SPI_HOLD#: length 2.6
  TOP w0.102: R335.2 161.11,31.09 160.92,31.28 160.92,33.18 TP9102.1
EC_SPI_WP#: length 0.9
  BOTTOM w0.102: TP9101.1 R363.1
EC_SPI_WP#_R: length 4.8
  BOTTOM w0.102: U33.3 160.46,25.62 161.18,24.91 161.18,24.45 160.84,24.12 R351.1 R363.2 160.47,22.33 v2(160.59,22.21)
EC_TYPEC_CHG_HI: length 164.9
  TOP w0.102: U13.3 166.47,27.36 166.6,27.23 166.6,26.93 167.13,26.4 167.45,26.4 167.8,26.05 167.8,25.54 167.6,25.33 167.6,23.18 v2(167.37,22.95) ; v2(27.82,26.64) v2(27.35,26.16) 26.86,25.67 26.86,24.42 25.46,23.03 25.46,22.47 24.45,21.45 23.18,21.45 22.16,20.43 22.16,20 21.95,19.79 R6511.1
  IN2 w0.089: v2(167.37,22.95) 166.91,22.48 166.56,22.48 165.9,23.15 162.2,23.15 161.59,22.53 155.44,22.53 154.8,21.9 146.96,21.9 144.31,24.54 131.34,24.54 130.86,25.02 121.47,25.02 120.76,24.31 116.51,24.31 115.92,24.9 110.95,24.9 110.36,24.31 98.46,24.31 96.42,22.27 95.36,22.27 94.96,21.87 92.47,21.87 92.26,22.08 91.91,22.08 90.81,23.18 85.69,23.18 85.55,23.04 82.13,23.04 80.2,21.11 68.46,21.11 67.95,21.61 53.72,21.61 51.83,23.5 51.83,24.36 51.38,24.81 43.87,24.81 43.41,24.35 39.66,24.35 38.75,25.26 31.53,25.26 30.15,26.64 v2(27.82,26.64)
EC_TYPEC_EN: length 3.9
  TOP w0.102: R416.2 184.42,22.29 184.03,21.91 182.26,21.91 182.11,21.76 U13.80
EC_TYPEC_EN_R: length 177.5
  TOP w0.102: v1(186.4,23.15) 186.4,23.11 185.57,22.29 R416.1 ; v2(28.24,26.16) 27.44,25.35 v2(27.44,24.68) 25.69,22.93 25.69,22.37 25.31,21.99 R6529.2
  IN2 w0.089: v1(186.4,23.15) 186.37,23.18 186.32,23.18 185.99,23.51 176.75,23.51 175.18,21.94 171.23,21.94 170.36,22.81 167.88,22.81 167.36,22.29 165.24,22.29 165.11,22.16 163.81,22.16 163.62,22.34 163,22.34 162.74,22.08 161.24,22.08 160.98,22.34 155.52,22.34 154.88,21.71 146.88,21.71 144.23,24.35 130.47,24.35 130.32,24.2 125.99,24.2 125.37,24.83 121.55,24.83 120.84,24.12 116.43,24.12 115.84,24.71 111.03,24.71 110.44,24.12 98.54,24.12 96.5,22.08 95.44,22.08 94.35,20.99 92.14,20.99 90.14,22.99 85.77,22.99 85.63,22.85 82.21,22.85 80.28,20.91 68.38,20.91 67.87,21.42 53.64,21.42 51.64,23.42 51.64,24.28 51.3,24.62 43.95,24.62 43.49,24.16 39.58,24.16 38.76,24.98 31.54,24.98 30.36,26.16 v2(28.24,26.16)
ECAGND: length 16.2
  TOP w0.203: 182.69,20.05 182.39,19.76 U13.75
  TOP w0.381: 186.22,17.61 185.76,17.61 185.23,18.15 C434.1 ; 186.22,17.61 186.22,16.26 L9.1 C457.1 ; 186.22,17.61 v2(187.26,17.61) 188,17.61 188.38,18 188.38,18.54 187.81,19.11 187.81,20.29 187.16,20.94 185.08,20.94 184.87,20.74 184,20.74 C433.2 182.95,20.31 182.69,20.05
ECROM_PWR: length 5.9
  TOP w0.508: v2(161.73,32.85) 161.48,32.6 R335.1 161.85,31.87 162.11,31.61 162.11,30.47 161.74,30.09 R324.2
  BOTTOM w0.508: v2(161.35,33.51) 161.73,33.13 v2(161.73,32.85) U33.7
EDCA0_0: length 29.9
  IN3 w0.114: v2(120.31,112.67) 120.84,113.2 128.31,113.2 128.71,112.8 129.72,112.8 132.09,110.42 137.21,110.42 139.58,108.05 139.58,107.62 139.9,107.3 142.74,107.3 143.44,106.6 144.29,106.6 144.41,106.72 145.32,106.72 v2(145.58,106.98)
  BOTTOM w0.102: U2029.G38 119.95,112.67 v2(120.31,112.67)
  BOTTOM w0.127: VRAM2001.C2 v2(145.58,106.98)
EDCA0_1: length 32.3
  IN3 w0.114: v2(144.77,116.59) 143.77,117.59 139.89,117.59 137.72,119.75 121.34,119.75 119.59,118.01 v2(119.59,117.74)
  BOTTOM w0.102: 119.59,117.61 119.59,117.17 120.36,116.41 120.36,116.07 120.25,115.97 U2029.F41
  BOTTOM w0.127: VRAM2001.C13 144.77,115.79 v2(144.77,116.59) ; 119.59,117.61 v2(119.59,117.74)
EDCA0_2: length 15.4
  IN1 w0.114: v2(125.59,113.93) 126.2,114.54 128.08,114.54 128.81,115.28 132.5,115.28 132.68,115.46 134.82,115.46 135.3,114.98 v2(135.98,114.98)
  BOTTOM w0.102: U2029.B37 122.83,112.52 123.13,112.83 123.53,112.83 123.73,113.02 124.32,113.02 124.55,113.24 125.03,113.24 125.59,113.8 v2(125.59,113.93)
  BOTTOM w0.127: VRAM2001.R13 v2(135.98,114.98)
EDCA0_3: length 14.9
  IN1 w0.114: v2(135.15,106.18) 134.9,105.93 134.71,105.93 134.48,105.7 133.84,105.7 133.67,105.52 132.75,105.52 132.47,105.81 132.47,106.29 131.77,106.99 131.77,107.65 131.35,108.06 126.24,108.06 v2(125.49,108.81)
  BOTTOM w0.102: v2(125.49,108.81) 125.15,109.16 123.37,109.16 U2029.A31
  BOTTOM w0.127: v2(135.15,106.18) 135.18,106.18 VRAM2001.R2
EDCA1_0: length 25.9
  IN3 w0.114: v2(135.18,92.59) 134.4,92.59 133.98,93.02 133.98,93.9 134.08,94 134.07,94.01 134.07,99.84 130.33,103.59 129.27,103.59 v2(128.9,103.22)
  BOTTOM w0.102: 126.5,104.21 126.38,104.21 126.13,104.46 124.39,104.46 123.71,105.14 123.15,105.14 123.07,105.07 122.82,105.07 122.51,105.37 U2029.B24
  BOTTOM w0.127: 126.5,104.21 126.88,104.21 127.26,104.58 127.68,104.58 127.81,104.46 127.81,103.75 127.94,103.63 128.19,103.63 128.32,103.75 128.32,104.46 128.45,104.58 128.79,104.58 128.9,104.47 v2(128.9,103.22) ; v2(135.18,92.59) VRAM2002.C2
EDCA1_1: length 26.5
  IN3 w0.114: v2(127.6,100.28) 127.6,99.81 128.21,99.2 129.37,99.2 129.63,98.95 129.63,97.24 130.21,96.66 130.21,93.36 130.42,93.15 130.42,91.23 131.14,90.51 131.14,89.88 133.06,87.97 v2(133.06,87.3)
  BOTTOM w0.102: U2029.A18 122.98,102.04 123.51,102.04 123.74,101.81 124.8,101.81 125.21,101.41 125.21,101.08 125.34,100.95 126.45,100.95 126.63,100.77 127.11,100.77 v2(127.6,100.28)
  BOTTOM w0.127: VRAM2002.C13 135.22,84.56 133.72,84.56 133.06,85.23 v2(133.06,87.3)
EDCA1_2: length 25.9
  IN1 w0.114: v2(144.78,93.39) 142.72,95.45 138.9,95.45 136.92,97.43 v2(129.06,97.43)
  BOTTOM w0.102: U2029.B12 122.48,98.77 122.81,98.44 123.09,98.44 123.17,98.53 123.48,98.53 123.84,98.16 124.55,98.16 125.88,96.83 128.46,96.83 v2(129.06,97.43)
  BOTTOM w0.127: VRAM2002.R2 v2(144.78,93.39)
EDCA1_3: length 32.4
  IN1 w0.114: v2(126.07,89.8) 126.76,89.8 127.8,88.76 128,88.76 128.39,88.37 130.5,88.37 132.9,85.97 132.9,83.93 133.64,83.2 141.13,83.2 141.93,82.4 142.53,82.4 143.33,83.2 144.18,83.2 v2(144.78,83.79)
  BOTTOM w0.102: U2029.B6 122.49,95.47 122.83,95.13 123.06,95.13 123.2,95.26 124.04,95.26 125.56,93.74 125.56,92.82 126.07,92.32 v2(126.07,89.8)
  BOTTOM w0.127: VRAM2002.R13 v2(144.78,83.79)
EEPROM_SCL: length 4.1
  BOTTOM w0.102: U2033.18 96.71,89.01 95.69,90.03 TP2090.1 94.68,90.03 94.17,90.54 R77831.1
EEPROM_SDA: length 3.8
  BOTTOM w0.102: TP2091.1 102.08,83.89 101.53,84.44 101.15,84.44 100.26,85.34 U2033.26
EMMC_CLK: length 48
  TOP w0.102: v1(67.19,34.38) 67.37,34.56 67.37,34.63 U2031.M6
  IN3 w0.089: v1(94.6,32.43) 94.29,32.43 92.84,30.97 92.52,30.97 91.4,29.86 91.4,29.6 91.12,29.32 90.03,29.32 89.6,28.89 89.6,27.96 89.31,27.67 86.38,27.67 85.88,28.17 85.16,28.17 83.73,26.74 82.48,26.74 81.07,25.33 75.67,25.33 75.24,25.76 70.04,25.76 69.95,25.85 69.95,26.4 69.77,26.58 69.38,26.58 69.23,26.43 69.23,25.85 69.14,25.76 68.51,25.76 67.96,26.31 67.96,26.44 68.32,26.8 68.32,26.98 67.97,27.33 67.79,27.33 67.46,27 67.28,27 66.36,27.92 66.36,28.45 66.23,28.58 65.19,28.58 65.06,28.45 v2(65.06,28.05)
  BOTTOM w0.102: v1(67.19,34.38) 66.72,33.9 66.72,33.45 66.23,32.96 66.23,32.37 65.83,31.97 65.34,31.97 64.78,31.41 64.78,30.14 65.06,29.86 v2(65.06,29.45) v2(65.06,28.05) ; R6579.2 94.04,32.98 v1(94.6,32.43)
EMMC_CLK_R: length 7.3
  BOTTOM w0.089: U2030.BD13 93.56,40.66 93.56,39.55 94.02,39.08
  BOTTOM w0.102: R6579.1 94.04,34.69 94.22,34.87 94.22,36.44 94.47,36.69 94.47,38.63 94.02,39.08
EMMC_CMD: length 43.7
  TOP w0.102: U2031.M5 68.11,34.42 v1(68.08,34.38)
  IN3 w0.089: v2(72.96,28.05) 72.31,28.71 72.31,29.6 72.43,29.72 74.97,29.72 77.17,27.53 80.16,27.53 82.02,29.39 82.02,32.47 82.14,32.59 83.48,32.59 85.53,30.55 87.04,30.55 88.06,31.57 88.8,31.57 89.6,32.36 89.6,33.01 90.24,33.65 91.49,33.65 91.63,33.51 91.63,32.55 91.76,32.42 v1(92.14,32.42)
  BOTTOM w0.102: v1(68.08,34.38) 68.35,34.66 69.78,34.66 70.13,34.32 72.2,34.32 72.32,34.19 72.32,33.77 72.2,33.64 71.44,33.64 71.31,33.51 71.31,33.13 71.56,32.88 72.07,32.88 72.2,32.75 72.2,29.2 72.96,28.43 v2(72.96,28.05) ; v1(92.14,32.42) 92.14,32.2 92.17,32.17 R6580.2
EMMC_CMD_R: length 12.8
  BOTTOM w0.089: 92.97,39.58 92.97,40.22 92.82,40.37 92.82,40.88 92.59,41.1 92.59,41.43 U2030.BB14
  BOTTOM w0.102: 92.97,39.58 92.97,39.53 93.33,39.17 93.33,36.91 93.53,36.71 93.53,35.23 93.17,34.87 93.17,33.29 92.54,32.66 92.54,32.32 92.62,32.25 R6580.1 92.62,31.41 92.67,31.36 R6552.1 92.67,30.89 93.36,30.21 R77880.2
EMMC_DAT0: length 43.4
  TOP w0.102: U2031.A3 69.11,29.11 69.99,28.23 69.99,27.28 v2(67.48,24.77) v2(66.86,24.15)
  IN3 w0.089: v1(97.71,32.42) 97.71,32.04 95.92,30.25 95.25,30.25 94.35,29.35 94.35,29.08 93.17,27.9 93.17,27.32 91.48,25.64 88.93,25.64 88,24.71 83.32,24.71 81.67,23.06 72.85,23.06 72.18,23.73 67.29,23.73 v2(66.86,24.15)
  BOTTOM w0.102: R6581.2 97.88,32.25 v1(97.71,32.42)
EMMC_DAT0_R: length 12.2
  BOTTOM w0.089: 94.85,39.64 94.89,39.68 94.89,40.27 94.81,40.34 94.81,40.86 94.66,41.01 94.66,41.36 U2030.BB12
  BOTTOM w0.102: R6553.1 98.61,31.96 98.52,31.86 R6581.1 98.33,32.37 97.88,32.83 97.45,32.83 96.66,33.62 96.66,34.25 96.05,34.86 96.05,35.65 95.41,36.28 95.41,38.9 94.85,39.46 94.85,39.64
EMMC_DAT1: length 44.1
  TOP w0.102: U2031.A4 68.61,28.84 69.1,28.36 69.1,27.91 69,27.79 v2(66.23,24.15)
  IN3 w0.089: v2(66.23,24.15) 66.63,24.55 67.06,24.55 67.49,24.12 72.34,24.12 73.01,23.45 81.5,23.45 83.16,25.1 86.3,25.1 87.24,26.03 91.32,26.03 92.77,27.49 92.77,28.06 93.94,29.23 93.94,29.5 95.09,30.64 95.15,30.64 95.93,31.43 97.7,33.77 v1(97.71,33.77)
  BOTTOM w0.102: R6582.2 98.08,33.77 v1(97.71,33.77)
EMMC_DAT1_R: length 10.3
  BOTTOM w0.089: 95.08,39.52 95.08,40.34 95.01,40.41 95.01,41.11 U2030.BC11
  BOTTOM w0.102: R6554.1 98.64,33.21 98.59,33.16 R6582.1 98.15,33.16 98.06,33.26 97.6,33.26 97.15,33.7 97.15,34.34 96.47,35.03 v2(96.47,35.48) 96.47,35.56 95.62,36.41 95.62,38.98 95.08,39.52
EMMC_DAT2: length 41.3
  TOP w0.102: v2(68.06,28.05) 68.11,28.11 U2031.A5
  IN3 w0.089: v1(88.53,31.96) 88.53,32.2 88.41,32.33 87.99,32.33 87.14,31.48 86.45,31.48 86.22,31.25 85.39,31.25 83.65,32.99 82.95,32.99 82.39,33.55 81.38,33.55 81.21,33.39 81.21,32.53 81.62,32.12 81.62,29.55 79.99,27.92 77.33,27.92 75.52,29.74 75.52,30.21 75.43,30.29 73.57,30.29 73.48,30.38 73.48,30.68 73.57,30.76 75.43,30.76 75.52,30.85 75.52,31.25 75.39,31.37 72.58,31.37 72.39,31.18 72.39,30.85 72.52,30.72 72.9,30.72 73.03,30.59 73.03,30.34 72.9,30.21 71.04,30.21 70.91,30.09 70.91,28.62 70.78,28.5 70.55,28.5 70.42,28.62 70.42,29.44 70.29,29.56 70.11,29.56 69.99,29.44 69.99,28.65 69.78,28.45 68.18,28.45 68.06,28.33 v2(68.06,28.05)
  BOTTOM w0.102: R6583.2 88.63,31.86 v1(88.53,31.96)
EMMC_DAT2_R: length 12.5
  BOTTOM w0.089: 91.83,39.41 91.83,40.84 91.58,41.1 91.58,41.44 U2030.BB15
  BOTTOM w0.102: 91.83,39.41 92.42,38.82 92.42,38.09 92.31,37.98 92.31,35.74 91.95,35.38 91.95,33.97 91.27,33.29 90.83,33.29 90.36,32.82 89.97,32.82 89.57,32.42 R6583.1 89.57,31.48 89.63,31.42 R6555.1
EMMC_DAT3: length 42.9
  TOP w0.079: 70.29,29.63 69.86,29.63 U2031.B2
  TOP w0.102: v2(71.05,28.05) 71.49,28.48 72.38,28.48 72.51,28.62 72.51,28.79 72.27,29.02 72.27,34.12 72.15,34.25 71.87,34.25 71.74,34.12 71.74,29.04 71.61,28.91 70.5,28.91 70.37,29.03 70.37,29.55 70.29,29.63
  IN3 w0.089: v1(90.13,32.41) 90.13,32.34 88.96,31.17 88.22,31.17 87.2,30.16 85.36,30.16 83.32,32.2 82.54,32.2 82.41,32.07 82.41,29.23 80.32,27.13 77,27.13 75.32,28.82 73.59,28.82 73.36,28.58 73.36,27.82 73.19,27.65 71.46,27.65 v2(71.05,28.05)
  BOTTOM w0.102: v1(90.13,32.41) R6584.2
EMMC_DAT3_R: length 11.5
  BOTTOM w0.089: 92.29,39.33 92.02,39.6 92.02,41.1 U2030.BC15
  BOTTOM w0.102: 92.29,39.33 92.72,38.9 92.72,35.57 92.36,35.21 92.36,33.8 91.43,32.88 90.99,32.88 90.58,32.47 R6584.1 90.58,31.48 90.64,31.42 R6556.1
EMMC_DAT4: length 42.6
  TOP w0.079: 69.36,29.24 69.36,29.62 U2031.B3
  TOP w0.102: 69.36,29.24 70.42,28.18 v2(70.42,28.05)
  IN3 w0.089: v2(70.42,28.05) 71.23,27.24 73.75,27.24 73.84,27.33 73.84,28.33 73.93,28.42 74.22,28.42 74.31,28.33 74.31,27.33 74.4,27.24 74.69,27.24 74.78,27.33 74.78,28.33 74.87,28.42 75.16,28.42 75.25,28.33 75.25,27.33 75.34,27.24 75.6,27.24 75.88,27.52 76.06,27.52 76.84,26.74 80.48,26.74 81.89,28.15 83.14,28.15 83.3,28.31 83.3,28.47 83.17,28.6 82.7,28.6 82.57,28.73 82.57,28.83 82.87,29.12 82.87,31.62 82.99,31.75 83.21,31.75 83.53,31.43 83.53,31.31 83.27,31.05 83.27,30.87 83.45,30.69 83.58,30.69 83.86,30.97 83.99,30.97 84.51,30.46 84.51,29.71 84.64,29.58 87.03,29.58 87.12,29.49 87.12,29.3 87.21,29.21 87.5,29.21 87.59,29.3 87.59,29.49 87.68,29.58 88.07,29.58 88.35,29.86 88.35,29.99 88.09,30.25 88.09,30.38 88.29,30.59 88.42,30.59 88.61,30.39 88.74,30.39 89.45,31.1 89.63,31.1 89.93,30.8 90.21,30.8 90.34,30.92 90.34,31.14 90.01,31.48 90.01,31.66 90.13,31.78 90.31,31.78 90.67,31.43 90.84,31.43 91,31.58 91,31.76 90.65,32.11 90.65,33.14 90.76,33.26 90.99,33.26 91.12,33.13 v1(91.12,32.42)
  BOTTOM w0.102: v1(91.12,32.42) 91.15,32.39 R6585.2
EMMC_DAT4_R: length 12
  BOTTOM w0.089: U2030.BA15 92.01,41.55 92.34,41.23 92.34,40.98 92.21,40.86 92.21,39.81 92.73,39.29
  BOTTOM w0.102: 92.73,39.29 93.13,38.9 93.13,35.4 92.77,35.04 92.77,33.63 91.6,32.47 R6585.1 91.6,31.51 91.66,31.45 R6557.1
EMMC_DAT5: length 43.6
  TOP w0.079: 68.86,28.97 68.86,29.63 U2031.B4
  TOP w0.102: v2(69.56,28.05) 69.56,28.28 68.86,28.97
  IN3 w0.089: v1(92.95,32.49) 92.95,33.21 92.64,33.51 92.64,34.28 92.01,34.91 92.01,37.71 91.88,37.83 91.63,37.83 91.49,37.69 91.49,35.66 91.37,35.55 90.99,35.55 90.23,34.78 90.23,34.4 90.36,34.28 91.88,34.28 92.14,34.02 92.14,33.39 92.51,33.01 92.51,32.21 92.31,32.02 91.99,32.02 90.36,30.39 89.43,30.39 87.86,28.82 86.8,28.82 86.43,29.19 84.74,29.19 83.3,27.75 82.05,27.75 80.65,26.35 76.57,26.35 76.08,26.83 71,26.83 69.78,28.05 v2(69.56,28.05)
  BOTTOM w0.102: v1(92.95,32.49) 93.18,32.26 R6586.2
EMMC_DAT5_R: length 10.8
  BOTTOM w0.089: 93.98,38.8 93.18,39.6 93.18,40.3 93.01,40.47 93.01,41.1 U2030.BC13
  BOTTOM w0.102: R6558.1 93.69,31.48 93.63,31.54 R6586.1 93.63,32.48 93.58,32.53 v2(93.58,32.79) 93.58,34.7 93.91,35.04 93.91,36.56 94.17,36.82 94.17,38.61 93.98,38.8
EMMC_DAT6: length 46.2
  TOP w0.079: 68.36,29.2 68.36,29.62 U2031.B5
  TOP w0.102: 68.36,29.2 68.36,28.71 68.69,28.38 v2(68.69,28.05)
  IN3 w0.089: v2(68.69,28.05) 68.69,27.49 68.88,27.3 69.16,27.3 69.4,27.55 69.74,27.55 70.9,26.38 75.9,26.38 76.33,25.95 80.81,25.95 82.22,27.36 83.47,27.36 84.9,28.8 86.13,28.8 86.64,28.29 88.7,28.29 88.89,28.49 88.89,29.06 89.77,29.95 90.47,29.95 92.14,31.61 92.59,31.61 93.51,32.52 93.51,33.29 93.15,33.64 93.15,34.4 92.52,35.04 92.52,37.32 92.64,37.45 92.9,37.45 93.03,37.32 93.03,36.24 93.15,36.11 94.59,36.11 94.68,36.02 94.68,35.73 94.59,35.64 93.15,35.64 93.03,35.51 93.03,35.17 93.66,34.53 93.66,33.95 v1(94.6,33.01)
  BOTTOM w0.102: v1(94.6,33.01) 94.75,33.16 R6587.2
EMMC_DAT6_R: length 9.4
  BOTTOM w0.089: U2030.BB13 93.67,41.35 93.67,40.98 93.81,40.84 93.81,40.57 93.76,40.51 93.76,39.64 94.17,39.22
  BOTTOM w0.102: R77883.1 95.18,33.77 94.96,33.99 R6587.1 94.75,34.23 94.8,34.28 94.8,38.59 94.17,39.22
EMMC_DAT7: length 42.2
  TOP w0.079: 67.36,29.19 67.36,29.62 U2031.B6
  TOP w0.102: 67.36,29.19 66.86,28.69 65.06,28.69 v2(64.43,28.05)
  IN3 w0.089: v1(96.07,32.63) 96.07,32.47 95.64,32.03 95.64,31.69 94.99,31.04 94.92,31.04 93.53,29.65 93.53,29.5 90.46,26.43 87.07,26.43 86.14,25.49 82.99,25.49 81.34,23.84 73.23,23.84 72.55,24.52 67.96,24.52 v2(64.43,28.05)
  BOTTOM w0.102: R6588.2 96.07,32.47 v1(96.07,32.63)
EMMC_DAT7_R: length 11.6
  BOTTOM w0.089: U2030.BC12 94.01,40.46 93.95,40.4 93.95,39.73 94.35,39.32 94.41,39.32
  BOTTOM w0.102: 94.41,39.32 95.01,38.73 95.01,36.05 95.24,35.83 v2(95.24,35.09) 95.24,34.86 95.36,34.73 95.36,33.95 95.52,33.79 95.52,33.58 95.69,33.41 95.69,32.12 96.17,31.64 R6588.1 96.33,31.61 96.86,31.07 R6559.1
EMMC_RCLK: length 43.8
  TOP w0.102: U2031.H5 68.34,32.87 v1(68.59,32.63)
  IN3 w0.089: v2(65.7,28.05) 65.7,27.7 68.26,25.14 74.99,25.14 75.42,24.71 81.33,24.71 82.73,26.12 85.88,26.12 86.82,27.05 89.82,27.05 90.99,28.22 90.99,28.31 91.63,28.94 92.09,28.94 92.58,29.43 92.58,30.15 92.78,30.35 93.1,30.35 94.53,31.79 94.63,31.79 95.01,32.17 95.01,32.6 95.64,33.23 96.07,33.23 v1(96.07,33.23)
  BOTTOM w0.102: v1(96.07,33.23) 96.55,32.75 R6589.2 ; v1(68.59,32.63) 68.1,32.14 68.1,31.39 68.4,31.09 68.4,30.68 67.55,29.83 66.98,29.83 65.7,28.54 v2(65.7,28.05)
EMMC_RCLK_R: length 11.7
  BOTTOM w0.089: U2030.BA12 94.01,41.55 94.32,41.24 94.32,40.97 94.21,40.86 94.21,40.36 94.14,40.29 94.14,39.81 94.36,39.59 94.44,39.59
  BOTTOM w0.102: R6560.1 97.01,32.17 R6589.1 97.01,32.96 96.25,33.72 95.95,33.72 95.57,34.1 95.57,34.61 95.85,34.89 95.85,35.55 95.21,36.18 95.21,38.82 94.44,39.59
EMMC_RST_L_R: length 6.9
  TOP w0.102: U2031.K5 68.29,33.87 v1(68.64,34.23)
  BOTTOM w0.102: R2714.2 67.93,33.51 v1(68.64,34.23) 69.33,34.23 v2(70.17,33.39) 71.27,32.28 D2040.2
EMMC_VDDI_BYP: length 4.6
  TOP w0.079: 69.82,30.63 70.57,30.63 70.7,30.5 70.7,30.12 69.86,30.12 U2031.C2 69.61,30.42 69.82,30.63
  TOP w0.508: v2(71.31,29.45) 70.7,30.06 70.7,30.12
  BOTTOM w0.203: C146.1 71.59,29.17 v2(71.31,29.45)
EN: length 4.1
  TOP w0.102: R451.1 205.19,17.69 205.65,17.69 R446.2 205.96,17.13 206.08,17 207.1,17 207.23,16.87 U17.7
EQ0: length 1.9
  BOTTOM w0.102: U26.13 20.66,74.9 21.27,74.28 R2708.1
EQ1: length 11.9
  TOP w0.102: U17.17 212.91,15.87 v2(213.14,15.63) ; R477.2 R476.1 204.88,13.48 205.22,13.14 v2(205.42,13.14)
  IN2 w0.089: v2(205.42,13.14) 205.65,13.37 208.19,13.37 209.09,14.27 211.33,14.27 212.69,15.63 v2(213.14,15.63)
EQ2: length 11.9
  TOP w0.102: U17.19 212.91,16.87 v2(213.17,17.13) ; v2(205.42,15.28) 205.22,15.28 204.88,14.94 R470.1 R471.2
  IN2 w0.089: v2(213.17,17.13) 211.01,14.97 205.73,14.97 v2(205.42,15.28)
ESPI_0: length 75
  TOP w0.102: R6573.1 157.8,20.43 157.54,20.18 157.54,19.54 157.19,19.19 153.69,19.19 153.16,18.66 v2(152.44,18.66)
  IN1 w0.102: v2(152.44,18.66) 152.23,18.66 151.75,18.17 150.5,18.17 148.97,19.7 137.47,19.7 136.63,18.86 128.86,18.86 128.6,18.59 115.64,18.59 115.35,18.3 105.86,18.3 105.07,19.09 105.07,24.2 104.66,24.6 104.66,30.39 104.35,30.69 104.35,31.47 v1(104.29,31.53)
  BOTTOM w0.102: v1(104.29,31.53) 103.01,31.53 101.81,32.73 101.81,33.36 101.1,34.07 R6541.2
ESPI_0_R: length 10.2
  TOP w0.102: U13.10 164.71,24.56 164.53,24.37 164.53,23.99 163.64,23.1 162.87,23.1 162.63,22.87 162.63,22.35 162.32,22.03 159.9,22.03 158.4,20.54 R6573.2 R6564.1
ESPI_1: length 69.2
  TOP w0.102: v2(151.93,19.06) 152.39,19.52 155.99,19.52 156.14,19.67 R6574.1
  IN1 w0.102: v1(104.28,32.19) 104.76,31.71 104.76,30.8 104.99,30.57 104.99,24.74 105.4,24.33 105.4,19.23 106,18.63 115.21,18.63 115.5,18.92 128.46,18.92 128.72,19.19 136.49,19.19 137.33,20.03 149.11,20.03 150.64,18.5 151.37,18.5 v2(151.93,19.06)
  BOTTOM w0.102: R6540.2 103,34.3 103,33.46 v2(103.64,32.83) v1(104.28,32.19)
ESPI_1_R: length 11.5
  TOP w0.102: U13.9 164.65,24.96 164.2,24.51 164.2,24.13 163.5,23.43 162.44,23.43 161.37,22.36 159.76,22.36 158.2,20.8 157.66,20.8 157.29,20.43 R6565.1 R6574.2
ESPI_2: length 74.5
  TOP w0.102: R6575.1 155,20.94 154.77,20.71 154.45,20.71 v2(154.02,20.28)
  IN1 w0.102: v1(101.39,32.93) 101.98,32.34 101.98,31.06 103.62,29.42 103.62,24.24 104.08,23.78 104.08,18.68 105.68,17.08 108.4,17.08 108.63,17.31 115.76,17.31 116.05,17.6 129.01,17.6 129.27,17.87 137.11,17.87 137.96,18.71 143.35,18.71 144.88,17.18 152.77,17.18 153.58,17.99 153.58,18.76 154.02,19.19 v2(154.02,20.28)
  BOTTOM w0.102: v1(101.39,32.93) 101.39,33.19 99.91,34.67 99.91,35.44 99.93,35.47 R6542.2
ESPI_2_R: length 12.7
  TOP w0.102: U13.8 164.58,25.36 163.87,24.64 163.87,24.26 163.36,23.76 162.3,23.76 161.24,22.69 159.62,22.69 158.1,21.17 156.37,21.17 156.15,20.94 R6575.2 R6566.1
ESPI_3: length 83.7
  TOP w0.102: R6576.1 162.49,24.88 160.96,23.35 159.35,23.35 158.05,22.06 156.68,22.06 155.93,21.31 154.9,21.31 154.66,21.07 154.17,21.07 v2(153.38,20.28)
  IN1 w0.102: v1(102.36,31.33) 103.95,29.74 103.95,24.38 104.41,23.92 104.41,18.82 105.59,17.64 115.62,17.64 115.92,17.93 128.87,17.93 129.14,18.2 136.98,18.2 137.82,19.04 143.82,19.04 145.35,17.51 152.56,17.51 153.25,18.2 153.25,20.15 v2(153.38,20.28)
  BOTTOM w0.102: R6543.2 99.3,35.75 99.57,35.48 99.57,34.54 100.98,33.13 100.98,32.76 101.24,32.5 101.53,32.5 102.36,31.67 v1(102.36,31.33)
ESPI_3_R: length 4.1
  TOP w0.102: R6576.2 R6567.1 163.28,24.14 163.54,24.4 163.54,24.78 164.51,25.76 U13.7
ESPI_ALERT#: length 1.9
  TOP w0.102: Q6565.6 109.77,16.23 109.66,16.12 R77859.1 v2(109.25,15.35)
ESPI_ALERT#_Q: length 38.2
  TOP w0.102: Q6565.1 111.46,16.23 111.06,16.62 111.06,18.27 111.31,18.53 R77869.1 111.72,18.68 111.95,18.91 113.4,18.91 v2(113.55,19.06)
  IN1 w0.089: v2(113.55,19.06) 112.36,19.06 105.64,25.78 105.64,30.88 105.47,31.05 105.47,31.25 v1(105.94,31.72)
  BOTTOM w0.102: v1(105.94,31.72) 106.35,31.72 106.53,31.91 106.53,32.92 107.4,33.79 107.4,34.57 103.82,38.16 102.9,38.16 101.65,39.4 101.04,39.4 100.25,40.19 99.77,40.19 99.01,40.96 U2030.BC6 ; v2(113.55,19.06) 113.6,19.11 R77876.1
ESPI_CLK: length 70.1
  TOP w0.102: R6577.1 163.76,22.08 163.38,21.7 v2(163.2,21.7)
  IN3 w0.102: v1(107,34.4) 108.52,32.88 108.8,32.88 109.23,32.45 109.23,31.54 109.41,31.36 109.41,29.99 110.73,28.67 110.73,24.91 113.53,22.11 119.41,22.11 119.97,22.67 122.82,22.67 123.51,23.35 132.52,23.35 133.15,23.98 144.72,23.98 145.27,23.43 147.84,23.43 148.15,23.74 149.79,23.74 151.45,22.08 154.8,22.08 155.97,23.25 158.15,23.25 158.56,22.85 160.59,22.85 161.74,21.7 v2(163.2,21.7)
  BOTTOM w0.102: R2403.2 106.52,33.92 v1(107,34.4) ; R419.2 v2(163.2,21.7)
ESPI_CLK_R: length 2.8
  TOP w0.102: U13.13 164.53,23.36 163.86,22.69 R6577.2 R6568.1
ESPI_CS#: length 88.8
  TOP w0.102: R6578.1 162.88,26.53 161.7,25.36 160.87,25.36 159.14,24.08 157.78,22.72 156.12,22.72 155.04,21.64 154.77,21.64 154.52,21.4 150.51,21.4 150.15,21.04 150.15,20.8 v2(150.4,19.93) v2(150.65,19.06)
  IN1 w0.102: v1(104.2,36.33) 104.22,36.31 105.47,34.15 105.47,33.39 106.33,31.85 106.54,28.11 106.98,24.9 112.09,19.79 114.82,19.44 115.44,19.25 120.22,19.25 120.71,19.74 121.73,19.74 121.91,19.7 124.38,19.28 124.52,19.25 128.32,19.25 128.59,19.52 135.38,19.52 135.99,19.8 137.21,20.36 149.35,20.36 v2(150.65,19.06)
  BOTTOM w0.102: U2030.BA8 98.01,41.55 97.7,41.24 97.7,40.96 97.98,40.68 97.98,40.18 98.8,39.36 99.47,39.36 100.56,38.26 101.39,38.26 102.49,37.17 102.88,37.17 103.14,36.91 103.14,36.21 103.39,35.95 103.82,35.95 v1(104.2,36.33) 104.33,36.21 104.33,34.66 104.07,34.4 R77857.1
ESPI_CS#_R: length 3
  TOP w0.102: U13.6 164.01,26.16 163.65,25.79 R6571.1 R6578.2
ESPI_RESET#: length 66.1
  IN1 w0.102: v2(113.98,16.85) 114.45,16.85 114.58,16.98 115.89,16.98 116.19,17.27 125.55,17.27 125.7,17.12 128.99,17.12 129.41,17.54 137.25,17.54 138.1,18.38 143.21,18.38 144.78,16.81 148.84,16.81 149.99,15.66 158.37,15.66 159.32,16.61 159.32,18.95 v2(160.68,20.31)
  BOTTOM w0.102: R77871.1 119.54,24.72 119.47,24.65 R77870.1 119.47,24.01 119.2,23.74 D8516.2 117.66,23.74 117.02,23.09 115.98,23.09 114.74,21.85 114.74,20.5 113.98,19.73 v2(113.98,16.85) ; R441.1 161.76,21.2 160.87,20.31 v2(160.68,20.31)
ESPI_RESET#_Q: length 35.9
  TOP w0.102: v2(107.38,16.37) 107.38,16.62 107.66,16.91 R77868.1 108.42,16.91 v2(108.9,17.39) 109.04,17.53 Q6565.4
  IN1 w0.102: v2(107.38,16.37) 107.12,16.62 105.6,16.62 101.69,20.53 101.69,27.04 102.12,27.47 102.12,29.27 100.71,30.68 100.71,31.44 v1(101.36,32.09)
  BOTTOM w0.102: v1(101.36,32.09) 101.18,32.09 100.65,32.62 100.65,32.99 98.51,35.13 98.51,35.56 98.51,36.74 98.05,37.2 97.69,37.2 97.22,37.67 97.22,38.39 95.69,39.91 95.69,40.46 95.82,40.59 95.82,40.85 95.69,40.98 95.69,41.33 U2030.BB11
FAN1_RPM: length 23.4
  TOP w0.102: U13.47 172.82,15.92 173.4,16.51 174.94,16.51 v2(175.45,16)
  BOTTOM w0.102: FAN1.2 180.72,28.87 181.04,28.56 R371.2 181.29,26.12 181.42,25.99 181.42,23.43 179.89,21.91 179.34,21.91 v2(179.07,21.64) 178.61,21.19 178.61,19.33 179.06,18.89 179.06,18.45 178.45,17.84 177.43,17.84 176.68,17.09 176.05,17.09 175.45,16.5 v2(175.45,16)
FAN_PWM: length 2
  TOP w0.254: v2(164.15,15.48) 164.27,15.35 164.91,15.35
  BOTTOM w0.254: v2(173.8,20.31) 174.18,20.31 174.5,20.63 Q16.1
FAN_PWM_C: length 8.4
  BOTTOM w0.254: FAN1.3 178.16,30.13 177.48,29.45 177.48,28.18 177.23,27.93 177.23,23.61
FB_VMEMIO: length 6.5
  BOTTOM w0.102: TP8000.1 122.33,88.85 122.33,92.58 122.11,92.8 121.79,92.8 121.58,93.01 121.58,93.27 121.9,93.59 U2029.C3
G5335-AGND: length 9.6
  IN2 w0.406: v2(148.47,61.66) 146.92,61.66 145.84,62.74 v1(145.65,62.74)
  BOTTOM w0.152: PC9096.2 148.17,61.68 148.19,61.66 v2(148.47,61.66) 148.85,62.03 148.97,62.03 149.09,62.15 149.09,63.28 148.96,63.41 PC9077.2
  BOTTOM w0.203: PR9126.2 145.11,61.7 145.56,62.15 PR9117.1 145.86,62.04 PR9116.1
  BOTTOM w0.254: PR9117.1 145.76,62.62 v1(145.65,62.74) 145.47,62.92 PU9005.4
G5335-AGND-1: length 46.6
  TOP w0.127: v1(121.72,50.61) 121.55,50.61 121.25,50.31 PR2015.1 118.65,50.31 118.55,50.41 PR9296.2
  IN1 w0.127: v2(146.01,42.43) 146.68,43.1 v2(146.68,45.42)
  IN3 w0.127: v1(121.72,50.61) 123.68,50.61 123.84,50.45 123.84,50.27 123.26,49.69 123.26,49.51 123.44,49.33 123.62,49.33 124.2,49.91 124.38,49.91 124.56,49.73 124.56,49.55 123.98,48.97 123.98,48.79 124.16,48.61 124.34,48.61 124.92,49.19 125.1,49.19 125.26,49.03 125.26,48.85 125.03,48.63 125.03,48.25 125.22,48.06 142.62,48.06 142.81,48.25 143.86,48.25 144.29,47.81 144.29,47.64 143.99,47.34 143.99,47.16 144.14,47.01 144.38,47.01 144.65,47.28 144.83,47.28 v2(146.68,45.42)
  BOTTOM w0.203: PR2011.2 147.61,41.85 147.46,41.99 146.78,41.99 146.63,42.14 PR2013.1 146.63,43.18 PR2006.2 ; PC2016.2 146.87,45.23 v2(146.68,45.42) 146.68,45.55 146.22,46.01 145.36,46.01 PC2017.2
  BOTTOM w0.254: PU2000.4 145.95,42.49 v2(146.01,42.43) 146.57,42.43 PR2013.1
G5335-BST: length 4.6
  BOTTOM w0.219: PR9137.2 149.86,66.6 149.86,66.2 149.86,66.19 149.86,65.38 149.72,65.25 148.71,65.25 148.57,65.38 148.57,65.56 148.35,65.79 PU9005.20
G5335-BST-1: length 4.7
  BOTTOM w0.254: PU2000.20 142.72,45.4 143.13,45.8 143.13,46.67 142.9,46.9 141.97,46.9 141.31,46.24 PR2003.2
G5335-EN: length 8.8
  TOP w0.102: v2(147.78,61.03) 147.78,62.49 149.29,63.99 PR77853.1
  BOTTOM w0.152: PU9005.2 146.47,63.09 146.67,62.89 146.82,62.89 147.23,62.48 147.23,62.47 147.31,62.4 147.31,61.91 PC9096.1
  BOTTOM w0.203: PR9118.2 147.99,60.82 v2(147.78,61.03) 147.54,61.27 PC9096.1
G5335-EN-1: length 4
  BOTTOM w0.152: PR2009.2 147.28,45.54 147.28,44.56 147.03,44.31 PC2016.1 146.59,44.03 146.03,44.03 145.49,43.49 PU2000.2
G5335-FB: length 3.4
  BOTTOM w0.203: PU9005.5 144.97,62.67 144.85,62.56 PR9126.1 PR9125.2 143.88,62.14 PC9095.1
G5335-FB-1: length 3.4
  BOTTOM w0.254: PU2000.5 145.42,41.99 145.86,41.55 PR2010.2 147.15,41.55 PR2011.1 147.16,40.86 PC2014.1
G5335-LX:
  vias: v2(147.89,68.57)
G5335-LX-1:
  vias: v2(139.76,43.8)
G5335-PFM: length 2.8
  BOTTOM w0.203: PU9005.3 145.97,63.07 146.44,62.6 146.7,62.6 146.98,62.32 PR9116.2 PR9124.1
G5335-PFM-1: length 3
  BOTTOM w0.203: PR2005.1 147.33,43.27 146.88,43.72 PR2006.1 146.18,43.72 145.44,42.99 PU2000.3
G5335-PWRGD: length 1.4
  BOTTOM w0.152: PR9119.2 147.62,62.48 147.37,62.73 147.35,62.73 146.97,63.11 PU9005.1
G5335-PWRGD-1: length 1.3
  BOTTOM w0.152: PR2004.1 145.89,44.34 145.54,43.99 PU2000.1
G5335-SS: length 1.3
  BOTTOM w0.203: PC9077.1 148.28,64.07 148.06,64.29 PU9005.23
G5335-SS-1: length 1.3
  BOTTOM w0.203: PU2000.23 144.22,45 144.52,45.3 PC2017.1
G5335-TON: length 2.3
  BOTTOM w0.254: PR9120.1 142.42,64.05 142.92,63.54 PU9005.6
G5335-TON-1: length 2.3
  BOTTOM w0.203: PU2000.6 144.97,41.48 144.62,41.13 144.62,40.98 144.61,40.96 144.61,40.18 144.37,39.94 PR2001.1
G5335-VCC: length 3.2
  BOTTOM w0.254: PU9005.21 148.16,65.29 148.24,65.22 148.24,65.21 148.89,64.56 PC9074.1
  BOTTOM w0.406: PR9121.2 149.54,63.35 149.54,63.74 149.22,64.06 PC9074.1
G5335-VCC-1: length 3
  BOTTOM w0.254: PU2000.21 143.22,45.36 143.72,45.86 PC2004.1
  BOTTOM w0.457: PR2002.2 144.64,46.24 PC2004.1
G_MBCLK_R: length 4.1
  TOP w0.102: U16.4 65.66,15.67 65.71,15.62 C467.1 65.34,15.1 65.11,14.87 R483.2 R484.2 v2(63.31,14.87)
G_MBDATA_R: length 4.2
  TOP w0.102: v2(68.54,14.85) 68.29,15.1 R475.2 R468.2 67.78,16.12 67.36,16.53 C464.1 67.36,17.52 67.19,17.7 U16.6
G_WAKEB: length 9.5
  BOTTOM w0.102: R2631.1 106.61,120.13 106.23,119.75 106.23,118.6 106.34,118.5 106.34,117.7 105.69,117.05 102.94,117.05 102.61,116.73 102.61,115.56 102.9,115.28 102.9,114.88 103.2,114.57 U2029.AU40
GC6FBEN_Q_EC: length 1.9
  TOP w0.102: U13.2 164.74,27.76 164.65,27.67 163.89,27.67 TP39.1
GENERICA: length 7.5
  BOTTOM w0.102: U2029.BA38 100.44,113.07 100.3,113.22 99.93,113.22 99.2,113.96 99.2,118.17 99.38,118.35 TP8071.1
GFX_TX0N_C: length 10.7
  BOTTOM w0.102: U2030.N3 101.14,65.14 101.47,65.14 101.64,65.31 102.67,65.31 103.49,66.13 103.87,66.13 106.16,68.41 109.92,68.41 C2653.2
GFX_TX0P_C: length 10
  BOTTOM w0.102: U2030.N1 101.89,65.09 102.76,65.09 103.58,65.91 103.96,65.91 106.25,68.2 110.07,68.2 110.2,68.07 C2652.2
GFX_TX1N_C: length 9.2
  BOTTOM w0.089: U2030.M4 100.96,65.64 101.2,65.76 101.28,65.83 101.41,65.83 101.6,65.79 101.64,65.75 101.79,65.73 102.38,65.73
  BOTTOM w0.102: C2651.2 107.91,69.61 107.79,69.48 106.13,69.48 102.38,65.73
GFX_TX1P_C: length 8.2
  BOTTOM w0.102: U2030.M2 101.41,65.51 102.47,65.51 106.22,69.26 107.6,69.26 C2650.2
GFX_TX2N_C: length 11.5
  BOTTOM w0.102: C2649.2 109.87,70.65 106.23,70.65 102.38,66.8 102.06,66.8 101.96,66.7 101.67,66.7 101.54,66.83 101.27,66.83 100.94,66.51 U2030.L4
GFX_TX2P_C: length 10.6
  BOTTOM w0.102: U2030.L2 101.43,66.49 102.05,66.49 102.15,66.58 102.47,66.58 106.32,70.43 109.86,70.43 C2648.2
GFX_TX3N_C: length 8.9
  BOTTOM w0.102: U2030.L3 101.54,67.2 101.92,67.42 106.33,71.83 107.62,71.83 C2647.2
GFX_TX3P_C: length 8.3
  BOTTOM w0.102: C2646.2 107.91,71.46 107.76,71.61 106.42,71.61 U2030.L1
GPIO_0: length 8.2
  BOTTOM w0.102: R2607.2 R2626.2 115.48,120.31 115.76,120.03 115.76,118.48 113.41,116.12 113.41,114.87 113.33,114.79 113.33,114.55 U2029.W40
GPIO_1: length 9.1
  BOTTOM w0.102: U2029.AA40 112.23,114.55 112.23,114.8 112.33,114.9 112.33,116.76 112.99,117.42 112.99,121.32 113.5,121.83 R2623.2 R2604.2
GPIO_2: length 16.1
  TOP w0.102: v2(112.56,111.64) 113.24,112.33 113.24,112.59 113.24,112.59 113.24,113.81 119.52,120.08 120.25,120.08 120.51,119.82 120.86,119.82 120.97,119.92 R2211.2 120.68,120.16 120.58,120.26 120.58,120.86 120.46,120.99 120.46,121.3 R2218.2
  BOTTOM w0.102: v2(112.56,111.64) 112.24,111.32 U2029.AA35
GPIO_8_ROMSO: length 23.9
  TOP w0.102: v2(109.28,118.07) 108.42,118.93 R2661.2 TP8012.1 107.76,122.69 107.86,122.79 R2660.2 R2664.1
  IN1 w0.089: v2(104.81,105.47) 104.81,105.5 105.16,105.85 106.74,105.85 106.9,106.01 106.9,106.39 107.18,106.67 107.63,106.67 109.03,108.06 109.03,109.33 109.92,110.22 109.92,114.03 110.42,114.54 110.42,116.93 v2(109.28,118.07)
  BOTTOM w0.102: v2(104.81,105.47) 104.81,105.53 U2029.AP25
GPIO_9_ROMSI: length 27.4
  TOP w0.102: R2656.1 118.65,121.37 TP8008.1 v2(118.68,122.08)
  IN1 w0.089: v2(118.68,122.08) 118.68,119.24 113.25,113.81 111.48,113.81 110.81,113.14 110.81,110.1 110.04,109.33 110.04,108.7 108.01,106.67 108.01,106.29 107.38,105.65 107.12,105.65 106.92,105.45 v2(105.6,105.45)
  BOTTOM w0.102: R77855.2 118.14,122.6 R77856.2 118.63,122.03 v2(118.68,122.08) ; U2029.AM25 105.6,105.52 v2(105.6,105.45)
GPIO_10_ROMSCK: length 30.2
  TOP w0.102: R2657.1 117.92,122.54 117.66,122.8 TP8006.1 118.04,123.05 118.38,122.72 v2(118.68,122.72)
  IN1 w0.089: v2(118.68,122.72) 118.27,122.31 118.27,119.47 117.66,118.86 116.65,118.86 115.76,117.97 111.69,117.97 111.19,118.48 109.12,118.48 108.88,118.24 108.88,117.27 110.04,116.11 110.04,114.7 108.77,113.43 108.77,111.49 107.5,110.22 107.5,109.84 107,109.33 107,107.66 106.26,106.92 v2(106.26,106.46)
  BOTTOM w0.102: U2029.AM27 106.26,106.77 v2(106.26,106.46)
GPIO_11: length 5.7
  BOTTOM w0.102: U2029.W41 113.1,116.24 115.48,118.62 R2627.2 R2608.2
GPIO_12: length 6.3
  BOTTOM w0.102: U2029.Y40 112.55,114.2 112.91,114.56 112.91,114.75 112.79,114.88 112.79,116.28 113.5,116.99 R2624.2 R2605.2
GPIO_13: length 7
  BOTTOM w0.102: U2029.Y41 112.55,116.37 113.22,117.03 113.22,120.14 113.5,120.42 R2625.2 R2606.2
GPIO_15: length 5.1
  TOP w0.102: v2(112.2,117.46) 112.81,118.07 R77854.2 R77853.2
  BOTTOM w0.102: U2029.AA41 112,117.26 v2(112.2,117.46)
GPIO_20: length 6.6
  BOTTOM w0.102: U2029.AB40 111.45,114.22 111.77,114.54 111.77,114.79 111.69,114.87 111.69,117.72 111.93,117.95 112.41,117.95 112.68,118.22 R2622.2 R2603.2
GPIO_21_PCC: length 4.3
  BOTTOM w0.102: TP8527.1 111.64,118.43 111.45,118.24 U2029.AB41
GPIO_22_ROMCSB: length 28.5
  TOP w0.102: R2667.2 R2669.1 R2668.2 TP8013.1 107.75,124.07 106.67,122.98 106.67,121.98 108.14,120.51 108.14,118.58 v2(109.28,117.44)
  IN1 w0.089: v2(109.28,117.44) 110.23,116.48 110.23,114.62 109.73,114.11 109.73,111.43 108.65,110.35 108.65,109.97 108.01,109.33 108.01,108.32 106.71,107.02 106.71,106.13 106.61,106.04 105.08,106.04 104.95,105.9 104.58,105.9 v2(104.02,106.46)
  BOTTOM w0.102: v2(104.02,106.46) 104.02,107.22 104.2,107.4 104.82,107.4 U2029.AP27
GPIO_28_FDO: length 16
  TOP w0.102: R8047.2 R8042.1 122.21,122.66 122.06,122.51 122.06,119.67 121.22,118.84 120.81,118.84 120.42,118.45 119.18,118.45 115.14,114.4 115.14,112.77 114.92,112.56 v2(114.78,112.56)
  BOTTOM w0.102: v2(114.78,112.56) 114.57,112.56 U2029.U38
GPIO_29: length 18
  TOP w0.102: R2212.2 121.83,124.86 122.06,124.62 122.06,123.51 121.88,123.33 R2219.2 121.6,119.87 121.02,119.29 120.62,119.29 120.23,118.91 118.99,118.91 114.06,113.97 114.06,112.83 v2(113.65,112.42)
  BOTTOM w0.102: v2(113.65,112.42) 113.35,112.12 U2029.W37
GPIO_30: length 17.5
  TOP w0.102: v2(113.65,113.11) 113.65,113.89 118.9,119.14 120.14,119.14 120.52,119.52 120.92,119.52 121.35,119.95 121.35,122.92 121.22,123.05 121.22,123.18 121.06,123.33 R8046.2 120.56,123.33 120.46,123.43 120.46,124.75 120.56,124.86 R8041.1
  BOTTOM w0.102: v2(113.65,113.11) 113.47,112.92 U2029.W38
GPIO_5441: length 4.6
  TOP w0.102: U2034.23 19.12,18.77 18.73,19.16 18.73,19.93 R6516.2 17.71,20.57 17.59,20.44 17.59,20.28 17.46,20.15 R6514.2
GPIO_SVC: length 9.3
  TOP w0.102: v2(103.26,102.14) 102.86,101.74 101.87,101.74 100.58,100.44 96.96,100.44 96.58,100.06 96.58,99.7 96.31,99.43 R2243.1
  BOTTOM w0.102: v2(103.26,102.14) 103.6,101.8 U2029.AU17
GPIO_SVD: length 8
  TOP w0.102: v2(102.47,102.17) 102.27,101.97 101.78,101.97 100.48,100.67 96.81,100.67 96.33,100.19 R2242.1
  BOTTOM w0.102: v2(102.47,102.17) 102.8,101.84 U2029.AV17
GPIO_SVT: length 9.6
  TOP w0.102: v2(104.02,102.14) 103.57,102.6 102.04,102.6 101.03,101.59 100.01,101.59 99.38,100.95 R2241.1
  BOTTOM w0.102: v2(104.02,102.14) 104.4,101.77 U2029.AR17
GPU_CHOKE_THERMAL: length 7.7
  TOP w0.102: TP9088.1 164.27,33.64 164.48,33.44 167.02,33.44 167.45,33.01 167.45,31.99 167.8,31.64 R325.1 168.08,31.1 168.02,31.03 U13.126
GPU_CLR_REQ4#: length 79.2
  IN2 w0.089: v2(88.2,82.31) 91.62,82.31 93.52,80.41 95.8,80.41 96.52,81.12 97.33,81.12 98.43,82.22 101.55,82.22 103.01,83.68 v2(104,83.68)
  IN3 w0.089: v1(85.67,33.77) 85.67,33.55 85.8,33.43 86.48,33.43 87.19,34.14 87.19,34.41 89.29,36.5 89.29,40.29 87.86,41.72 87.86,44.22 v1(88.07,44.44) 87.69,44.44 87.44,44.69 87.44,46.21 87.27,46.38 86.8,46.38 86.55,46.64 86.55,52.27 86.54,52.28 86.54,53.29 86.47,53.36 86.47,57.73 86.17,58.03 85.28,58.03 84.9,58.41 84.9,59.27 84.13,60.04 84.13,66.79 83.88,67.04 83.59,67.04 83.59,67.04 83.55,67.04 83.29,67.3 83.29,67.72 83.5,67.93 83.5,72 85.32,73.82 85.32,74.84 87.78,77.3 87.78,79.74 88.2,80.16 v2(88.2,82.31)
  BOTTOM w0.102: U2030.AU19 88.14,44.44 v1(88.07,44.44) ; Q2030.3 105.27,82.99 104.58,83.68 v2(104,83.68) 103.79,83.68 103.67,83.81 R6648.1 ; v1(85.67,33.77) 85.4,33.77 85.12,34.05 R2448.1
GPU_CLR_REQ6#: length 14.1
  TOP w0.102: R6647.1 88.05,30.34 v2(88.05,30.97) 88.05,32.05 88.58,32.59 88.58,33.05 88.8,33.27 88.8,39.24 89.01,39.45 89.01,40.29 88.63,40.67 88.63,42.67 v1(89.02,43.06)
  BOTTOM w0.102: U2030.AW19 88.76,43.06 v1(89.02,43.06)
GPU_EDP_HPD: length 7.3
  TOP w0.102: v2(102.42,104.25) 100.24,102.07 99.85,102.07 99.19,101.41 97.39,101.41 TP8531.1
  BOTTOM w0.127: U2029.AV21 102.8,103.87 v2(102.42,104.25)
GPU_GPIO6: length 24.8
  TOP w0.102: R12295.2 129.09,122.54 129.07,122.51 R12293.2 R12296.1 129.07,121.07 v2(129.17,120.97) 129.81,120.97 129.85,121.01 D8509.2
  IN1 w0.089: v2(114.79,110.86) 115.25,111.31 115.25,113.4 118.67,116.83 119.7,116.83 120.96,118.09 124.86,118.09 125.88,119.11 127.09,119.11 127.82,119.84 127.82,120.97 128.2,121.35 128.79,121.35 v2(129.17,120.97)
  BOTTOM w0.102: v2(114.79,110.86) 114.67,110.86 U2029.U35
GPU_PCIE_CLKREQ#: length 59.5
  TOP w0.203: R77861.2 106.21,120.26 v2(105.69,119.74)
  IN1 w0.089: v2(103.29,84.82) 103.29,85.73 102.3,86.73 102.3,89.01 98.87,92.44 98.87,94.68 97.07,96.47 97.07,110.5 96.18,111.38 96.18,113.76 98,115.58 98,117.74 99.08,118.81 99.1,118.81 99.9,119.62 103.06,119.62 103.44,120 105.42,120 v2(105.69,119.74)
  BOTTOM w0.102: U2029.AV40 102.03,113.97 101.79,114.21 101.79,114.72 101.67,114.83 101.67,115.67 101.26,116.09 101.26,117.07 101.87,117.69 102.45,117.69 102.68,117.46 104.4,117.46 105.29,118.35 105.29,119.35 v2(105.69,119.74) 105.85,119.9 R8527.2 ; Q2030.1 103.89,83.17 103.21,83.85 R6648.2 103.21,84.75 v2(103.29,84.82)
GPU_PWM_PROCHOT#: length 5
  TOP w0.102: R77867.2 128.13,122.95 127.95,123.13 127.95,123.56 127.7,123.81 126.55,123.81 126.17,123.43 PR9048.2 125.89,123.68 125.76,123.81 124.9,123.81 124.75,123.66 PR77866.2
H_PROCHOT#: length 116.1
  TOP w0.102: v2(146.62,28.94) 145.98,28.31 145.98,25.16 146.73,24.42 146.73,23.67 147.15,23.25 147.15,20.13 146.5,19.48 146.5,14.48 147.46,13.52 148.52,13.52 148.71,13.72 Q20.3
  IN1 w0.089: v2(146.62,28.94) 146.24,28.56 144.33,28.56 138.49,34.4 138.49,35.55 132.78,41.26 129.47,41.26 127.19,43.55 127.19,46.58 125.86,47.91 125.86,63.28 124.71,64.42 124.71,67.36 118.11,73.96 118.11,76.48 116.2,78.39 116.2,79.78 115.15,80.83 v2(115.15,82.03)
  IN2 w0.089: v2(93.19,79.23) 95.13,79.23 95.63,79.74 95.95,79.74 96.75,80.55 97.67,80.55 98.78,81.65 102.81,81.65 104.22,83.06 106.6,83.06 107.63,82.03 v2(115.15,82.03)
  BOTTOM w0.102: v2(93.19,79.23) 92.89,79.54 91.04,79.54 90.64,79.14 C2596.1 R2496.2
H_THRMDA1: length 166.6
  TOP w0.102: C96270.1 100.93,78.25 v1(100.93,78.24) ; v2(24.45,95.88) 24.83,95.49 v2(28.38,95.49) 28.58,95.29 42.93,95.29 44.52,96.89 49.08,96.89 50.23,98.03 51.88,98.03 52.26,97.65 v2(52.26,97.4)
  IN1 w0.089: v2(18.73,38.44) 18.22,38.95 18.22,41.39 16.55,43.06 16.55,49.76 17.25,50.47 21.31,50.47 21.78,50.94 21.78,55.99 22.6,56.82 22.6,70.15 21.21,71.55 21.21,72.46 19.3,74.36 19.3,75.36 19.05,75.61 19.05,82.71 19.81,83.47 20.04,83.47 20.45,83.87 20.45,85.17 19.34,86.28 19.34,91.14 24.07,95.88 v2(24.45,95.88)
  IN2 w0.089: v1(100.93,78.24) 100.28,78.24 98.93,76.88 97.66,76.88 97.34,77.2 92.14,77.2 91.31,76.37 89.55,76.37 86.94,78.97 86.94,79.53 83.06,83.41 83.06,84.11 79.52,87.64 72.95,87.64 67.37,93.22 67.37,94.73 66.61,95.49 65.39,95.49 62.47,98.41 60.61,98.41 59.32,99.71 54.06,99.71 52.26,97.9 v2(52.26,97.4)
  BOTTOM w0.102: Q6544.3 102.6,77.47 Q6544.2 101.14,77.47 100.93,77.68 v1(100.93,78.24) ; U5400.2 18.41,38.12 v2(18.73,38.44)
