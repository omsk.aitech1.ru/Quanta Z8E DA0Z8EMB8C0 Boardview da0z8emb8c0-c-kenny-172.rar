# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_PCIE_LANP_R: length 11.4
  BOTTOM w0.102: U2030.AM2 101.26,49.51 101.18,49.59 101.18,49.75 101.32,49.89 101.5,49.89 101.78,49.6 102.51,49.6 103.63,50.72 104.52,50.72 105.61,51.81 109.69,51.81 109.92,52.04 109.92,52.21 109.85,52.28 109.49,52.28 109.41,52.36 109.41,52.52 R2433.1
CLK_PCIE_SSDN: length 127.1
  IN3 w0.089: v1(108.98,52.27) 109.17,52.46 109.31,52.46 109.41,52.36 109.41,51.58 109.18,51.35 109.18,49.64 108.01,48.47 108.01,44.72 107.5,44.22 107.5,42.18 107.25,41.93 107.25,35.8 106.34,34.89 106.34,33.63 106.41,33.56 106.41,31.02 106.28,30.89 106.28,30.3 104.39,28.41 104.39,26.59 100.52,22.73 100.52,22.22 95.87,17.57 95.87,15.06 94.39,13.58 92.26,13.58 88.45,9.77 82.75,9.77 79.08,13.43 49.54,13.43 48.8,12.69 47.09,12.69 43.43,9.03 41.27,9.03 39.16,6.92 37.82,6.92 37.37,6.46 28.38,6.46 26.49,8.36 26.49,11.85 26.62,11.97 27.04,11.97 27.16,12.1 27.16,12.31 27.04,12.43 v2(26.92,12.43)
  BOTTOM w0.102: v2(26.92,12.43) 26.61,12.12 26.61,11.92 26.76,11.77 R848.2 ; v1(108.98,52.27) 108.79,52.46 108.52,52.46 R2420.2
CLK_PCIE_SSDN_C: length 1.9
  BOTTOM w0.102: R848.1 26.71,11.04 26.71,10.72 26.85,10.58 CN18.53
CLK_PCIE_SSDN_R: length 8.2
  BOTTOM w0.102: U2030.AL4 100.95,50.51 101.25,50.2 101.57,50.2 101.74,50.37 102.17,50.37 103.01,51.22 104.25,51.22 105.32,52.28 107.69,52.28 R2420.1
CLK_PCIE_SSDP: length 127.1
  IN3 w0.089: v2(26.29,12.43) 26.29,8.27 28.3,6.26 37.45,6.26 37.91,6.72 39.25,6.72 41.36,8.83 43.51,8.83 47.17,12.48 48.88,12.48 49.63,13.23 79,13.23 82.67,9.56 88.54,9.56 92.35,13.37 94.47,13.37 96.07,14.97 96.07,17.49 100.72,22.13 100.72,22.64 104.59,26.51 104.59,28.33 106.48,30.22 106.48,30.8 106.61,30.94 106.61,33.64 106.54,33.72 106.54,34.8 107.45,35.72 107.45,41.85 107.71,42.1 107.71,44.13 108.22,44.64 108.22,48.39 109.38,49.56 109.38,51.27 109.61,51.5 109.61,52.44 109.39,52.67 109.18,52.67 v1(108.98,52.87)
  BOTTOM w0.102: v2(26.29,12.43) 26.4,12.32 26.4,11.94 R847.2 ; v1(108.98,52.87) 108.79,52.68 108.5,52.68 R2419.2
CLK_PCIE_SSDP_C: length 1.9
  BOTTOM w0.102: CN18.55 26.35,10.58 26.49,10.72 26.49,11.05 R847.1
CLK_PCIE_SSDP_R: length 8.2
  BOTTOM w0.102: U2030.AL2 101.23,50.69 101.23,50.8 101.32,50.89 101.5,50.89 101.76,50.63 102.12,50.63 102.92,51.43 104.16,51.43 105.23,52.5 107.31,52.5 107.4,52.59 107.4,52.87 107.48,52.95 R2419.1
CLK_PCIE_VGA_N: length 66.4
  IN1 w0.089: v2(103.32,110.86) 103.08,110.62 103.08,110.12 101.87,108.9 101.87,99.1 103.31,97.65 103.31,96.58 103.81,96.07 104.16,96.07 105.49,94.74 105.49,93.99 107.07,92.41 107.07,88.59 109.85,85.81 109.85,84.14 111.01,82.98 111.01,79.01 111.67,78.35 111.67,75.83 112.03,75.47 112.03,71.63 112.55,71.1 112.55,67.71 113.35,66.92 113.35,60.53 112.82,60 111.89,60 v2(111.57,59.68)
  BOTTOM w0.102: v2(111.57,59.68) 111.47,59.78 111.16,59.78 110.93,59.55 110.93,58.79 111.51,58.21 111.51,53.22 111.64,53.09 R2402.2 ; U2029.AU33 103.6,110.57 v2(103.32,110.86)
CLK_PCIE_VGA_P: length 66.2
  IN1 w0.089: v2(111.57,60.31) 111.67,60.21 112.73,60.21 113.14,60.62 113.14,66.83 112.35,67.62 112.35,71.02 111.82,71.55 111.82,75.39 111.46,75.75 111.46,78.27 110.81,78.92 110.81,82.89 109.64,84.06 109.64,85.73 106.87,88.51 106.87,92.32 105.29,93.91 105.29,94.66 104.07,95.87 103.73,95.87 103.11,96.49 103.11,97.56 101.66,99.01 101.66,108.99 102.88,110.2 102.88,110.67 v2(102.68,110.87)
  BOTTOM w0.102: R2401.2 111.29,53.27 111.29,58.12 110.72,58.7 110.72,59.64 111.07,59.99 111.25,59.99 v2(111.57,60.31) ; v2(102.68,110.87) 102.8,110.74 U2029.AV33
CLK_PCIE_WLANN: length 114.3
  IN1 w0.089: v1(109.76,50.49) 109.59,50.67 109.41,50.67 109.28,50.54 109.28,49.53 107.45,47.7 107.45,46.51 107.12,46.18 107.12,42.91 107.45,42.59 107.45,36.24 108.55,35.14 108.55,34.61 109.1,34.06 109.1,32.85 109.66,32.29 109.66,26.17 110,25.35 113.18,22.17 119.75,22.17 119.91,22.33 122.1,22.33 122.57,22.8 124.57,22.8 124.8,22.57 130.8,22.57 131.59,23.35 147.29,23.35 148.36,24.42 148.75,24.42 149.92,25.59 152.31,25.59 153.12,24.78 156.73,24.78 157.17,25.22 167.65,25.22 168.68,24.19 169.69,24.19 170.04,23.84 172.7,23.84 173.79,22.75 176.72,22.75 177,22.47 182.13,22.47 183.54,21.07 185.23,21.07 185.56,20.73 185.56,20.41 v2(185.82,20.15)
  BOTTOM w0.102: v2(185.82,20.15) 185.57,19.9 185.57,19.64 185.22,19.28 184.24,19.28 184.08,19.13 CN9.49 ; v1(109.76,50.49) 109.57,50.68 108.52,50.68 R2418.2
CLK_PCIE_WLANN_R: length 7.5
  BOTTOM w0.089: 102.18,48.94 101.94,48.71 101.75,48.71 101.66,48.73 101.64,48.75 U2030.AM3
  BOTTOM w0.102: 102.18,48.94 103.17,48.94 103.87,49.64 104.96,49.64 105.57,50.25 107.63,50.25 R2418.1
CLK_PCIE_WLANP: length 114.2
  IN1 w0.089: v2(185.1,20.15) 185.36,20.41 185.36,20.65 185.14,20.86 183.45,20.86 182.05,22.27 176.92,22.27 176.64,22.55 173.71,22.55 172.62,23.64 169.96,23.64 169.61,23.99 168.59,23.99 167.56,25.02 157.25,25.02 156.81,24.58 153.03,24.58 152.23,25.39 150.01,25.39 148.84,24.22 148.45,24.22 147.38,23.15 131.67,23.15 130.89,22.36 124.72,22.36 124.49,22.59 122.65,22.59 122.19,22.13 119.99,22.13 119.84,21.97 113.1,21.97 109.83,25.24 109.46,26.13 109.46,32.21 108.9,32.77 108.9,33.98 108.35,34.53 108.35,35.05 107.24,36.15 107.24,42.5 106.92,42.83 106.92,46.26 107.25,46.6 107.25,47.79 109.08,49.62 109.08,50.63 109.32,50.87 109.55,50.87 v1(109.76,51.09)
  BOTTOM w0.102: R2416.2 108.5,50.9 109.57,50.9 v1(109.76,51.09) ; CN9.47 184.08,19.63 184.21,19.5 185.13,19.5 185.35,19.73 185.35,19.9 v2(185.1,20.15)
CLK_PCIE_WLANP_R: length 7.5
  BOTTOM w0.102: R2416.1 107.25,51.17 107.17,51.09 107.17,50.99 107.42,50.74 107.42,50.6 107.29,50.47 105.48,50.47 104.87,49.86 103.78,49.86 103.31,49.39 103.15,49.23 103.15,49.23 103.07,49.15 102.18,49.15 102.17,49.16 101.96,49.16 U2030.AM1
CLKA0: length 28.8
  TOP w0.102: v2(120.08,108.69) 120.32,108.94 120.32,109.11 120.56,109.35 121.77,109.35 122.01,109.59 122.01,110.81 123.24,112.04 128.73,112.04 132.36,115.67 137.89,115.67 138.7,114.86 140.27,114.86 140.47,114.65 140.47,114.49 v2(140.78,114.18) 140.5,113.9 140.5,113.78 141.16,113.12 141.85,113.12 141.95,113.22 R2238.2
  BOTTOM w0.102: v2(120.08,108.69) 120.4,109.01 U2029.E31 ; VRAM2001.J12 v2(140.78,114.18)
CLKA0B: length 29.1
  TOP w0.102: R2239.2 141.95,112.83 141.85,112.93 141.08,112.93 140.31,113.7 140.31,113.89 v2(140.02,114.18) 140.28,114.44 140.28,114.58 140.19,114.67 138.62,114.67 137.81,115.48 132.44,115.48 128.81,111.85 123.32,111.85 122.2,110.73 122.2,109.51 121.85,109.16 120.7,109.16 120.54,108.99 120.54,108.72 120.6,108.66 v2(120.81,108.66)
  BOTTOM w0.102: VRAM2001.J11 140.38,114.08 140.28,114.18 v2(140.02,114.18) ; U2029.D31 120.9,109.22 120.67,108.99 120.67,108.81 v2(120.81,108.66)
CLKA1: length 32.4
  TOP w0.102: v2(120.97,95.48) 121.07,95.58 121.07,95.8 121.17,95.9 121.93,95.9 122.43,95.41 122.43,94.65 124.44,92.63 125.03,92.63 127.07,90.59 129.41,90.59 129.92,90.08 129.92,88.68 132.21,86.39 132.21,85 134.04,83.16 138.81,83.16 140.48,84.82 140.48,85.09 v2(140.78,85.39) 140.68,85.5 140.68,85.64 140.87,85.83 141.15,85.83 141.39,85.59 141.39,85.09 141.6,84.87 141.85,84.87 141.95,84.77 R2257.2
  BOTTOM w0.102: U2029.D7 121.2,95.72 v2(120.97,95.48) ; VRAM2002.J12 v2(140.78,85.39)
CLKA1B: length 32.9
  TOP w0.102: v2(120.95,96.52) 120.97,96.52 121.07,96.42 121.07,96.19 121.17,96.09 122.01,96.09 122.62,95.49 122.62,94.73 124.52,92.82 125.11,92.82 127.15,90.78 129.49,90.78 130.11,90.16 130.11,88.76 132.4,86.47 132.4,85.08 134.12,83.35 138.73,83.35 140.29,84.9 140.29,85.09 v2(139.98,85.39) 140.33,85.74 140.43,85.74 140.73,86.05 141.2,86.05 141.58,85.67 141.58,85.16 141.68,85.06 141.85,85.06 141.95,85.16 R2254.2
  BOTTOM w0.102: VRAM2002.J11 140.38,85.52 140.25,85.39 v2(139.98,85.39) ; U2029.D9 121.2,96.62 121.1,96.52 v2(120.95,96.52)
CLR_CMOS: length 75.2
  TOP w0.102: v2(164.39,20.97) 164.4,20.96 U13.19 ; v1(106.92,28.13) 106.92,28.38 106.61,28.69 104.2,28.69 103.82,29.07 103.82,31.36 103.69,31.48 R2395.1 103.09,32.02 103.06,31.99 Q2025.2
  IN2 w0.089: v2(110.17,20.69) 111.66,22.17 119.82,22.17 121.9,24.26 123.75,24.26 124.8,23.21 143.98,23.21 146.05,21.14 149.22,21.14 149.86,20.49 151.53,20.49 151.85,20.82 161.7,20.82 161.84,20.97 v2(164.39,20.97)
  IN3 w0.089: v2(110.17,20.69) 106.92,23.94 v1(106.92,28.13)
CLR_REQ5#: length 15.1
  TOP w0.102: R2449.1 87.31,30.41 87.31,32.36 87.77,32.82 87.77,33.31 88.07,33.6 88.07,34.6 87.84,34.82 87.84,42.34 87.9,42.39 87.9,42.98 88.56,43.64 v1(89.07,43.64)
  BOTTOM w0.102: U2030.AW18 89.18,43.64 v1(89.07,43.64)
CODEC_VREF: length 2.4
  BOTTOM w0.203: U30.28 206.97,27.66 207.29,27.98 208.03,27.98 C616.2
CORE_PWM_PROCHOT#: length 123
  TOP w0.102: v2(139.1,31.61) 139.1,30.46 139.03,30.39 PR9292.1 ; v2(150.09,43.42) 149.92,43.59 149.92,45.07 150.43,45.58 150.43,48.75 150.18,49.01 PR6051.2
  IN2 w0.089: v2(91.25,79.11) 91.65,79.51 92.8,79.51 92.92,79.63 95.26,79.63 95.62,80 95.93,80 96.67,80.74 97.59,80.74 98.7,81.84 102.73,81.84 104.14,83.25 106.67,83.25 107.71,82.22 112.09,82.22 v2(112.74,82.87) ; v2(150.09,43.42) 144.07,37.4 140.99,37.4 138.62,35.03 138.62,34.28 138.07,33.72 138.07,33.17 138.36,32.88 138.61,32.88 139.1,32.39 v2(139.1,31.61)
  IN3 w0.089: v2(112.74,82.87) 113.13,82.48 113.13,76.22 113.75,75.6 114.91,75.6 119.02,71.49 139.94,71.49 140.43,71 140.43,63.08 142.13,61.38 145.4,61.38 146.4,60.38 146.4,58.63 147.61,57.41 147.61,56.59 149.35,54.85 149.35,52.26 150.5,51.11 150.5,48.37 148.52,46.39 148.52,45.33 149.92,43.93 149.92,43.59 v2(150.09,43.42)
  BOTTOM w0.102: R2508.2 v2(91.25,79.11)
CPU_VDD0_RUN_FB_H: length 54.6
  TOP w0.127: v1(89.07,67.21) 89.47,67.61 89.47,68.69 89.6,68.82 TP2045.1 89.58,69.22 89.58,72.36 90.36,73.14 90.36,73.8 90.97,74.41 91.12,74.41 93.03,76.31 93.03,76.5 94.24,77.71 94.54,77.71 95.07,78.24 95.07,79.24 95.35,79.53 95.7,79.53 95.87,79.36 98.72,79.36 98.78,79.3 99.75,79.3 100.04,79.01 100.04,78.02 100.14,77.92 100.14,77.91 100.95,77.1 101.88,77.1 104.25,74.73 104.65,74.73 105.83,73.54 v2(106.18,73.54)
  BOTTOM w0.127: v2(106.18,73.54) 106.74,72.99 109.94,72.99 111.06,71.87 112.11,71.87 112.81,71.17 112.81,63.12 113.51,62.42 113.51,59.85 113.14,59.48 113.14,54.77 PR6000.1 ; v1(89.07,67.21) 89.12,67.21 U2030.K18
CPU_VDD0_RUN_FB_L: length 53.7
  TOP w0.127: v1(89.04,68.79) 89.04,69.28 89.22,69.46 89.22,69.46 89.22,72.51 90,73.29 90,73.95 90.82,74.76 90.97,74.76 92.67,76.46 92.67,76.64 94.12,78.09 94.42,78.09 94.7,78.37 94.7,79.38 95.21,79.88 95.85,79.88 96.01,79.72 98.86,79.72 98.92,79.66 99.9,79.66 100.39,79.16 100.39,78.17 101.1,77.46 102.02,77.46 104.4,75.08 104.79,75.08 105.85,74.03 106.34,74.03 106.63,73.73 106.63,73.3 v2(106.21,72.88)
  BOTTOM w0.127: PR6061.1 112.79,55.02 112.79,59.63 113.16,59.99 113.16,62.27 112.46,62.97 112.46,71.02 111.99,71.49 110.93,71.49 109.79,72.63 106.46,72.63 v2(106.21,72.88) ; U2030.J18 89.13,68.79 v1(89.04,68.79)
CPU_VDDNB_RUN_FB_H: length 54.8
  TOP w0.127: v1(89.04,68.03) 88.74,68.03 TP2044.1 88.45,69.2 88.87,69.62 88.87,73.31 90.67,75.12 90.83,75.12 92.31,76.61 92.31,76.86 93.61,78.16 93.61,78.81 95.04,80.24 96,80.24 96.16,80.07 99.01,80.07 99.07,80.01 100.38,80.01 101.15,79.23 101.79,79.23 102.3,78.73 102.3,77.69 104.55,75.44 104.95,75.44 106.01,74.38 106.51,74.38 106.95,73.95 v2(107.38,73.95)
  BOTTOM w0.127: v1(89.04,68.03) 88.68,68.03 88.51,68.2 U2030.J19 ; PR6030.1 123,80.38 122.11,79.49 119.16,79.49 118.81,79.14 118.81,73.39 118.1,72.68 110.76,72.68 110.04,73.39 107.94,73.39 v2(107.38,73.95)
CPU_VDDNB_RUN_FB_L: length 0.8
  BOTTOM w0.102: PR6032.1 TP9093.1
CPU_VDDP_RUN_FB_H: length 0.9
  BOTTOM w0.127: TP2056.1 149.13,40.47 PR9298.2
CPU_VDDP_RUN_FB_L: length 1.2
  TOP w0.127: TP2050.1 118.48,50.86 118.98,50.86 119.09,50.76 PR2015.2
CSA0B_0: length 28.1
  TOP w0.127: v2(118.86,109.82) 119.26,110.22 119.98,110.22 120.2,110.45 120.94,110.45 121.35,110.86 121.35,111.07 123.47,113.19 127.39,113.19 128.62,114.43 129.72,114.43 132.37,117.08 137.86,117.08 138.11,116.83 138.11,116.57 139.2,115.48 141.11,115.48 v2(141.58,115.01)
  BOTTOM w0.102: U2029.H31 118.8,109.76 v2(118.86,109.82)
  BOTTOM w0.127: VRAM2001.G12 141.58,114.98 v2(141.58,115.01)
CSA1B_0: length 32.1
  TOP w0.102: 120.88,94.68 120.27,95.29 v2(120.27,95.48)
  TOP w0.127: v2(141.39,81.77) 134.38,81.77 131.38,84.77 131.38,86.09 128.46,89.01 125.99,89.01 123.13,91.87 123.13,92.24 120.99,94.39 120.99,94.56 120.88,94.68
  BOTTOM w0.102: v2(120.27,95.48) 120.4,95.62 U2029.E7
  BOTTOM w0.127: v2(141.39,81.77) 141.54,81.92 141.54,84.56 VRAM2002.L12
CTL2: length 1.5
  TOP w0.102: U7.7 23.2,48.88 R225.1
CTL3: length 2.7
  TOP w0.102: U7.8 22.53,49.38 22.79,49.64 22.79,49.9 22.95,50.05 R222.1 v2(23.2,50.88)
DBGDATA_0: length 7.6
  BOTTOM w0.102: U2029.L40 117.5,114.57 117.18,114.9 117.18,116.37 119.27,118.45 120.05,118.45 120.2,118.6 R2638.2 R2615.2
DBGDATA_1: length 10
  BOTTOM w0.102: U2029.L41 117.5,116.36 119.36,118.22 122.24,118.22 v2(123.12,119.11) 123.38,119.37 R2616.2 R2639.2
DBGDATA_2: length 9.3
  BOTTOM w0.102: U2029.M40 116.95,114.23 116.65,114.54 116.65,114.82 116.72,114.9 116.72,116.56 118.78,118.61 118.78,120 119.09,120.31 R2636.2 R2613.2 119.09,121.68 v2(119.44,122.03)
DBGDATA_3: length 6
  BOTTOM w0.102: R2614.2 R2637.2 119.09,118.6 116.95,116.46 U2029.M41
DBGDATA_4: length 6.5
  BOTTOM w0.102: R2611.2 R2634.2 118.27,118.75 116.08,116.56 116.08,114.9 116.4,114.58 U2029.N40
DBGDATA_5: length 7.3
  BOTTOM w0.102: R2612.2 R2635.2 118.27,120.31 118.55,120.03 118.55,118.71 116.4,116.56 U2029.N41
DBGDATA_6: length 8.6
  BOTTOM w0.102: U2029.P40 115.85,114.24 115.53,114.57 115.53,114.79 115.61,114.87 115.61,117.94 116.01,118.35 116.01,120.14 116.3,120.42 R2632.2 R2609.2 116.3,121.93 v2(116.39,122.03)
DBGDATA_7: length 5.3
  BOTTOM w0.102: U2029.P41 115.85,117.81 116.3,118.25 R2633.2 R2610.2
DBRDY1: length 5.5
  BOTTOM w0.102: R575.2 120.72,46.16 119.72,45.17 119.72,44.27 119.52,44.06 119.52,42.99 119.31,42.79 117.92,42.79
DBRDY2: length 4.9
  BOTTOM w0.102: CN2021.13 119.19,44.06 119.5,44.36 119.5,45.27 120.38,46.15 120.38,46.65 120.72,46.98 R12317.2
DBRDY3: length 4.4
  BOTTOM w0.102: CN2021.11 119.23,45.33 120.15,46.25 120.15,46.81 120.38,47.03 120.38,47.41 120.61,47.64 R560.2
DC-DET: length 3.6
  TOP w0.102: v2(198.56,25.03) 198.46,25.13 R375.2 R752.1
  BOTTOM w0.102: v2(198.56,25.03) 198.94,25.03 199.56,25.66 U30.4
DCIN_EN: length 1.6
  TOP w0.102: R2710.1 22.51,77.68 v2(22.52,77.67)
  BOTTOM w0.102: U26.8 v2(22.52,77.67)
DDBIA0_0: length 31.7
  IN3 w0.114: v2(144.78,107.78) 143.76,107.78 141.75,109.79 138.75,109.79 137.47,111.07 132.36,111.07 130.49,112.94 130.49,113.39 129.77,114.11 127.49,114.11 127.23,114.37 122.23,114.37 121.84,113.98 120.15,113.98 119.57,113.4 119.57,113.02 v2(119.05,112.5)
  BOTTOM w0.102: v2(119.05,112.5) 119.03,112.5 U2029.J38
  BOTTOM w0.127: VRAM2001.D2 144.78,106.98 v2(144.78,107.78)
DDBIA0_1: length 29.2
  IN3 w0.114: v2(120.63,116.87) 121.17,116.87 121.37,116.67 122.46,116.67 123.47,117.68 129.04,117.68 129.52,117.21 130.78,117.21 132.19,115.8 134.99,115.8 135.4,115.39 137.78,115.39 138.25,114.92 139.76,114.92 140.09,114.59 141.97,114.59 142.06,114.67 142.68,114.67 142.94,114.41 143.41,114.41 v2(143.98,114.98)
  BOTTOM w0.102: v2(120.63,116.87) 120.64,116.86 120.64,116.07 120.48,115.91 120.48,114.88 120.58,114.78 120.58,114.56 120.25,114.23 U2029.F40
  BOTTOM w0.127: VRAM2001.D13 v2(143.98,114.98)
DDBIA0_2: length 16.4
  IN1 w0.114: v2(127.04,115.63) 128.46,117.06 134.69,117.06 134.95,116.8 134.96,116.8 135.13,116.63 v2(135.23,116.63)
  BOTTOM w0.102: U2029.A38 123.49,113.07 123.69,113.27 124.19,113.27 124.45,113.52 124.94,113.52 125.18,113.76 125.18,114.26 125.64,114.72 126.12,114.72 v2(127.04,115.63)
  BOTTOM w0.127: VRAM2001.P13 135.95,115.81 135.47,115.81 135.23,116.04 v2(135.23,116.63)
DDBIA0_3: length 17.2
  IN1 w0.114: v2(136,106.18) 135.64,105.82 135.64,105.76 135.17,105.28 134.98,105.28 134.82,105.12 134.72,105.03 134.72,104.93 134.35,104.56 132.7,104.56 131.82,105.44 131.82,105.97 130.64,107.15 125.73,107.15 v2(125.04,107.83)
  BOTTOM w0.102: v2(125.04,107.83) 124.36,108.51 123.27,108.51 123.12,108.37 122.79,108.37 122.49,108.67 U2029.B30
  BOTTOM w0.127: VRAM2001.P2 136,106.21 v2(136,106.18)
DDBIA1_0: length 23.2
  IN3 w0.114: v2(135.95,93.41) 135.3,94.06 134.96,94.06 134.72,94.3 134.72,94.65 135.57,95.5 135.57,99.26 130.6,104.23 126.88,104.23 126.52,104.6 125.21,104.6 124.75,105.07 v2(124.7,105.07)
  BOTTOM w0.102: U2029.B25 122.85,105.92 123.18,105.6 123.86,105.6 124.39,105.07 v2(124.7,105.07)
  BOTTOM w0.127: VRAM2002.D2 136.37,92.99 v2(135.95,93.41)
DDBIA1_1: length 30.7
  IN3 w0.114: v2(135.99,83.81) 135.36,83.17 132.49,83.17 126.48,89.18 126.48,91.6 125.13,92.95 124.62,92.95 122.78,94.79 122.78,99.62 123.96,100.79 124.35,100.79 v2(124.78,101.22)
  BOTTOM w0.102: v2(124.78,101.22) 124.38,101.61 123.66,101.61 123.43,101.84 123.18,101.84 123.07,101.74 122.85,101.74 122.51,102.07 U2029.B18
  BOTTOM w0.127: VRAM2002.D13 v2(135.99,83.81)
DDBIA1_2: length 24.5
  IN1 w0.114: v2(143.96,92.57) 142.64,93.89 142.24,93.89 141.33,94.8 138.63,94.8 136.92,96.51 128.49,96.51 v2(127.55,97.45)
  BOTTOM w0.102: v2(127.55,97.45) 127.15,97.05 125.95,97.05 124.63,98.36 123.93,98.36 123.52,98.77 U2029.A12
  BOTTOM w0.127: VRAM2002.P2 v2(143.96,92.57)
DDBIA1_3: length 28.1
  IN1 w0.114: v2(125.54,91.48) 126.45,90.57 131.22,90.57 132.94,88.85 133.58,88.85 134.17,88.25 134.98,88.25 135.95,87.28 135.95,86.98 136.67,86.26 137.56,86.26 137.98,85.84 137.98,85.25 138.26,84.98 141.53,84.98 141.82,84.7 142.52,84.7 143.02,84.2 143.58,84.2 v2(143.98,83.79)
  BOTTOM w0.102: U2029.B5 122.7,94.83 122.95,94.83 123.2,94.58 123.57,94.58 123.8,94.35 124.45,94.35 125.23,93.56 125.23,91.78 v2(125.54,91.48)
  BOTTOM w0.127: VRAM2002.P13 v2(143.98,83.79)
DDR4_SUSON_2V5: length 187.9
  TOP w0.102: v2(169.66,28.35) 169.62,28.39 U13.122
  IN1 w0.089: v2(89.98,95.24) 88.98,96.23 76.39,96.23 68.83,103.79 68.83,105.7 67.77,106.76 67.77,117.04 69.16,118.43 70.56,118.43 70.97,118.85 70.97,121.28 70.46,121.79 70.46,124.44 70.01,124.89 68.04,124.89 v2(67.38,125.55)
  IN3 w0.089: v2(89.98,95.24) 92.06,95.24 93.12,94.18 94.66,94.18 95.93,92.91 97.98,92.91 99.6,91.28 99.6,85.92 100.04,85.48 101.24,84.28 101.24,82.58 102.15,81.67 102.75,81.67 103.15,81.27 104.21,81.27 105.75,79.74 105.75,78.21 108.16,75.79 108.16,74.28 108.95,73.49 110.48,73.49 111.58,72.39 112.52,72.39 113.44,71.47 113.44,70.52 114.4,69.56 114.4,69.14 116.06,67.48 116.06,63.08 116.18,62.95 116.18,60.17 114.58,58.57 114.27,57.82 114.27,54.41 115.74,52.95 115.74,51.29 118.11,48.93 118.11,44.13 120.52,41.72 120.52,39.74 123.64,36.63 124.36,36.63 124.98,36.01 124.98,35.53 125.21,35.3 129.09,35.3 130.82,37.03 135.64,37.03 136.16,37.55 144.01,37.55 144.45,37.11 144.45,33.48 148.49,29.44 158.44,29.44 158.8,29.08 162.82,29.08 164.14,27.76 167.62,27.76 167.76,27.62 168.38,27.62 169.11,28.35 v2(169.66,28.35)
  BOTTOM w0.203: PR124.2 67.11,125.28 v2(67.38,125.55)
DE1: length 4.1
  TOP w0.102: U17.9 207.71,15.87 207.08,15.24 206.08,15.24 205.96,15.37 R466.2 205.8,15.61 205.67,15.73 205.17,15.73 205.04,15.61 R465.1
DE2: length 3.9
  TOP w0.102: U17.8 207.83,16.37 207.58,16.12 206.08,16.12 205.96,16.24 R460.2 R461.1
DEBUG_CLK: length 3.1
  BOTTOM w0.102: CN9.60 191.59,16.38 191.8,16.59 192.55,16.59 192.85,16.29 192.85,16.06 R706.2
DEBUG_IRQ: length 1.9
  BOTTOM w0.102: R712.2 191.91,15.65 191.69,15.88 CN9.62
DEVSLP0: length 143.3
  IN2 w0.089: v1(97.42,47.47) 98.08,47.47 98.57,46.98 106.87,46.98 110.68,50.79 110.68,50.91 111.95,52.18 117.92,52.18 118.39,52.66 120.33,52.66 120.4,52.73 v1(121.73,52.73)
  IN3 w0.089: v1(121.73,52.73) 121.73,51.15 121.07,50.49 121.07,49.57 121.76,48.88 124.29,46.35 131.12,46.35 131.42,46.05 142.79,46.05 144.69,44.14 145.64,44.14 146.62,43.17 146.62,41.13 147.83,39.93 148.54,39.93 150.05,38.42 150.05,36.84 149.48,36.28 149.48,35.04 151.37,33.15 152.38,33.15 152.47,33.23 158.24,33.23 158.75,33.75 167.63,33.75 169.62,31.75 170.39,31.75 172.05,30.09 173.47,30.09 174.09,29.47 178.17,29.47 179.35,28.3 183.15,28.3 183.27,28.18 186.42,28.18 186.94,27.67 191.83,27.67 192.03,27.47 194.26,27.47 194.52,27.2 194.52,21.78 197.77,18.53 202.57,18.53 202.98,18.12 205.57,18.12 v2(206.51,19.06)
  BOTTOM w0.102: R570.2 207.49,16.83 207.3,16.83 206.34,17.79 206.34,18.88 v2(206.51,19.06) 206.51,19.85 206.95,20.29 Q5403.3 ; U2030.AP9 96.96,47.01 v1(97.42,47.47)
DEVSLP0_R: length 1.8
  BOTTOM w0.102: R837.2 213.01,14.18 213.15,14.32 HD1.5
DEVSLP_HDD_C: length 10.4
  BOTTOM w0.102: R6645.1 211.34,14.21 211.74,14.61 R573.2 ; R6645.1 210.89,14.71 210.63,14.97 209.23,14.97 208.6,15.6 R570.1 208.6,16.89 v2(208.16,17.33) 207.55,17.94 207.23,17.94 Q5403.1 ; R6645.1 210.89,13.86 211.02,13.73 R837.1
DEW1: length 12.5
  TOP w0.102: U17.16 212.63,15.37 213.01,15 v2(213.14,15) 213.14,14.49 v2(213.29,14.34) ; R485.2 205.96,12.59 205.7,12.33 v2(205.42,12.33) 205.14,12.33 204.88,12.59 R481.1
  IN2 w0.089: v2(213.14,15) 213.14,14.86 212.36,14.08 209.17,14.08 207.41,12.33 v2(205.42,12.33)
DEW2: length 4.8
  TOP w0.102: v2(204.88,19.13) R435.1 R436.2 205.96,18.02 206.08,17.89 207.53,17.89 208.05,17.37 U17.6
DGPU_DP_HPD: length 10.9
  BOTTOM w0.102: TP9081.1 96.2,100.82 98.07,100.82 99.49,102.24 99.49,104.49 100.57,105.57 100.8,105.57 100.92,105.7 101.18,105.7 101.28,105.6 101.51,105.6 101.6,105.69 101.88,105.69 101.97,105.6 102.48,105.6 U2029.AV25
DGPU_HIN_RST#: length 5.9
  BOTTOM w0.102: U8001.2 84.26,86.22 v2(84.01,85.97) 83.5,85.97 83.3,86.17 83.3,88.58 82.97,88.91 R8134.1 R8133.1
DGPU_OPP#: length 4.8
  TOP w0.102: v2(178.62,18.71) 178.91,18.71 179.19,18.43 180,18.43 180.26,18.16 U13.71
  BOTTOM w0.102: v2(178.62,18.71) 178.39,18.95 178.39,19.88 178.19,20.08 R77852.2
DGPU_OVT#_EC: length 3
  TOP w0.102: v2(166.74,20.29) 166.47,20.56 U13.20
  BOTTOM w0.102: R791.1 167.57,21.07 TP9095.1 166.79,20.29 v2(166.74,20.29)
DGPU_PW_CTRL#: length 7.3
  TOP w0.102: v1(98.99,42.66) 99.38,42.28 100.9,42.28 102.6,40.58 102.6,40.25 102.73,40.12 103.19,40.12 103.41,40.34 R77832.2 R77833.1
  BOTTOM w0.102: v1(98.99,42.66) 98.99,42.83 U2030.AW7
DGPU_PWREN: length 69
  IN2 w0.089: v2(88.58,76.11) 89.08,75.61 89.08,75.4 89.89,74.58 90.73,74.58 91.81,75.67 95.81,75.67 96.49,76.35 96.88,76.35 96.92,76.31 98.63,76.31 100.15,77.84 101.15,77.84 102.83,79.51 v2(104.46,79.51)
  IN3 w0.089: v1(89.09,45.15) 89.6,45.66 89.6,47.72 88.46,48.85 88.46,57.63 88.51,57.68 88.51,58.73 88.22,59.02 87.26,59.02 86.95,59.32 86.95,59.86 86.48,60.33 86.48,65.55 85.77,66.26 85.77,66.98 85.65,67.1 85.65,71.98 87.44,73.77 87.44,74.79 88.58,75.93 v2(88.58,76.11)
  BOTTOM w0.102: U2030.AT18 89.51,45.57 v1(89.09,45.15) ; PR9136.1 115.51,77.08 115.26,77.32 PR9133.2 114.42,77.32 114.26,77.48 PR9134.1 113.83,77.28 113.45,76.9 112.54,76.9 112.4,76.76 110.99,76.76 110.68,77.08 110.68,77.58 109.81,78.46 107.52,78.46 107,78.98 104.84,78.98 104.46,79.36 v2(104.46,79.51) 104.46,79.62 103.95,80.12 R2431.1
DGPU_PWREN_R: length 92.7
  IN3 w0.089: v2(115.44,79.11) 114.23,80.31 114.23,88.11 114.34,88.21 114.34,88.65 v2(113.85,89.14) 113.85,89.14 110.16,92.83 107.4,92.83 106.12,94.11 106.12,94.5 105.71,94.91 105.71,96.06 106,96.34 106,98.2 104.95,99.24 102.06,99.24 100.91,100.4 100.91,101.4 99.13,103.18 99.13,110.64 98.87,110.91 98.87,114.02 96.05,116.83 93.88,116.83 92.47,118.24 92.47,122.34 91.72,123.09 88.75,123.09 v2(88.71,123.05)
  BOTTOM w0.102: v2(115.44,79.11) 115.01,78.68 114.18,78.68 113.83,78.32 PR9134.2 113.45,77.94 113.29,78.1 PC9094.2 111.83,78.1 111.5,77.77 PQ9006.2 ; PR77846.1 121.09,87.62 119.57,89.14 v2(113.85,89.14) ; v2(88.71,123.05) 88.53,123.23 87.87,123.23 87.77,123.13 77.85,123.13 76.94,124.04 73.93,124.04 73.52,123.64 72.63,123.64 72.44,123.82 PR77835.1
DGPU_PWROK: length 59.8
  TOP w0.102: v1(121.75,48.25) 118.69,48.25 118.41,48.53 R2439.1 R2452.2
  IN2 w0.089: v2(147.51,63.19) 148.95,63.19 150.29,61.85 150.29,60.92 150.76,59.77 151.05,58.83 151.05,55.74 152.39,54.4 152.39,50.07 151.56,49.25 151.56,46.71 149.86,45.01 145.81,45.01 144.41,46.4 133.24,46.4 131.4,48.25 v1(121.75,48.25)
  BOTTOM w0.152: PR9119.1 148.07,62.63 v2(147.51,63.19)
  BOTTOM w0.203: PR9119.1 148.35,62.39 148.41,62.33 PR9122.2
DGPUT_CLK: length 10
  IN3 w0.089: v2(109.66,125.46) 109.66,121.46 v2(109.22,121.02)
  BOTTOM w0.102: Q2038.1 108.41,124.64 108.24,124.82 R8128.2 108.44,125.59 108.75,125.89 109.41,125.89 109.66,125.64 v2(109.66,125.46) ; v2(109.22,121.02) R2644.2 108.72,121.75 109.31,122.34 R2630.1
DGPUT_CLK_R: length 11.9
  TOP w0.102: v2(102.04,117.28) 104.45,117.28 105.31,118.15 106.92,118.15 v2(107.1,118.32)
  BOTTOM w0.102: v2(107.1,118.32) 107.88,119.11 107.88,119.87 108.01,120 108.01,120.52 108.27,120.78 R2644.1 ; U2029.AW40 102.1,114.55 102.42,114.87 102.42,115.18 102.21,115.39 102.21,117.12 v2(102.04,117.28)
DGPUT_DATA: length 3.4
  BOTTOM w0.102: R2643.2 107.73,121.29 R2629.1 108.06,121.83 108.29,122.06 R8118.2 108.29,122.51 108.01,122.8 108.01,123.18 107.85,123.34 Q2038.4
DGPUT_DATA_R: length 11
  TOP w0.102: v2(101.66,116.7) 101.53,116.83 101.53,117.39 101.86,117.72 102.35,117.72 102.55,117.51 104.35,117.51 105.22,118.38 106.09,118.38 106.67,118.96 v2(107.16,118.96)
  BOTTOM w0.102: v2(107.16,118.96) 107.16,119.3 v2(107.44,119.58) 107.63,119.77 R2643.1 ; v2(101.66,116.7) 101.93,116.43 101.93,115.15 U2029.AW41
DIECRACKMON: length 6.5
  BOTTOM w0.102: R8485.2 123.92,88.38 123.79,88.25 TP8067.1 123,88.89 123.25,89.14 123.25,91.82 123.15,91.92 123.15,92.58 U2029.B2
DISP_ON: length 5
  BOTTOM w0.102: U23.4 67.43,89.46 67.63,89.27 68.01,89.27 68.13,89.39 68.13,90.41 68.51,90.79 R535.2 68.9,90.95 69.02,91.07 69.02,91.84 68.9,91.96 R536.1
DMIC-DATA34: length 1.9
  TOP w0.102: TP36.1 200.85,24.24 200.5,23.89 R338.1
DMIC_CLK: length 4.4
  BOTTOM w0.102: U30.3 199.45,25.26 198.82,24.62 198.02,24.62 197.39,23.99 196.83,23.99 R749.2
DMIC_CLK_2: length 134
  IN3 w0.089: v2(42.29,113.01) 42.63,112.68 42.63,111.59 43.52,110.7 43.52,106.76 42.52,105.77 42.52,104.34 42,103.81 42,103.24 39.88,101.12 39.88,98.97 41.64,97.2 46.1,97.2 46.7,97.8 50.51,97.8 51.51,96.8 52.74,96.8 53.95,95.59 58.3,95.59 60.02,97.31 63.19,97.31 66.37,94.14 66.8,94.14 68.94,92.01 70.24,92.01 71.2,92.97 73.14,92.97 73.91,92.2 78.29,92.2 79.13,91.36 81.61,91.36 83.13,89.84 85.5,89.84 86.85,88.49 91.68,88.49 93.21,86.95 93.21,81.98 92.99,81.77 92.99,80.64 93.6,80.04 93.6,77.9 93.12,77.43 93.12,70.34 92.47,69.68 92.47,64.71 92.41,64.65 92.41,64.1 92.14,63.82 91.07,63.82 90.89,63.64 90.89,54.47 91.15,54.22 91.5,54.22 91.74,53.98 91.74,53.65 91.96,53.43 92.28,53.43 92.56,53.15 92.56,52.83 93.28,52.11 93.28,51.36 93.73,50.91 97.37,50.91 98.29,49.99 98.29,48.97 98.57,48.69 98.57,46.9 98.74,46.72 98.74,46.32 100.04,45.02 v1(100.52,45.02)
  BOTTOM w0.102: v1(100.52,45.02) 100.57,45.02 101.06,45.51 U2030.AT2 ; R77874.2 40.84,116.32 42.11,115.05 42.11,113.19 v2(42.29,113.01)
DMIC_CLK_2_R: length 5.9
  BOTTOM w0.102: v2(35.5,114.67) CN1.3 35.5,116.45 35.82,116.77 38.6,116.77 39.05,116.32 R77874.1
DMIC_CLK_L: length 226.8
  IN3 w0.089: v2(194.12,27.04) 193.35,26.27 189.44,26.27 188.91,26.8 186.58,26.8 186.06,27.32 179,27.32 178.8,27.11 177.66,27.11 176.72,28.05 174.29,28.05 173.11,29.23 171.69,29.23 170.26,30.66 167.86,30.66 166.33,32.18 153.21,32.18 153.1,32.07 151.23,32.07 148.52,34.77 148.52,38.72 148.18,39.06 130.53,39.06 129.6,39.99 129.6,43.55 127.7,45.45 121.49,45.45 120.2,46.74 120.2,52.91 120.66,53.36 120.66,58.53 121.65,59.52 121.65,63.32 119.2,65.77 119.2,68 118.33,68.87 118.33,70.15 114.98,73.5 113.43,73.5 112.35,74.57 112.35,74.57 110.94,75.98 110.94,78.58 109.94,79.58 109.94,80.99 108.69,82.24 108.69,83.79 106.89,85.59 103.45,85.59 103.04,85.18 102.08,85.18 100.87,86.4 100.87,92.55 99.78,93.64 99.78,94.15 98.7,95.23 96.75,95.23 96.07,95.9 94.39,95.9 93.61,96.68 92.39,96.68 91.54,97.53 85.3,97.53 83.08,99.75 83.08,103.41 81.97,104.52 78.01,104.52 77.82,104.33 76.58,104.33 74.11,106.8 69.17,106.8 66.51,109.46 63.35,109.46 61.68,111.14 57.24,111.14 56.93,110.82 56.93,109.87 55.49,108.43 51.47,108.43 47.95,104.91 46.65,104.91 43.55,101.81 42,101.81 v2(41.97,101.84)
  BOTTOM w0.102: R749.1 195.92,23.86 196.15,24.09 C663.2 195.72,24.36 195.51,24.56 195.51,25.82 194.3,27.04 v2(194.12,27.04) ; L11.2 41.08,102.73 v2(41.97,101.84)
DMIC_CLK_L_C: length 5.1
  BOTTOM w0.102: CN2.1 43.72,106.64 43.62,106.54 42.73,106.54 42.33,106.13 42.33,105.39 C528.1 41.46,104.88 41.08,104.51 L11.1
DMIC_DAT: length 5.6
  BOTTOM w0.102: U30.2 199.43,24.86 198.99,24.42 198.39,24.42 197.45,23.48 v2(197.29,23.48) 197.04,23.48 196.68,23.13 195.79,23.13 195.53,23.38 R745.1
DMIC_DAT_2: length 134.8
  IN3 w0.089: v2(42.57,113.83) 42.78,114.04 45.65,114.04 46.04,113.65 46.04,112.89 46.67,112.25 46.67,111.37 43.71,108.4 43.71,106.68 42.71,105.69 42.71,104.26 42.19,103.73 42.19,103.16 40.07,101.04 40.07,99.05 41.72,97.4 46.02,97.4 46.62,97.99 50.62,97.99 51.62,96.99 52.82,96.99 53.8,96.01 55.07,96.01 55.81,96.76 59.2,96.76 59.94,97.5 63.27,97.5 66.44,94.33 66.88,94.33 69.01,92.2 70.16,92.2 71.12,93.16 73.22,93.16 73.99,92.39 80.85,92.39 82.57,90.66 84.94,90.66 86.93,88.68 91.76,88.68 93.4,87.03 93.4,81.9 93.18,81.69 93.18,80.72 93.79,80.12 93.79,77.71 93.32,77.24 93.32,70.05 93.53,69.84 93.53,67.93 92.71,67.11 92.71,64.57 92.61,64.46 92.61,63.53 92.54,63.47 92.54,58.76 93.33,57.97 93.33,52.41 94.6,51.13 97.42,51.13 98.48,50.07 98.48,49.05 99.32,48.21 99.32,46.27 v1(100.08,45.51)
  BOTTOM w0.102: R77875.2 40.28,117.21 v2(40.68,116.8) 42.57,114.92 v2(42.57,113.83) ; U2030.AT4 v1(100.08,45.51)
DMIC_DAT_2_R: length 6.2
  BOTTOM w0.102: v2(39.33,118.1) R77875.1 39.05,117.21 38.85,117 35.73,117 35.55,116.83 34.99,116.83 34.7,116.54 CN1.2
DMIC_DAT_L: length 223
  IN3 w0.089: v2(42.71,103.49) 44.07,103.49 45.58,105 45.89,105 47.92,107.03 49.51,107.03 51.31,108.83 55.33,108.83 56.53,110.02 56.53,110.97 57.08,111.53 61.84,111.53 63.5,109.87 66.66,109.87 69.34,107.19 74.27,107.19 76.74,104.72 77.65,104.72 77.85,104.92 82.13,104.92 83.48,103.58 83.48,99.91 84.82,98.56 87.29,98.56 87.5,98.35 91.27,98.35 92.55,97.07 93.86,97.07 94.63,96.3 96.24,96.3 96.91,95.62 98.86,95.62 99.99,94.49 100.35,94.49 100.59,94.26 100.59,93.39 101.34,92.63 101.34,87.01 102.38,85.98 107.05,85.98 109.09,83.95 109.09,82.4 110.34,81.15 110.34,79.74 111.33,78.75 111.33,76.15 112.51,74.97 112.52,74.97 113.59,73.89 115.14,73.89 118.72,70.31 118.72,69.03 119.59,68.16 119.59,65.93 122.04,63.48 122.04,59.36 121.05,58.37 121.05,53.2 120.6,52.74 120.6,46.91 121.66,45.85 127.86,45.85 130,43.71 130,40.15 130.69,39.46 148.35,39.46 148.92,38.88 148.92,34.94 151.39,32.46 152.94,32.46 153.05,32.57 158.24,32.57 158.95,33.28 163.27,33.28 163.97,32.57 166.5,32.57 168.02,31.05 170.43,31.05 171.85,29.62 173.28,29.62 173.9,29 177.98,29 179.27,27.71 186.22,27.71 186.74,27.2 189.08,27.2 189.61,26.67 193.1,26.67 v2(193.48,27.04)
  BOTTOM w0.102: v2(42.71,103.49) 42.32,103.1 L12.2 ; R745.2 195.26,24.24 195.01,24.5 v2(195.01,25.13) 195.01,25.76 194.24,26.53 193.99,26.53 v2(193.48,27.04)
DMIC_DAT_L_C: length 5.2
  BOTTOM w0.102: L12.1 42.41,103.88 42.99,104.46 C529.1 42.56,105.31 42.56,105.98 42.86,106.29 43.69,106.29 43.94,106.53 44.1,106.53 44.22,106.66 CN2.2
DNBSWON#: length 117.1
  TOP w0.102: v2(170.45,24.52) 170.45,26.07 169.76,26.75 169.76,27.63 169.22,28.18 U13.123
  IN2 w0.089: v2(170.45,24.52) 170.07,24.15 168.36,24.15 167.36,25.14 166.48,25.14 165.84,24.5 161.54,24.5 161.03,23.99 155.94,23.99 154.7,25.23 154.42,25.23 153.21,26.44 140.34,26.44 139.78,25.87 131.89,25.87 131.42,26.35 120.69,26.35 120.39,26.65 115.61,26.65 115.19,26.23 110.4,26.23 109.81,25.64 97.91,25.64 96.26,24 91.89,24 90.9,24.98 87.89,24.98 v2(87.64,25.23) ; v1(91.91,45.25) 91.58,45.58 90.78,45.58 90.48,45.27 90.48,40.74 90.2,40.47 90.2,35.6 88.18,33.58 v1(88.18,33.14)
  BOTTOM w0.102: v1(91.91,45.25) 91.91,46.01 U2030.AR15 ; v1(88.18,33.14) 87.79,32.75 R2455.1 87.79,25.39 v2(87.64,25.23)
DP_STEREOSYNC: length 14.5
  TOP w0.102: R2549.1 96.06,77.84 96.14,77.84 R2550.1 95.81,76.94 95.81,76.45 91.4,72.04 91.4,68.28 91.63,68.06 91.63,67.92 92.02,67.53 v1(92.02,67.02)
  BOTTOM w0.102: v1(92.02,67.02) 92.02,67.1 U2030.K15
DQA0_0: length 34.6
  IN3 w0.114: v2(144.39,104.1) 143.65,103.36 142.45,103.36 142.11,103.69 135.11,103.69 134.68,104.13 134.68,105.13 134.43,105.39 133.8,105.39 133.67,105.52 132.77,105.52 129.03,109.26 127.42,109.26 127.01,109.67 125.73,109.67 124.86,108.8 123.18,108.8 121.79,110.19 119.98,110.19 v2(119.52,110.65)
  BOTTOM w0.102: v2(119.52,110.65) 119.44,110.73 118.93,110.73 118.76,110.91 117.89,110.91 U2029.L34
  BOTTOM w0.127: v2(144.39,104.1) 143.96,104.53 143.96,106.2 VRAM2001.E2
DQA0_1: length 30.4
  IN3 w0.114: v2(142.17,109.97) 141.95,110.19 138.84,110.19 137.62,111.42 132.5,111.42 130.87,113.05 130.87,113.5 129.87,114.5 127.65,114.5 127.37,114.77 122.09,114.77 121.68,114.36 119.29,114.36 118.6,113.68 118.6,113.14 v2(118.02,112.56)
  BOTTOM w0.102: v2(118.02,112.56) 117.58,112.12 U2029.L37
  BOTTOM w0.127: v2(142.17,109.97) 142.34,109.8 142.34,108.62 VRAM2001.F4
DQA0_2: length 33.6
  IN3 w0.114: v2(116.93,112.56) 117.41,113.04 117.41,113.32 118.88,114.79 121.58,114.79 121.92,115.14 127.49,115.14 127.79,114.84 130.7,114.84 132.14,113.4 132.14,112.26 132.65,111.76 139.11,111.76 140.12,110.75 141.88,110.75 142.15,110.48 142.43,110.48 142.79,110.11 143.52,110.11 v2(143.52,110.09)
  BOTTOM w0.102: v2(116.93,112.56) 117.29,112.92 U2029.L38
  BOTTOM w0.127: v2(143.52,110.09) 143.52,109.62 143.15,109.26 143.15,108.61 VRAM2001.E4
DQA0_3: length 30.3
  IN3 w0.114: v2(119.13,111.85) 119.49,111.49 121.09,111.49 121.32,111.26 122.72,111.26 122.85,111.4 129.2,111.4 133.36,107.24 133.99,107.24 134.27,106.96 137.43,106.96 137.97,106.43 137.97,106.01 139.25,104.72 142.63,104.72 v2(142.9,104.45)
  BOTTOM w0.102: U2029.J35 v2(119.13,111.85)
  BOTTOM w0.127: v2(142.9,104.45) 142.9,105.11 143.16,105.37 143.16,106.2 VRAM2001.F2
DQA0_4: length 31.8
  IN3 w0.114: v2(120.31,112.03) 120.46,111.87 121.22,111.87 121.47,111.62 122.44,111.62 122.6,111.78 129.33,111.78 131.68,109.43 134.08,109.43 134.78,108.73 134.78,107.45 134.93,107.31 137.6,107.31 138.24,106.67 138.91,106.67 139.81,105.77 142.62,105.77 143.06,105.33 146.33,105.33 v2(146.38,105.38)
  BOTTOM w0.102: v2(120.31,112.03) 119.8,112.03 U2029.G37
  BOTTOM w0.127: v2(146.38,105.38) 146.38,106.18 145.99,106.58 VRAM2001.B2
DQA0_5: length 32.2
  IN3 w0.114: v2(121.07,112.36) 121.19,112.48 122.39,112.48 122.72,112.15 129.45,112.15 131.82,109.78 136.94,109.78 138.01,108.7 138.01,107.66 138.01,107.65 138.01,107.61 138.45,107.17 139.11,107.17 139.63,106.65 142.44,106.65 143.4,105.7 145.81,105.7 146.83,106.71 146.83,107.33 v2(146.38,107.78)
  BOTTOM w0.102: v2(121.07,112.36) 121.07,112.66 U2029.E38
  BOTTOM w0.127: VRAM2001.B4 v2(146.38,107.78)
DQA0_6: length 36.6
  IN3 w0.114: v2(147.68,107.61) 147.85,107.44 147.85,105.09 147.32,104.56 144.14,104.56 143.28,103.7 142.59,103.7 142.25,104.04 137.54,104.04 135.85,105.73 134.13,105.73 133.95,105.91 133.95,106.31 133.71,106.55 133.04,106.55 129.47,110.12 125.64,110.12 124.83,109.31 123.22,109.31 122,110.53 120.48,110.53 v2(120.13,110.88)
  BOTTOM w0.102: U2029.E35 120.4,111.16 v2(120.13,110.88)
  BOTTOM w0.127: VRAM2001.A4 147.11,108.18 v2(147.68,107.61)
DQA0_7: length 32.2
  IN3 w0.114: v2(120.84,110.98) 120.86,110.98 120.94,110.91 122.9,110.91 123.02,111.03 129.05,111.03 133.18,106.9 133.85,106.9 134.13,106.62 137.14,106.62 137.6,106.16 137.6,105.89 139.11,104.38 142.39,104.38 142.73,104.04 143.13,104.04 144.02,104.93 146.58,104.93 146.83,105.18 146.83,105.57 v2(147.42,106.16)
  BOTTOM w0.102: v2(120.84,110.98) 120.84,111.06 U2029.D35
  BOTTOM w0.127: v2(147.42,106.16) 147.01,106.58 VRAM2001.A2
DQA0_8: length 32.7
  IN3 w0.114: v2(145.58,114.98) 145.54,114.98 144.84,115.68 143.9,115.68 143.32,116.27 142.12,116.27 141.99,116.13 139.06,116.13 138.62,116.57 138.62,116.68 137.17,118.13 135.63,118.13 134.89,117.39 132.37,117.39 131.51,118.25 130.08,118.25 129.6,118.74 122.9,118.74 122.26,118.09 121.09,118.09 119.57,116.57 119.14,116.57 118.78,116.22 v2(118.63,116.22)
  BOTTOM w0.102: U2029.H41 119.15,114.9 119.11,114.95 119.11,115.73 v2(118.63,116.22)
  BOTTOM w0.127: VRAM2001.B13 v2(145.58,114.98)
DQA0_9: length 35.2
  IN3 w0.114: v2(147.18,115.78) 146.39,115.78 145.98,116.19 145.22,116.19 145.1,116.06 144.03,116.06 143.47,116.62 141.97,116.62 141.82,116.47 140.09,116.47 138.09,118.47 131.77,118.47 131.13,119.11 122.78,119.11 122.12,118.44 120.95,118.44 119.44,116.93 118.98,116.93 118.7,116.65 118.37,116.65 118.17,116.45 118.17,116.01 v2(118.6,115.58)
  BOTTOM w0.102: U2029.H40 119.15,114.22 118.83,114.54 118.83,114.82 118.91,114.9 118.91,115.28 v2(118.6,115.58)
  BOTTOM w0.127: VRAM2001.A13 v2(147.18,115.78)
DQA0_10: length 35.3
  IN3 w0.114: v2(147.18,113.38) 147.18,112.65 145.64,111.11 143.19,111.11 142.91,110.83 142.3,110.83 141.9,111.24 140.12,111.24 139.26,112.1 132.79,112.1 132.48,112.4 132.48,113.54 130.84,115.18 128.15,115.18 127.25,116.09 122.87,116.09 122.77,115.99 121.93,115.99 121.12,115.18 119.49,115.18 119.29,115.38 v2(119.29,116.14)
  BOTTOM w0.102: U2029.G41 119.34,115.39 119.34,116.09 v2(119.29,116.14)
  BOTTOM w0.127: v2(147.18,113.38) VRAM2001.A11
DQA0_11: length 29.9
  IN3 w0.114: v2(119.77,115.61) 120.99,115.61 121.72,116.33 122.63,116.33 122.77,116.47 127.39,116.47 127.68,116.18 130.35,116.18 133.47,113.06 143.28,113.06 143.44,112.89 145.09,112.89 v2(145.58,113.38)
  BOTTOM w0.102: v2(119.77,115.61) 120.03,115.35 120.03,114.92 119.7,114.59 U2029.G40
  BOTTOM w0.127: v2(145.58,113.38) VRAM2001.B11
DQA0_12: length 28.2
  IN3 w0.114: v2(143.2,115.79) 142.71,115.3 142.05,115.3 141.93,115.42 138.5,115.42 137.98,115.94 135.34,115.94 135.13,116.14 132.53,116.14 131.13,117.55 129.66,117.55 129.19,118.03 123.31,118.03 122.31,117.03 121.52,117.03 121.13,117.42 v2(121,117.42)
  BOTTOM w0.102: v2(121,117.42) 121.45,116.98 121.45,116.09 121.12,115.76 121.12,114.91 120.94,114.73 120.94,114.46 U2029.E40
  BOTTOM w0.127: VRAM2001.E13 143.2,115.76 v2(143.2,115.79)
DQA0_13: length 25.7
  IN3 w0.114: v2(142.39,115.77) 142.39,115.77 138.78,115.77 138.11,116.45 138.11,116.7 137.6,117.21 135.19,117.21 135.03,117.05 132.12,117.05 131.27,117.89 129.81,117.89 129.33,118.37 123.17,118.37 122.49,117.69 v2(122.34,117.69)
  BOTTOM w0.102: U2029.D41 121.35,115.71 121.75,116.11 121.75,116.72 122.34,117.31 v2(122.34,117.69)
  BOTTOM w0.127: v2(142.39,115.77) VRAM2001.F13
DQA0_14: length 25.9
  IN3 w0.114: v2(123.33,116.95) 123.72,117.34 128.9,117.34 129.38,116.86 130.64,116.86 132.04,115.46 134.78,115.46 135.82,114.41 135.82,113.87 135.95,113.74 141.94,113.74 v2(142.38,114.18)
  BOTTOM w0.102: U2029.D40 121.35,114.2 121.66,114.5 121.66,114.82 121.58,114.9 121.58,115.64 122.89,116.95 v2(123.33,116.95)
  BOTTOM w0.127: VRAM2001.F11 142.78,113.78 v2(142.38,114.18)
DQA0_15: length 25.4
  IN3 w0.114: v2(124.6,116.93) 127.47,116.93 127.88,116.52 130.5,116.52 133.62,113.4 143.96,113.4 v2(143.98,113.38)
  BOTTOM w0.102: U2029.C41 121.78,115.2 121.78,115.56 122.39,116.17 123.84,116.17 v2(124.6,116.93)
  BOTTOM w0.127: v2(143.98,113.38) VRAM2001.E11
DQA0_16: length 21.3
  IN1 w0.114: v2(137.58,114.18) 137.73,114.33 138.02,114.84 138.02,115.5 137.6,117.06 137.3,117.36 135.92,118.14 134.59,118.63 133.21,118.63 128,118.22 127.37,117.99 124.74,116.52 124.44,116.4 122.99,116.06 v2(122.39,115.56)
  BOTTOM w0.102: v2(122.39,115.56) 122.31,115.07 122.31,114.9 U2029.C40
  BOTTOM w0.127: VRAM2001.M11 v2(137.58,114.18)
DQA0_17: length 20.1
  IN1 w0.114: v2(124.52,115.63) 125.06,115.63 125.89,116.47 126.76,116.47 128.05,117.77 133.34,117.77 133.85,118.28 134.45,118.28 135.34,117.39 136.28,117.39 136.59,117.08 137.09,117.08 137.3,116.88 137.3,115.86 137.61,115.55 v2(137.61,114.98)
  BOTTOM w0.102: U2029.B39 123.01,114.03 123.43,114.03 124.52,115.12 v2(124.52,115.63)
  BOTTOM w0.127: VRAM2001.M13 137.98,115.34 v2(137.61,114.98)
DQA0_18: length 16.9
  IN1 w0.114: v2(125.69,115.61) 126.17,116.09 126.91,116.09 128.22,117.4 134.83,117.4 135.09,117.15 135.1,117.15 135.2,117.05 136.12,117.05 136.54,116.63 v2(136.88,116.63)
  BOTTOM w0.102: v2(125.69,115.61) 125.31,115.61 123.38,113.67 U2029.A39
  BOTTOM w0.127: v2(136.88,116.63) 136.78,116.53 136.78,115.78 VRAM2001.N13
DQA0_19: length 19
  IN1 w0.114: v2(136.78,114.18) 137.19,114.59 137.19,115.43 136.42,116.19 128.33,116.19 127.34,115.19 124.79,115.19 124.14,114.55 v2(124.14,113.85)
  BOTTOM w0.102: U2029.B38 122.53,113.07 122.83,113.38 123.1,113.38 123.16,113.32 123.45,113.32 123.61,113.47 123.76,113.47 v2(124.14,113.85)
  BOTTOM w0.127: v2(136.78,114.18) 137.18,113.78 VRAM2001.N11
DQA0_20: length 14.7
  IN1 w0.114: v2(124.55,112.6) 124.99,113.04 125.98,113.04 126.32,113.39 128.85,113.39 129.58,114.12 132.31,114.12 132.78,113.65 133.54,113.65 133.92,114.03 133.92,114.52 v2(134.38,114.98)
  BOTTOM w0.102: U2029.B36 122.52,111.97 122.85,112.3 123.07,112.3 123.16,112.2 124.15,112.2 v2(124.55,112.6)
  BOTTOM w0.127: VRAM2001.T13 v2(134.38,114.98)
DQA0_21: length 12.6
  IN1 w0.114: v2(127.07,113.81) 128.79,113.81 129.6,114.62 133.16,114.62 133.28,114.73 v2(133.28,115.05)
  BOTTOM w0.102: U2029.A36 122.98,112 124.52,112 125.77,113.24 126.5,113.24 v2(127.07,113.81)
  BOTTOM w0.127: v2(133.28,115.05) 133.61,115.38 VRAM2001.U13
DQA0_22: length 14.4
  IN1 w0.114: v2(126.07,112.58) 126.5,113.02 128.71,113.02 128.76,112.97 130.19,112.97 131,113.78 132.02,113.78 132.52,113.27 134.26,113.27 134.38,113.38 v2(134.38,114.18)
  BOTTOM w0.102: U2029.B35 122.83,111.65 123.1,111.65 123.25,111.8 124.83,111.8 125.62,112.58 v2(126.07,112.58)
  BOTTOM w0.127: v2(134.38,114.18) 134.78,113.78 VRAM2001.T11
DQA0_23: length 11.8
  IN1 w0.114: v2(132.93,112.54) 132.88,112.59 v2(127.49,112.59)
  BOTTOM w0.102: v2(127.49,112.59) 127.02,112.12 125.58,112.12 125.06,111.59 123.47,111.59 U2029.A35
  BOTTOM w0.127: v2(132.93,112.54) 132.93,112.74 VRAM2001.U11
DQA0_24: length 12.9
  IN1 w0.114: v2(126.74,110.59) 127.2,110.13 132.34,110.13 133.54,108.93 v2(133.54,108.57)
  BOTTOM w0.102: v2(126.74,110.59) 126.32,110.17 123.58,110.17 123.43,110.02 123.18,110.02 122.87,110.32 U2029.B33
  BOTTOM w0.127: v2(133.54,108.57) 133.59,108.57 VRAM2001.U4
DQA0_25: length 14.3
  IN1 w0.114: v2(128.19,110.57) 132.39,110.57 134.35,108.6 v2(134.35,108.58)
  BOTTOM w0.102: v2(128.19,110.57) 127.75,110.13 126.97,110.13 126.57,109.73 125.02,109.73 124.65,109.36 123.61,109.36 123.43,109.54 123.18,109.54 123.1,109.46 122.82,109.46 122.51,109.77 U2029.B32
  BOTTOM w0.127: v2(134.35,108.58) 134.38,108.58 134.77,108.18 VRAM2001.T4
DQA0_26: length 14.1
  IN1 w0.114: v2(123.79,109.76) 124.22,109.33 125.22,109.33 125.75,109.87 126.17,109.87 126.4,109.64 126.4,108.98 126.63,108.75 131.86,108.75 132.41,108.19 132.41,107.26 v2(133.54,106.14)
  BOTTOM w0.102: v2(123.79,109.76) 123.78,109.77 U2029.A32
  BOTTOM w0.127: VRAM2001.U2 v2(133.54,106.14)
DQA0_27: length 14.8
  IN1 w0.114: v2(126.84,109.23) 126.84,109.24 131.86,109.24 132.76,108.34 132.76,107.45 133.28,106.92 133.64,106.92 v2(134.38,106.18)
  BOTTOM w0.102: v2(126.84,109.23) 126.02,108.41 125.29,108.41 124.78,108.92 123.16,108.92 122.85,109.22 U2029.B31
  BOTTOM w0.127: VRAM2001.T2 v2(134.38,106.18)
DQA0_28: length 16.9
  IN1 w0.114: v2(128.33,109.67) 132.05,109.67 133.1,108.63 133.1,107.68 133.41,107.37 136.37,107.37 v2(136.78,107.78)
  BOTTOM w0.102: v2(128.33,109.67) 126.86,108.21 125.21,108.21 124.7,108.72 123,108.72 U2029.A30
  BOTTOM w0.127: VRAM2001.N4 v2(136.78,107.78)
DQA0_29: length 17.7
  IN1 w0.114: v2(136.78,106.18) 136.33,105.74 136.33,104.89 135.66,104.21 132.56,104.21 129.98,106.79 125.54,106.79 125.44,106.89 124.72,106.89 123.79,107.83 123.78,107.83 v2(123.76,107.85)
  BOTTOM w0.102: U2029.B29 122.85,108.12 123.19,107.78 123.68,107.78 v2(123.76,107.85)
  BOTTOM w0.127: VRAM2001.N2 v2(136.78,106.18)
DQA0_30: length 20.1
  IN1 w0.114: v2(138.38,106.18) 137.96,105.76 137.96,104.89 136.6,103.53 132.28,103.53 130.32,105.48 127.56,105.48 126.77,106.27 v2(126.77,106.37)
  BOTTOM w0.102: v2(126.77,106.37) 126.05,107.1 123.66,107.1 123.43,107.33 123.17,107.33 123.1,107.25 122.85,107.25 122.52,107.57 U2029.B28
  BOTTOM w0.127: VRAM2001.M2 v2(138.38,106.18)
DQA0_31: length 19.9
  IN1 w0.114: v2(137.58,107.78) 137.58,105.05 136.4,103.87 132.42,103.87 129.97,106.32 v2(128.13,106.32)
  BOTTOM w0.102: v2(128.13,106.32) 127.15,107.3 123.74,107.3 123.51,107.53 123,107.53 U2029.A28
  BOTTOM w0.127: VRAM2001.M4 v2(137.58,107.78)
DQA1_0: length 26.5
  IN3 w0.114: v2(138.38,92.59) 137.88,93.09 137.88,98.89 130.94,105.83 125.19,105.83 v2(124.68,106.35)
  BOTTOM w0.102: v2(124.68,106.35) 124.34,106.68 123.17,106.68 122.83,107.02 U2029.B27
  BOTTOM w0.127: VRAM2002.F4 138.38,91.8 138.38,92.59 v2(138.38,92.59)
DQA1_1: length 24.9
  IN3 w0.114: v2(138.4,93.41) 138.4,98.86 131.08,106.18 129,106.18 128.38,106.79 126.43,106.79 v2(126.02,106.38)
  BOTTOM w0.102: U2029.A27 123.43,106.89 125.51,106.89 v2(126.02,106.38)
  BOTTOM w0.127: VRAM2002.F2 v2(138.4,93.41)
DQA1_2: length 24.6
  IN3 w0.114: v2(126.03,105.07) 126.43,105.47 130.82,105.47 136.89,99.4 136.89,93.46 v2(136.8,93.37)
  BOTTOM w0.102: U2029.B26 122.5,106.47 122.84,106.13 123.06,106.13 123.2,106.26 123.86,106.26 124.39,105.73 125.37,105.73 v2(126.03,105.07)
  BOTTOM w0.127: VRAM2002.E2 137.18,93 v2(136.8,93.37)
DQA1_3: length 24.8
  IN3 w0.114: v2(128.08,105.02) 130.79,105.02 136.55,99.26 136.55,93.8 136.39,93.64 136.39,92.98 v2(136.78,92.59)
  BOTTOM w0.102: U2029.A26 123.94,106.47 124.48,105.93 125.57,105.93 125.7,105.8 127.29,105.8 v2(128.08,105.02)
  BOTTOM w0.127: v2(136.78,92.59) 136.78,91.79 VRAM2002.E4
DQA1_4: length 22.7
  IN3 w0.114: v2(126.72,105.02) 127.16,104.58 130.74,104.58 135.91,99.4 135.91,95.07 135.65,94.81 135.64,94.81 135.39,94.57 135.39,94.55 135.32,94.47 v2(135.13,94.47)
  BOTTOM w0.102: v2(126.72,105.02) 126.35,104.66 124.5,104.66 123.78,105.37 U2029.A24
  BOTTOM w0.127: VRAM2002.B2 135.13,93.35 v2(135.13,94.47)
DQA1_5: length 19.9
  IN3 w0.114: v2(132.9,94.83) 133.07,94.99 133.07,99.45 130.06,102.46 127.75,102.46 v2(126.96,103.24)
  BOTTOM w0.102: U2029.B23 122.86,104.82 123.18,104.51 123.73,104.51 124.19,104.05 125.74,104.05 126.14,103.65 126.55,103.65 v2(126.96,103.24)
  BOTTOM w0.127: VRAM2002.A2 133.77,93.2 133.28,93.2 132.9,93.59 v2(132.9,94.83)
DQA1_6: length 22.1
  IN3 w0.114: v2(127.62,103.24) 128.07,102.8 130.2,102.8 133.41,99.59 133.41,94.73 133.15,94.47 133.15,92.44 133.57,92.02 133.71,92.02 134.38,91.35 v2(134.38,90.99)
  BOTTOM w0.102: U2029.A23 123.72,104.82 124.29,104.25 125.87,104.25 126.26,103.86 127.01,103.86 v2(127.62,103.24)
  BOTTOM w0.127: VRAM2002.B4 v2(134.38,90.99)
DQA1_7: length 23.2
  IN3 w0.114: v2(129.56,101.23) 129.56,100.9 130.96,99.5 130.96,97.8 131.55,97.21 131.55,93.91 131.75,93.7 131.75,91.78 132.48,91.06 132.48,90.58 v2(132.9,90.16)
  BOTTOM w0.102: v2(129.56,101.23) 128.97,101.82 127.73,101.82 126.71,102.83 124.16,102.83 123.58,103.41 123.15,103.41 123.07,103.49 122.82,103.49 122.72,103.39 122.46,103.39 122.25,103.6 U2029.B22
  BOTTOM w0.127: VRAM2002.A4 133.67,91.08 133.67,90.92 v2(132.9,90.16)
DQA1_8: length 25.2
  IN3 w0.114: v2(128.93,100.28) 129.37,99.85 129.64,99.85 130.28,99.22 130.28,97.51 130.86,96.93 130.86,93.63 131.07,93.42 131.07,91.5 131.79,90.78 131.79,90.15 134.35,87.59 v2(134.35,87.12)
  BOTTOM w0.102: v2(128.93,100.28) 128.93,100.35 128.51,100.77 127.77,100.77 127.57,100.98 127.57,101.23 126.38,102.42 124,102.42 123.49,102.93 123.18,102.93 123.1,102.86 122.82,102.86 122.5,103.17 U2029.B20
  BOTTOM w0.127: v2(134.35,87.12) 134.35,86.16 VRAM2002.A11
DQA1_9: length 25.4
  IN3 w0.114: v2(128.13,101.21) 128.56,100.77 129.21,100.77 130.62,99.36 130.62,97.65 131.2,97.07 131.2,93.77 131.41,93.56 131.41,91.64 132.13,90.92 132.13,90.29 134.44,87.98 135.05,87.98 135.42,87.61 v2(135.42,87.22)
  BOTTOM w0.102: v2(128.13,101.21) 127.89,101.21 126.47,102.63 124.08,102.63 123.53,103.17 U2029.A20
  BOTTOM w0.127: VRAM2002.B11 135.24,86.25 135.24,87.03 v2(135.42,87.22)
DQA1_10: length 29
  IN3 w0.114: v2(125.64,101.38) 125.53,101.38 124.46,100.32 123.97,100.32 123.16,99.51 123.16,96.15 125.14,94.17 125.14,93.43 126.55,92.01 126.83,91.74 126.83,89.32 132.51,83.64 134.24,83.64 v2(134.39,83.79)
  BOTTOM w0.102: U2029.B19 122.85,102.62 123.23,102.25 123.6,102.25 123.83,102.02 125,102.02 v2(125.64,101.38)
  BOTTOM w0.127: VRAM2002.A13 v2(134.39,83.79)
DQA1_11: length 31
  IN3 w0.114: v2(126.92,101.23) 126.49,100.8 125.43,100.8 124.44,99.81 123.94,99.81 123.51,99.37 123.51,96.29 125.48,94.31 125.48,93.57 127.19,91.86 127.19,89.44 132.37,84.26 134.99,84.26 135.19,84.06 v2(135.19,83.79)
  BOTTOM w0.102: U2029.A19 123.48,102.45 123.68,102.45 123.91,102.22 126.12,102.22 126.92,101.42 v2(126.92,101.23)
  BOTTOM w0.127: v2(135.19,83.79) 134.78,84.19 VRAM2002.B13
DQA1_12: length 29
  IN3 w0.114: v2(136.78,85.43) 136.19,86.02 131.58,86.02 128.46,89.15 128.46,92.06 127.95,92.57 127.95,92.93 124.86,96.01 124.86,98.09 125.24,98.46 125.24,99.05 125.83,99.64 126.29,99.64 v2(126.93,100.28)
  BOTTOM w0.102: v2(126.93,100.28) 126.79,100.28 126.33,100.75 125.14,100.75 125.09,100.8 123.97,100.8 123.62,101.15 123.2,101.15 122.83,101.52 U2029.B17
  BOTTOM w0.127: v2(136.78,85.43) 137.14,85.79 VRAM2002.E11
DQA1_13: length 28.3
  IN3 w0.114: v2(137.58,83.8) 136.43,84.95 132.17,84.95 128.12,89 128.12,91.42 125.82,93.71 125.82,94.57 124.52,95.87 124.52,98.23 124.9,98.61 124.9,99.6 v2(125.58,100.28)
  BOTTOM w0.102: U2029.A16 123,100.93 123.55,100.93 123.89,100.6 124.88,100.6 125.19,100.28 v2(125.58,100.28)
  BOTTOM w0.127: VRAM2002.E13 137.18,84.19 v2(137.58,83.8)
DQA1_14: length 31.3
  IN3 w0.114: v2(138.38,83.79) 138,84.17 138,85.95 137.24,86.71 132.2,86.71 130.49,88.42 130.49,90.24 129.77,90.96 129.77,92.88 127.24,95.41 126.63,95.41 125.61,96.44 125.61,97.85 125.79,98.03 126.41,98.03 v2(127.28,98.9)
  BOTTOM w0.102: v2(127.28,98.9) 126.65,99.53 125.46,99.53 124.6,100.39 123.8,100.39 123.47,100.73 123.15,100.73 123.05,100.62 122.85,100.62 122.49,100.97 U2029.B16
  BOTTOM w0.127: VRAM2002.F13 v2(138.38,83.79)
DQA1_15: length 25.9
  IN3 w0.114: v2(137.56,85.42) 136.61,86.37 132.06,86.37 130.15,88.28 130.15,90.1 129.43,90.82 129.43,92.74 127.32,94.86 126.51,94.86 125.21,96.16 125.21,97.94 125.61,98.34 125.61,98.49 v2(125.99,98.87)
  BOTTOM w0.102: v2(125.99,98.87) 125.83,98.87 124.51,100.19 123.72,100.19 123.49,100.42 U2029.A15
  BOTTOM w0.127: VRAM2002.F11 137.94,85.79 v2(137.56,85.42)
