# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ACZ_RST#_R: length 9.3
  BOTTOM w0.102: R2429.1 107.49,49.14 107.11,48.75 106.96,48.75 106.86,48.85 106.72,48.85 106.57,48.71 106.57,48.57 106.68,48.46 106.68,48.32 106.53,48.18 106.39,48.18 106.28,48.28 106.14,48.28 106,48.14 106,47.99 106.1,47.89 106.1,47.74 105.94,47.58 105.26,47.58 105.05,47.8 104.64,47.8 104.43,47.58 101.79,47.58 101.54,47.83 101.29,47.83 101.01,47.55 101.01,47.01 U2030.AP3
ACZ_SDIN0: length 115.5
  TOP w0.102: v1(121.73,49.44) 121.7,49.42 v2(118.86,49.42) 117.38,49.42 115.91,50.89 113.56,50.89 112.1,52.34 110.35,52.34 108.55,50.53 105.8,50.53 102.78,47.51 100.67,47.51 100.31,47.15 99.27,47.15 v1(98.94,47.48)
  IN3 w0.089: v1(121.73,49.44) 121.86,49.44 124.49,46.82 131.41,46.82 131.63,46.6 142.9,46.6 143.59,45.91 144.63,45.91 147.09,43.45 147.09,41.33 148.02,40.4 148.74,40.4 150.57,38.56 150.57,36.7 149.95,36.09 149.95,35.23 151.56,33.62 152.19,33.62 152.27,33.7 158.04,33.7 158.56,34.22 167.82,34.22 169.19,32.85 169.96,32.85 172.24,30.56 173.67,30.56 174.29,29.94 178.37,29.94 179.54,28.77 182.52,28.77 183.05,29.3 185.96,29.3 187.13,28.14 192.13,28.14 192.33,27.94 194.3,27.94 194.5,28.14 195.1,28.14 v2(195.51,27.72)
  BOTTOM w0.102: R751.2 195.67,27.88 v2(195.51,27.72) ; U2030.AP7 98.51,47.05 v1(98.94,47.48)
ACZ_SDOUT_AUDIO: length 124.7
  IN1 w0.089: v2(198.82,25.61) 198.34,25.61 197.8,26.15 196.78,26.15 196.45,25.82 191.89,25.82 191.45,25.38 191.45,23.61 191.2,23.35 190.61,23.35 190.36,23.61 v2(190.36,23.94)
  IN3 w0.089: v1(110.68,47.52) 111.19,48.03 111.19,48.37 111.31,48.5 111.69,48.5 111.82,48.37 111.82,47.77 113.45,46.14 113.45,41.12 112.46,40.14 112.46,36.54 111.26,35.33 111.17,35.33 110.67,34.83 110.67,33.88 111.52,33.04 111.52,32.8 113.61,30.71 113.61,26.47 114.28,25.8 115.15,25.8 116.34,24.61 121.02,24.61 122.31,25.91 145.07,25.91 146.33,27.17 153.27,27.17 153.65,27.55 155.56,27.55 155.99,27.13 158.59,27.13 159.08,26.64 162.91,26.64 163.57,25.97 164.83,25.97 166.67,24.12 168.04,24.12 168.28,23.88 172.33,23.88 173.61,22.6 177.71,22.6 178.27,22.04 182.25,22.04 183.21,21.09 187.56,21.09 190.23,23.76 190.23,23.81 v2(190.36,23.94)
  BOTTOM w0.102: v2(198.82,25.61) 199.04,25.61 199.49,26.06 U30.5 ; R2443.2 108.44,47.43 110.59,47.43 v1(110.68,47.52)
ACZ_SDOUT_R: length 7.4
  BOTTOM w0.102: U2030.AR3 101.36,46.01 101.84,46.49 102.01,46.49 102.07,46.54 103.14,46.54 103.31,46.72 106.11,46.72 107.02,47.64 R2443.1
ACZ_SPKR: length 119.6
  IN2 w0.089: v1(91.02,44.58) 91.3,44.87 93.33,44.87 94.88,46.42 95.52,46.42 95.99,46.89 98.12,46.89 98.41,46.6 99.88,46.6 101.92,44.56 103.68,44.56 106.49,41.75 106.49,36.87 107.73,35.63 109.19,35.63 109.59,35.23 109.59,34.72 113.4,30.91 120.26,30.91 120.89,30.29 130.72,30.29 132.2,28.81 136.5,28.81 137.77,30.08 138.21,30.08 138.47,30.34 152.45,30.34 153.69,29.1 156.24,29.1 156.89,28.45 159.08,28.45 159.28,28.64 164.05,28.64 164.67,29.27 168.54,29.27 168.73,29.08 174.46,29.08 175.05,29.67 181.08,29.67 181.56,30.14 182.36,30.14 182.8,30.57 184.95,30.57 185.23,30.85 188.91,30.85 190.99,32.93 v2(191.32,32.93)
  BOTTOM w0.102: v2(191.32,32.93) 191.32,32.88 v2(192.03,32.18) 194.05,32.18 D34.2 ; v1(91.02,44.58) 90.79,44.81 U2030.AU16
ACZ_SYNC_AUDIO: length 124.2
  IN1 w0.089: v2(198.56,28.38) 198.38,28.56 195.14,28.56 194.26,27.68 191.72,27.68 189.16,25.13 189.16,24.37 v2(189.65,23.89)
  IN3 w0.089: v2(189.65,23.89) 189.65,23.48 189.53,23.37 189.18,23.37 188.78,22.97 188.78,22.62 187.47,21.3 183.72,21.3 182.77,22.26 178.36,22.26 177.8,22.81 173.76,22.81 172.47,24.1 168.37,24.1 167.46,25.01 166.59,25.01 165.41,26.19 163.66,26.19 163,26.85 159.17,26.85 158.68,27.34 156.08,27.34 155.65,27.77 153.56,27.77 153.18,27.38 146.24,27.38 144.98,26.12 122.22,26.12 120.93,24.83 116.43,24.83 115.24,26.01 114.37,26.01 113.83,26.56 113.83,30.8 111.74,32.89 111.74,33.13 110.89,33.97 110.89,34.74 111.26,35.11 111.34,35.11 112.68,36.45 112.68,40.05 113.66,41.03 113.66,47.11 111.77,49.01 v1(110.68,49.01)
  BOTTOM w0.102: v2(198.56,28.38) 199.12,28.38 199.45,28.06 U30.10 ; R2446.2 109.66,48.75 109.84,48.58 110.25,48.58 v1(110.68,49.01)
ACZ_SYNC_R: length 9.3
  BOTTOM w0.102: U2030.AR4 100.95,46.51 101.41,46.97 101.41,47.07 101.67,47.32 106.01,47.32 107.43,48.75 R2446.1
ADBIA0: length 25.1
  TOP w0.102: 123.52,103.3 123.01,103.3 122.63,103.68 120.44,103.68 v2(119.87,103.11)
  TOP w0.127: v2(140,107.78) 139.98,107.78 138.85,106.65 138.85,106.01 136.41,103.57 131.43,103.57 130.62,102.75 124.06,102.75 123.52,103.3
  BOTTOM w0.102: U2029.H21 119.01,103.72 119.62,103.11 v2(119.87,103.11)
  BOTTOM w0.127: v2(140,107.78) 140,107.81 VRAM2001.J4
ADBIA1: length 28.8
  TOP w0.102: v2(119.3,102.13) 119.49,102.13 119.93,101.69 120.44,101.69 120.72,101.4 122.42,101.4 123.68,100.14 124.73,100.14
  TOP w0.127: 124.73,100.14 125.5,99.36 127.87,99.36 127.99,99.25 v2(134.81,99.25) 135.07,99.25 139.82,94.5 139.82,92.77 140.78,91.8 v2(140.78,90.99)
  BOTTOM w0.102: U2029.H19 v2(119.3,102.13)
  BOTTOM w0.127: VRAM2002.J4 v2(140.78,90.99)
ADOGND: length 31
  TOP w0.203: v2(208.47,26.02) 208.49,26 R281.2 ; v2(209.38,28.31) 209.51,28.44 R289.1 ; v2(201.33,32.07) R720.1 ; R275.1 206.08,22.18 205.8,22.47 v2(205.67,22.47)
  TOP w0.381: v2(214.44,42.79) 214.69,42.53 C343.1 215.32,41.89 v2(215.2,41.77) ; v2(204.02,34.02) 204.15,34.02 204.53,33.64 204.53,32.88 204.31,32.66 C375.1 ; C366.2 207.07,32.88 v2(206.82,33.13)
  BOTTOM w0.203: C620.2 209.11,29.33 208.95,29.17 R686.1 209.1,28.69 209.38,28.41 v2(209.38,28.31) ; v2(206.84,29.96) 206.94,29.86 206.94,29.2 206.6,28.86 U30.25 ; R224.2 207.71,38.21 v2(208.09,38.59) ; U30.38 204.94,22.96 205.43,22.47 v2(205.67,22.47) ; R249.2 210.85,36.91 v2(210.88,36.94)
  BOTTOM w0.305: v2(214.44,42.79) 214.33,42.9 CN6.1 ; CN6.12 212.36,37.4 v2(212.15,37.6) ; v2(214.43,41.9) 214.43,41.9 CN6.3 ; CN6.5 214.46,40.9 215.2,41.64 v2(215.2,41.77) ; v2(208.09,38.59) C323.1
  BOTTOM w0.381: C643.1 203.13,33.51 v2(203.26,33.39) ; C619.2 v2(204.79,22.1) ; C340.1 v2(211.02,33.9) ; v2(203.9,33.26) 203.9,33.01 203.53,32.63 C635.2 ; v2(209.23,27.04) 209.11,27.16 C616.1 209.11,28.04 v2(209.38,28.31) ; v2(205.67,22.47) 205.88,22.26 C629.1 ; C623.2 C627.2 206.94,33.01 v2(206.82,33.13) ; C620.2 209.11,30.53 v2(208.72,30.92) ; C332.1 v2(211.02,34.53) ; C327.1 v2(210.49,39.23)
  vias: v2(208.72,31.61)
ADP_ID: length 202.7
  TOP w0.305: v2(136.97,36.16) 137.28,36.47 PQ9.2 ; v2(136.97,36.16) 136.44,35.63 PR69.1 ; v2(136.97,36.16) 135.78,37.36 v2(134.55,37.36) PR71.2
  IN1 w0.254: v2(111.23,90.16) 112.04,90.16 112.86,89.33 112.86,88.23 113.6,87.49 113.6,86.35 114.29,85.66 114.29,79.98 114.96,79.31 114.96,77.73 115.86,76.82 116.87,76.82 117.43,76.25 117.43,72.61 118.53,71.52 118.53,67.32 122.87,62.97 122.87,60.69 124.93,58.63 124.93,47.34 126.2,46.07 126.2,43.15 129.07,40.27 132.38,40.27 134.33,38.32 134.33,37.43 135.37,36.38 135.37,36.08 135.77,35.67 136.48,35.67 v2(136.97,36.16)
  IN3 w0.254: v2(111.23,90.16) 110.87,90.51 107.92,90.51 105.86,92.57 105.12,92.57 104.05,93.64 104.05,94.7 102.77,95.98 102.06,95.98 101.19,96.85 101.19,97.55 100.46,98.28 99.6,98.28 96.62,101.25 96.62,106.61 96.96,106.96 96.96,108.95 96.62,109.29 96.62,111.32 96.02,111.92 94.78,111.92 92.42,114.29 86.69,114.29 83.72,117.26 80.13,117.26 78.72,118.67 78.36,118.67 77.66,117.97 73.84,117.97 73.1,118.71 72.16,118.71 70.99,119.87 69.02,119.87 68.31,119.16 67.28,119.16 66.08,120.36 52.49,120.36 50.12,117.99 46.14,117.99 43.76,120.38 41.84,120.38 41.46,120 39.56,120 35.62,116.06 16.06,116.06 14.45,114.45 PJ6.3
AGPIO3: length 1.5
  TOP w0.102: v1(90.87,46.01) 91.25,46.39 TP2039.1
  BOTTOM w0.102: U2030.AT15 91.11,46.01 v1(90.87,46.01)
AGPIO130: length 9.6
  TOP w0.102: TP9100.1 95.82,36.94 94.6,38.16 94.6,38.54 92.52,40.63 92.52,43.13 v1(92,43.64)
  BOTTOM w0.102: U2030.AV15 91.88,43.64 v1(92,43.64)
AMP_MUTE#: length 36.3
  TOP w0.102: v2(201.16,16.81) 201.15,16.81 201.15,16.37 201.33,16.19 D36.1 ; U13.108 175.22,28.67 175.4,28.48 175.4,27.34 175.65,27.09 176.08,27.09 v2(176.52,27.52)
  IN3 w0.089: v2(176.52,27.52) 177.41,26.62 182.99,26.62 183.28,26.33 188.72,26.33 189.25,25.8 192.33,25.8 193.01,25.13 193.01,24.25 193.15,24.1 193.15,22.88 197.69,18.34 200.88,18.34 201.16,18.07 v2(201.16,16.81)
ANALOGIO: length 8.7
  BOTTOM w0.102: R2653.2 98.36,118.48 98.61,118.22 98.61,114.12 99.79,112.94 100.21,112.94 100.33,112.83 100.85,112.83 100.94,112.73 101.16,112.73 101.5,113.07 U2029.AY38
APU_ALERT#: length 16
  TOP w0.102: v1(92.06,68.03) 91.63,68.45 91.63,71.9 93.07,73.34 98.56,73.34 99.63,74.41 100.39,74.41 100.7,74.71 100.7,75.22 100.85,75.37 R2524.2
  BOTTOM w0.102: U2030.J15 91.68,68.41 v1(92.06,68.03)
APU_CORETYPE: length 18.1
  TOP w0.102: R2510.2 94.55,28.94 v1(95.06,29.45)
  IN3 w0.089: v1(95.06,29.45) 95.46,29.86 96.08,29.86 98.11,31.88 98.11,34.58 97.1,35.58 97.1,41.23 96.59,41.75 96.59,43.07 v1(96.01,43.65)
  BOTTOM w0.102: v1(96.01,43.65) 95.67,43.31 U2030.AW11
APU_DBRDY: length 8.4
  BOTTOM w0.102: TP9104.1 111.01,41.82 111.75,41.82 112.08,42.15 115.38,42.15 115.56,42.33 115.56,43.88 115.38,44.06 CN2021.14
APU_DBREQ#: length 12.3
  BOTTOM w0.102: U2030.AW3 101.18,42.84 101.97,42.84 102.18,43.05 102.99,43.05 104.38,44.44 108.65,44.44 108.88,44.21 109.94,44.21 110.26,43.89 110.26,43.43 C8164.1 R129.2 R567.2
APU_DISP_ON: length 114.1
  IN3 w0.089: v1(113.74,38.59) 114.14,38.99 114.14,39.71 114.93,40.5 114.93,47.83 113.28,49.48 113.28,51.62 113.18,51.71 113.18,58.09 113.63,59.18 114.63,60.18 115.09,61.3 115.09,62.5 114.97,62.62 114.97,67.02 113.31,68.69 113.31,69.1 112.35,70.06 112.35,71.02 112.12,71.25 111.17,71.25 110.02,72.4 107.92,72.4 106.66,73.65 106.66,73.98 105.98,74.66 105.98,75.85 104.6,77.22 104.6,77.67 99.19,83.09 99.19,84.38 98.51,85.05 98.51,89.05 94.29,93.27 92.75,93.27 91.9,94.12 89.31,94.12 88.04,95.4 83.55,95.4 82.52,96.43 75.67,96.43 73.92,98.17 71.21,98.17 68.31,101.08 v2(68.19,101.08)
  BOTTOM w0.102: v2(68.19,101.08) 68.19,94.92 69.53,93.59 69.53,92.82 69.12,92.41 R536.2 ; D2039.2 110.65,35.09 111.67,36.1 111.67,37.29 112.45,38.08 R2546.2 113.09,38.08 113.61,38.59 v1(113.74,38.59) 114.12,38.21 115.25,38.21 115.65,38.61 Q2032.6
APU_DISP_ON_R: length 67.6
  TOP w0.102: v1(102.73,75.25) 102.47,75.25 102.42,75.3 102.24,75.47 101.55,75.47 101.1,75.03 101.1,74 100.19,73.09 94.23,73.09 92.15,71.01 v1(92.04,71.01)
  IN3 w0.089: v1(115.77,35.93) 115.25,35.93 113.37,37.81 113.37,39.76 114.35,40.75 114.35,47.4 112.43,49.32 112.43,51.13 112.42,51.13 109.96,53.59 109.96,60.42 111.38,61.85 111.38,61.9 112.35,62.87 112.35,65.81 111.48,66.68 110.97,66.68 109.82,67.83 108.23,67.83 107.93,68.12 102.97,68.12 101.79,69.3 101.79,72.88 102.21,73.31 102.21,74.71 102.73,75.22 v1(102.73,75.25)
  BOTTOM w0.102: Q2032.1 115.65,36.05 v1(115.77,35.93) ; U2030.F15 91.81,71.01 v1(92.04,71.01)
APU_DPST_PWM: length 68.9
  TOP w0.102: v2(53.25,106.06) 53.4,106.21 53.4,106.54 53.53,106.67 R25.1
  IN3 w0.089: v2(103.77,77.71) 103.77,78.06 98.87,82.96 98.87,84.25 98.19,84.92 98.19,86.58 97.71,87.07 97.71,89.41 94.71,92.41 93.17,92.41 91.76,93.81 89.18,93.81 87.91,95.08 83.42,95.08 82.39,96.11 75.54,96.11 73.79,97.85 71.08,97.85 68.26,100.68 67.77,100.68 65.45,103 60.27,103 58.9,104.38 57.59,104.38 56.83,105.14 54.16,105.14 v2(53.25,106.06)
  BOTTOM w0.102: v2(103.77,77.71) 104.03,77.97 R2522.2 105.99,77.97 Q2033.3
APU_DPST_PWM_R: length 23.2
  TOP w0.102: v1(92.08,66.38) 92.19,66.48 92.47,66.77 92.47,69.79 93.15,70.47 93.15,71.36 94.42,72.63 100.63,72.63 100.86,72.86 101.74,72.86 102.65,73.77 v1(102.68,73.77)
  BOTTOM w0.102: v1(102.68,73.77) 103.06,73.77 106.11,76.82 107.38,76.82 107.57,77.01 Q2033.1 ; U2030.L14 92.19,66.48 v1(92.08,66.38)
APU_LVDS_BLON: length 116.8
  TOP w0.102: R20.2 57.39,105.29 v2(57.54,105.14)
  IN3 w0.089: v1(113.74,37.98) 114.46,38.7 114.46,39.58 115.25,40.37 115.25,47.96 113.59,49.62 113.59,51.94 113.5,52.03 113.5,58.03 113.89,58.98 114.89,59.97 115.41,61.23 115.41,62.63 115.29,62.75 115.29,67.16 113.63,68.82 113.63,69.23 112.67,70.19 112.67,71.15 112.2,71.61 111.26,71.61 110.16,72.71 108.05,72.71 106.98,73.78 106.98,74.87 106.36,75.48 106.36,75.91 104.92,77.36 104.92,77.81 99.5,83.22 99.5,84.51 98.83,85.18 98.83,89.18 94.42,93.59 92.88,93.59 92.03,94.44 89.44,94.44 88.17,95.71 84.49,95.71 82.97,97.24 81.57,97.24 81.28,96.94 75.75,96.94 74.21,98.49 71.35,98.49 66.52,103.32 60.41,103.32 59.03,104.7 57.98,104.7 v2(57.54,105.14)
  BOTTOM w0.102: v2(113.47,35.8) 113.02,35.35 D2038.2 112.33,36.05 112.32,36.06 R2547.2 112.32,37.19 112.71,37.58 113.33,37.58 v1(113.74,37.98) 114.35,37.38 Q2032.3
APU_LVDS_BLON_R: length 62.8
  TOP w0.102: v1(92.04,70.41) 92.07,70.41 92.9,71.23 92.9,71.43 94.33,72.86 100.28,72.86 101.33,73.91 101.33,74.93 101.65,75.25 102.14,75.25 v1(102.73,74.66)
  IN3 w0.089: v1(102.73,74.66) 103.05,74.34 103.05,73.62 102.04,72.61 102.04,69.33 103.06,68.31 108.01,68.31 108.3,68.02 109.9,68.02 111.05,66.87 111.56,66.87 112.54,65.89 112.54,62.79 111.57,61.83 111.57,61.77 110.15,60.35 110.15,53.67 112.62,51.21 112.62,49.4 114.54,47.48 114.54,40.67 113.74,39.87 v1(113.74,39.18)
  BOTTOM w0.102: Q2032.4 114.14,38.78 v1(113.74,39.18) ; v1(92.04,70.41) 91.91,70.41 U2030.G15
APU_PROCHOT#: length 2.1
  BOTTOM w0.102: R2496.1 R2508.1 R2523.1 R2525.2
APU_PROCHOT#_R: length 14.5
  TOP w0.102: v1(90.74,75.68) 90.2,76.21 89.68,76.21 88.66,75.2 87.97,75.2 87.44,74.66 87.44,69.13 87.55,69.02 87.55,67.61 v1(87.97,67.18)
  BOTTOM w0.102: U2030.L19 88.14,67.18 v1(87.97,67.18) ; v1(90.74,75.68) 92.01,76.95 R2525.1
APU_PWRGD: length 14.6
  TOP w0.102: R77835.2 112.08,46.09 v1(111.57,45.58)
  BOTTOM w0.102: v1(111.57,45.58) 111.57,45.71 111.23,46.05 110.39,46.05 110.16,45.82 R2519.2 109.88,45.62 109.41,46.09 109.04,46.09 108.91,46.21 R2517.2 108.14,46.46 C2594.2 107.79,46.45 107.13,45.79 107.13,45.58 106.61,45.07 104.31,45.07 102.72,43.49 101.43,43.49 U2030.AW2
APU_PWRGD_D: length 1.7
  TOP w0.102: U8022.3 114.38,46.07 114.36,46.09 R77835.1 v2(113.83,46.85)
APU_PWRGD_SVID_REG: length 58.4
  TOP w0.102: v2(109.84,46.46) 110.24,46.85 111.06,46.85 112.23,48.02 118.27,48.02 118.55,47.74 119.95,47.74 120.71,46.98 v1(121.73,46.98)
  TOP w0.203: PR6037.2 151.36,55.83 v2(151.45,55.92)
  IN2 w0.089: v1(121.73,46.98) 122.81,48.06 131.32,48.06 133.16,46.21 144.33,46.21 145.73,44.82 149.94,44.82 151.76,46.63 151.76,49.17 152.58,50 152.58,54.48 151.45,55.61 v2(151.45,55.92)
  BOTTOM w0.102: R2503.1 v2(109.84,46.46) R2517.1
  BOTTOM w0.203: v2(151.45,55.92) 151.45,56.12 151.16,56.4 PR2033.2
APU_PWROK_BUF: length 5.1
  TOP w0.102: v2(115.76,46.07) U8022.4 117.13,46.07 117.37,45.83 R569.2 117.67,45.45 v2(118.04,45.07)
  BOTTOM w0.102: CN2021.10 115.24,46.6 v2(115.76,46.07)
APU_RST#: length 48.7
  TOP w0.102: v1(111.9,46.47) v2(112.37,46.94) 112.8,47.37 U8022.1
  IN3 w0.089: v1(111.9,46.47) 111.9,46.26 112.51,45.65 112.51,41.51 111.52,40.53 111.52,36.93 110.87,36.27 110.78,36.27 109.73,35.22 109.73,33.49 110.58,32.65 110.58,32.22 112.56,30.23 112.56,26.04 113.77,24.83 114.77,24.83 115.31,24.29 v2(115.43,24.29)
  BOTTOM w0.102: v1(111.9,46.47) 112.08,46.29 112.08,44.56 111.72,44.21 110.29,44.21 110.16,44.33 R2538.2 109.71,44.64 109.55,44.81 C2593.2 104.37,44.81 102.84,43.28 102.81,43.28 102.8,43.26 102.04,43.26 101.95,43.17 101.31,43.17 100.97,43.51 U2030.AW4 ; R77871.2 118.81,25.13 118.17,24.5 115.63,24.5 v2(115.43,24.29)
APU_RST_L_BUF: length 6.2
  TOP w0.102: v2(115.76,47.37) U8022.6 117.15,47.37 117.38,47.61 R568.2
  BOTTOM w0.102: CN2021.12 115.63,45.33 116.19,45.88 116.19,46.94 v2(115.76,47.37)
APU_SIC: length 190.9
  TOP w0.102: v1(93,69.68) 93.38,70.06 93.38,70.77 93.82,71.21 94.23,71.21 95.37,72.35 100.68,72.35 100.96,72.63 101.85,72.63 102.48,73.27 103.44,73.27 v2(104.46,74.28)
  IN1 w0.089: v2(17.71,32.5) 18.71,31.5 21.04,31.5 21.61,32.07 21.61,33.9 21.4,34.1 21.4,36.43 21.61,36.64 21.61,37.57 21.15,38.02 20.26,38.02 18.95,39.32 18.95,41.8 17.16,43.6 17.16,49.32 17.67,49.83 21.6,49.83 22.48,50.71 22.48,54.41 23.56,55.49 23.56,70.01 21.84,71.73 21.84,72.88 21.16,73.57 21.16,76.45 21.4,76.69 21.4,80.38 19.85,81.92 19.85,82.64 20.11,82.9 20.36,82.9 21.14,83.68 21.14,85.33 19.97,86.5 19.97,90.34 24.99,95.36 36.39,95.36 v2(37.79,96.76)
  IN2 w0.089: v2(37.79,96.76) 37.92,96.89 49.08,96.89 50.1,95.87 50.61,95.87 51.54,96.8 52.57,96.8 52.96,97.19 52.96,97.82 53.8,98.67 55.42,98.67 56.24,97.84 57.66,97.84 58.89,96.61 61.69,96.61 62.74,95.56 62.74,94.66 65.09,92.32 65.73,92.32 68.13,89.91 68.13,88.62 68.69,88.06 70.61,88.06 72.29,86.38 79,86.38 81.86,83.52 81.86,81.86 84.87,78.85 85.25,78.85 87.69,76.41 87.69,75.75 88.15,75.29 88.37,75.29 90.65,73.01 91.9,73.01 93.15,71.76 93.15,69.83 v1(93,69.68)
  BOTTOM w0.102: U2030.H14 92.53,69.21 v1(93,69.68) ; v2(17.71,32.5) 17.76,32.46 U5400.8 ; R2527.2 110.93,75.68 110.8,75.54 Q2031.4 109.29,75.54 108.65,76.19 105.98,76.19 104.46,74.66 v2(104.46,74.28)
APU_SID: length 191.9
  TOP w0.102: v2(104.46,73.65) v2(103.82,73.01) 102.55,73.01 101.94,72.4 101.05,72.4 100.77,72.12 95.46,72.12 94.32,70.98 93.91,70.98 93.61,70.67 93.61,69.66 93,69.05 v1(93,68.79)
  IN1 w0.089: v2(18.41,32.5) 19.21,31.69 20.96,31.69 21.42,32.15 21.42,33.77 21.14,34.04 21.14,36.56 21.42,36.84 21.42,37.49 21.07,37.83 20.18,37.83 18.73,39.28 18.73,41.64 16.95,43.42 16.95,49.39 17.59,50.02 21.52,50.02 22.29,50.79 22.29,54.48 23.37,55.56 23.37,69.93 21.65,71.65 21.65,72.76 20.97,73.44 20.97,76.53 21.21,76.77 21.21,80.3 19.66,81.84 19.66,82.72 20.03,83.09 20.28,83.09 20.95,83.76 20.95,85.25 19.78,86.42 19.78,90.42 24.91,95.55 36.31,95.55 37.15,96.39 v2(37.15,96.76)
  IN2 w0.089: v2(37.15,96.76) 37.54,97.16 38.4,97.16 38.48,97.08 49.16,97.08 50.18,96.06 50.53,96.06 51.46,96.99 52.49,96.99 52.77,97.27 52.77,97.9 53.81,98.94 55.41,98.94 56.32,98.03 57.74,98.03 58.97,96.8 61.8,96.8 62.93,95.67 62.93,94.74 65.16,92.51 65.81,92.51 68.32,89.99 68.32,88.7 68.77,88.25 70.69,88.25 72.37,86.57 79.08,86.57 82.08,83.58 82.08,82.04 85.07,79.05 85.33,79.05 87.88,76.49 87.88,75.84 88.24,75.48 88.45,75.48 90.67,73.27 92.01,73.27 93.41,71.87 93.41,69.2 v1(93,68.79)
  BOTTOM w0.102: U2030.J14 92.59,68.41 92.97,68.79 v1(93,68.79) ; v2(104.46,73.65) 104.46,72.12 104.58,72 104.96,72 105.15,72.19 105.15,74.34 105.25,74.44 R2499.2 107.73,74.44 107.93,74.24 Q2031.1 ; U5400.7 v2(18.41,32.5)
APU_SPI_CLK: length 97.3
  TOP w0.102: R403.1 121.25,21.7 120.58,22.36 120.58,22.93 119.77,23.75 116,23.75 115.12,22.87 112.99,22.87 110.06,19.94 110.06,19.68 109.03,18.66 105.22,18.66 103.95,19.93 99.12,19.93 97.57,21.47 v2(93.97,21.47)
  IN1 w0.102: v1(104.79,36.36) 103.82,37.32 100.14,37.32 98.54,35.72 98.54,34.92 98.11,34.49 98.11,31.91 97.47,31.27 97.47,29.7 97.03,29.27 97.03,26.91 94.74,24.62 93.51,24.62 92.73,23.84 90.49,23.84 88.86,22.21 v2(80.33,22.21)
  BOTTOM w0.102: v2(93.97,21.47) 93.53,21.91 92.98,21.91 92.79,21.72 92.79,21.4 92.48,21.09 92.04,21.09 91.37,21.75 89.66,21.75 87.86,23.56 81.21,23.56 81.08,23.68 R6533.1 80.71,24.12 80.47,23.88 C2792.1 80.47,22.36 v2(80.33,22.21) ; R2403.1 106.36,35.14 106.11,35.39 R2308.2 105.7,35.39 105.34,35.04 R2430.1 R2310.1 105.19,35.96 v1(104.79,36.36) 103.32,37.83 102.76,37.83 101.52,39.07 100.89,39.07 100.05,39.91 99.58,39.91 99.22,40.28 99.22,40.47 98.51,41.17 U2030.BB7
APU_SPI_CLK_R: length 1.7
  BOTTOM w0.102: R6533.2 U2038.6
APU_SPI_CLK_TPM: length 1.5
  TOP w0.102: R403.2 122.11,21.7 122.6,21.21 U15.19
APU_SPI_CS0#: length 40.2
  IN1 w0.102: v1(102.55,32.65) 101.88,33.31 100.91,33.31 100.38,32.78 100.38,27.28 98.67,25.57 98.67,25.39 99.51,24.56 99.51,24.38 99.24,24.11 99.1,24.11 98.22,24.98 98.08,24.98 97.79,24.69 97.79,24.55 98.6,23.74 98.6,23.6 98.31,23.31 98.17,23.31 97.36,24.12 97.22,24.12 96.93,23.83 96.93,23.69 97.49,23.13 97.49,22.99 97.2,22.7 97.05,22.7 96.5,23.25 96.36,23.25 95.79,22.69 94.26,22.69 v1(94.16,22.59)
  BOTTOM w0.089: U2030.BC9 97.01,40.51 97.12,40.4
  BOTTOM w0.102: v1(94.16,22.59) 94.16,22.6 94.16,26.41 93.91,26.66 R6532.2 93.43,27.14 93.25,27.32 R6544.2 ; 97.12,40.4 97.12,39.99 99.84,37.27 100.98,37.27 101.81,36.44 v2(101.81,36.11) 102.01,35.91 R2425.1 102.01,34.94 102.14,34.81 102.14,33.05 v1(102.55,32.65)
APU_SPI_CS0#_R: length 1.6
  BOTTOM w0.102: R6532.1 U2038.1
APU_SPI_HOLD#: length 44.3
  IN1 w0.102: v2(79.06,22.21) 79.46,21.8 90.49,21.8 92.14,23.46 92.81,23.46 93.58,24.22 94.93,24.22 97.37,26.65 97.37,29.13 97.88,29.64 97.88,31.1 98.51,31.74 98.51,34.43 98.92,34.83 v1(98.92,35.55)
  BOTTOM w0.089: U2030.BC10 96.02,41.1 96.02,40.5 95.92,40.4
  BOTTOM w0.102: v2(79.06,22.21) 79.06,23.23 80.96,25.13 R6535.1 81.24,24.88 81.5,24.62 82.23,24.62 82.58,24.98 82.58,25.26 82.71,25.39 U2038.7 ; v1(98.92,35.55) 98.85,35.62 R6543.1 98.85,36.87 98.24,37.48 97.69,37.48 97.47,37.7 97.47,38.42 95.92,39.97 95.92,40.4
APU_SPI_SI: length 75
  TOP w0.102: R458.1 R448.1 120.87,16.52 119.82,15.48 114.49,15.48 113.47,16.5 113.47,17.26 113.98,17.77 113.98,19.42 113.47,19.93 111.82,19.93 109.84,17.94 104.99,17.94 103.78,19.16 98.23,19.16 v2(96.96,20.43) 96.68,20.71 93.47,20.71 92.9,21.28 92.9,21.92 v1(93.57,22.59)
  IN1 w0.102: v1(102.55,33.23) 102.55,33.51 102.42,33.64 100.77,33.64 100.05,32.91 100.05,31.01 99.88,30.85 99.25,30.85 99.02,30.62 99.02,30.34 99.12,30.24 99.91,30.24 100.01,30.14 100.01,29.73 99.91,29.63 99.17,29.63 99.02,29.48 99.02,29.15 99.12,29.04 99.91,29.04 100.01,28.94 100.01,28.54 99.91,28.43 99.2,28.43 99.02,28.26 99.02,27.8 99.15,27.67 99.73,27.67 99.85,27.55 99.85,27.25 99.57,26.96 99.25,26.96 99.12,26.83 99.12,26.52 95.68,23.07 93.89,23.07 93.57,22.76 v1(93.57,22.59)
  BOTTOM w0.089: U2030.BA9 97.01,41.55 97.32,41.24 97.32,40.97 97.21,40.86 97.21,40.59 97.35,40.45
  BOTTOM w0.102: R6536.1 93.66,25.64 93.83,25.47 93.83,23.4 93.57,23.14 v1(93.57,22.59) ; 97.35,40.45 97.35,40.23 98.74,38.85 99.04,38.85 100.28,37.6 101.12,37.6 102.42,36.3 102.42,35.98 102.58,35.83 R2445.1 102.58,34.53 R6540.1 102.58,34.28 102.58,33.26 v1(102.55,33.23)
APU_SPI_SI_R: length 1.7
  BOTTOM w0.102: U2038.2 92.01,25.39 92.26,25.64 R6536.2
APU_SPI_SI_TPM: length 2.6
  TOP w0.102: R458.2 122.08,16.98 122.49,17.39 v2(122.49,17.77) 122.49,18.53 122.67,18.71 U15.24
APU_SPI_SO: length 88.7
  TOP w0.102: v2(93.33,21.47) 93.76,21.04 97.24,21.04 v2(98.36,19.93) 98.69,19.59 103.81,19.59 105.13,18.27 109.61,18.27 113.55,22.21 115.41,22.21 116.29,23.09 119.49,23.09 119.92,22.66 119.92,20.81 120.36,20.38 R417.1
  IN1 w0.102: v1(100.65,35.11) 100.07,34.54 100.07,34.08 98.92,32.93 98.92,31.57 98.28,30.94 98.28,29.58 97.7,28.99 97.7,26.45 95.08,23.84 93.66,23.84 92.9,23.07 92.26,23.07 90.66,21.47 79.16,21.47 v2(78.42,22.21)
  BOTTOM w0.089: U2030.BB10 96.64,41.03 96.82,40.85 96.82,40.43 96.89,40.36 96.89,39.93
  BOTTOM w0.102: v2(78.42,22.21) 78.85,21.78 80.51,21.78 81.06,22.33 R6534.1 88.62,22.33 89.53,21.42 91.24,21.42 91.9,20.76 92.62,20.76 v2(93.33,21.47) ; 96.89,39.93 96.89,39.76 99.71,36.94 99.88,36.94 100.65,36.18 R6541.1 v1(100.65,35.11)
APU_SPI_SO_R: length 1.8
  BOTTOM w0.102: U2038.5 82.61,22.85 82.35,23.11 R6534.2
APU_SPI_SO_TPM: length 2.5
  TOP w0.102: R417.2 121.06,20.43 122.36,20.43 122.59,20.21 U15.21
APU_SPI_WP: length 28.2
  IN1 w0.102: v1(92.99,22.59) 92.99,22.7 93.77,23.48 95.54,23.48 98.69,26.63 98.69,30.77 99.27,31.35 99.27,32.65 100.48,33.85 100.48,34.36 v1(100.65,34.53)
  BOTTOM w0.089: U2030.BA10 96.01,41.55 96.32,41.24 96.32,40.97 96.21,40.86 96.21,40.42 96.13,40.33 96.13,40.05 96.37,39.8
  BOTTOM w0.102: R6538.1 93.42,23.87 93,23.45 R6550.2 93,22.6 v1(92.99,22.59) ; 96.37,39.8 96.57,39.61 96.64,39.61 98.23,38.02 98.23,37.95 99.57,36.61 99.75,36.61 99.93,36.42 R6542.1 100.18,36.18 100.32,36.04 100.32,35.41 100.24,35.33 100.24,34.94 v1(100.65,34.53)
APU_SPI_WP_R: length 1.8
  BOTTOM w0.102: U2038.3 91.88,24.12 92.39,24.62 R6538.2
APU_SVC: length 86.3
  TOP w0.102: v2(149.69,56.8) 150.12,56.8 150.13,56.82 150.66,56.82 150.76,56.71 PR6039.2
  IN3 w0.102: v2(113.85,76.06) 113.85,78.37 113.96,78.47 114.36,78.47 114.49,78.35 114.49,78.09 114.97,77.61 114.97,77.18 114.49,76.69 114.49,76.48 119.16,71.81 140.08,71.81 140.75,71.14 140.75,63.21 142.27,61.7 145.53,61.7 146.72,60.51 146.72,58.76 147.87,57.61 148.87,57.61 v2(149.69,56.8)
  BOTTOM w0.102: v2(149.69,56.8) 149.69,56.79 150.16,56.32 PC9173.2 ; v2(113.85,76.06) 113.42,76.06 113.32,75.96 113.32,74.26 113.22,74.15 112.96,74.15 112.83,74.28 112.83,75.86 112.63,76.06 109.24,76.06 108.53,76.77 108.53,77.37 108.31,77.58 107.38,77.58 107.12,77.33 105.85,77.33 103.69,75.17 103.44,75.17 103.31,75.3 103.31,75.55 103.95,76.19 103.95,76.69 103.67,76.97 103.41,76.97 103.31,76.87 103.31,76.29 103.19,76.17 102.91,76.17 102.81,76.27 102.81,76.87 102.71,76.97 100.87,76.97 100.38,77.46 99.95,77.46 98.8,76.31 97.22,76.31 97.09,76.44 97.09,76.92 96.81,77.2 R2515.1 R2512.1 96.17,78.35 96.07,78.44 R2505.1
APU_SVD: length 82.3
  TOP w0.102: PR6041.2 150.76,57.46 150.56,57.67 v2(149.63,57.67)
  IN3 w0.102: v2(115.18,76.57) 115.45,76.84 115.45,77.28 115.57,77.39 116.19,77.39 117.36,76.22 117.36,74.08 119.29,72.14 140.21,72.14 141.08,71.27 141.08,63.35 142.4,62.03 145.67,62.03 147.05,60.65 147.05,58.9 148.01,57.94 149.35,57.94 v2(149.63,57.67)
  BOTTOM w0.102: PC9174.2 149.2,56.97 149.63,57.39 v2(149.63,57.67) ; v2(115.18,76.57) 112.67,76.57 112.53,76.43 110.86,76.43 110.35,76.94 110.35,77.45 109.67,78.13 107.38,78.13 106.91,78.6 104.58,78.6 103.31,79.87 101.16,79.87 100.84,79.55 100.84,79.41 100.41,78.98 100.41,78.39 98.84,76.82 98.01,76.82 97.7,77.13 97.36,77.13 96.56,77.92 96.56,79.39 96.2,79.74 94.68,79.74 94.37,79.44 94.37,79.11 94.72,78.75 R2502.1 94.93,78.48 95.16,78.26 R2513.1 R2516.1
APU_SVT: length 84.8
  TOP w0.102: v2(149.67,58.3) 149.65,58.28 149.65,58.28 149.4,58.03 PR6044.2
  IN3 w0.102: v2(149.67,58.3) 149.64,58.27 148.14,58.27 147.38,59.04 147.38,60.78 145.81,62.36 142.54,62.36 141.41,63.49 141.41,71.41 140.35,72.47 119.43,72.47 117.69,74.21 117.69,76.36 115.78,78.27 115.07,78.27 114.48,78.87 v2(114.48,79.11)
  BOTTOM w0.102: R2514.1 R2511.1 94.14,78.12 93.84,78.42 93.84,79.41 94.5,80.07 96.06,80.07 96.34,80.07 96.89,79.52 96.89,78.14 97.57,77.46 97.84,77.46 98.15,77.15 98.7,77.15 100.08,78.52 100.08,79.12 100.51,79.55 100.51,79.68 101.03,80.2 102.35,80.2 102.93,80.78 v2(102.93,81.52) 102.93,81.78 103.55,82.4 104.23,82.4 105.73,80.91 105.73,80.25 106.59,79.38 109.37,79.38 110,78.76 112.32,78.76 112.67,79.11 v2(114.48,79.11) ; v2(149.67,58.3) 149.65,58.3 149.17,57.82 149.17,57.42 148.87,57.12 148.87,56.72 148.46,56.31 PC9175.2
APU_TCK: length 15.9
  TOP w0.102: v1(103.39,45.71) 107.2,49.52 110.4,49.52 111.69,50.81 v1(112.05,50.81)
  BOTTOM w0.102: CN2021.2 112.33,51.68 111.8,51.14 R12314.2 111.62,50.89 111.69,50.81 v1(112.05,50.81) ; v1(103.39,45.71) 103.39,45.66 102.68,44.94 101.88,44.94 U2030.AU1
APU_TDI: length 13.6
  BOTTOM w0.102: U2030.AU2 101.42,44.52 101.74,44.52 101.91,44.68 102.94,44.68 104.49,46.23 106.07,46.23 106.96,47.12 108,47.12 111.04,47.12 C926.1 111.57,47.39 111.72,47.54 111.72,47.99 111.59,48.12 111.34,48.12 111.22,48.24 R12315.2 R626.2
APU_TDO: length 14.9
  BOTTOM w0.102: CN2021.8 112.46,47.87 111.48,46.89 107.06,46.89 106.17,46 104.59,46 103.04,44.45 101.96,44.45 101.83,44.31 101.66,44.31 101.54,44.19 101.28,44.19 100.96,44.51 U2030.AU4
APU_TEST4: length 1.3
  TOP w0.102: TP2051.1 93.03,47.51 v1(93.03,47.45)
  BOTTOM w0.102: U2030.AP14 92.79,47.21 v1(93.03,47.45)
APU_TEST5: length 1.6
  TOP w0.102: v1(93.03,48.42) 93.03,49.08 TP2052.1
  BOTTOM w0.102: U2030.AN14 92.93,48.42 v1(93.03,48.42)
APU_TEST14: length 8.8
  BOTTOM w0.102: R2551.1 92.67,76.21 90.11,73.65 90.11,73.27 90.32,73.06 90.32,72.76 90.19,72.63 90.19,72.38 90.37,72.2 90.37,71.85 90.14,71.62 90.14,71.24 89.89,70.98 89.89,70.38 U2030.G18
APU_TEST15: length 10.8
  TOP w0.102: v1(89.85,75.81) 89.01,74.97 88.25,74.97 87.68,74.39 87.68,69.22 87.96,68.94 v1(87.96,68.75)
  BOTTOM w0.102: v1(87.96,68.75) 88.03,68.75 88.5,69.21 U2030.H19 ; v1(89.85,75.81) 89.85,75.93 90.49,76.57 R2543.1
APU_TEST16: length 9
  BOTTOM w0.102: R2544.1 92.52,77.96 92.39,77.84 92.39,76.26 89.86,73.73 89.86,73.22 89.68,73.04 89.68,72.78 89.89,72.58 89.89,72.43 89.63,72.18 89.63,71.87 89.86,71.64 89.86,71.29 89.51,70.94 U2030.F18
APU_TEST17: length 8.8
  TOP w0.102: v1(90.21,75.35) 90.21,75.21 87.91,72.9 87.91,70.55 v1(88.08,70.37)
  BOTTOM w0.102: R2545.1 91.25,76.76 90.31,75.83 90.31,75.45 v1(90.21,75.35) ; v1(88.08,70.37) 88.42,70.71 U2030.F19
APU_TEST18: length 2.4
  BOTTOM w0.102: 113.85,40.25 112.2,40.25 111.82,39.86 TP8548.1
APU_TEST19: length 3
  BOTTOM w0.102: CN2021.18 112.46,41.52 111.69,40.75 TP8547.1
APU_TEST31: length 21.8
  IN1 w0.089: v2(88.45,74.54) 88.96,74.03 88.96,69.46 88.58,69.07 88.58,68.69 88.2,68.31 87.56,68.31 87.06,67.8 86.04,67.8 84.9,66.66 84.9,64.76 83.75,63.61 v1(83.75,61.45)
  BOTTOM w0.102: v2(88.45,74.54) 89.09,75.17 89.09,76.47 88.86,76.69 R2521.1 R2520.1 ; U2030.W24 84.11,60.18 83.75,60.53 v1(83.75,61.45)
APU_TEST41: length 10.9
  TOP w0.102: v1(96.05,46.35) 95.64,45.94 95.64,44.99 96,44.64 96.18,44.64 96.42,44.4 96.42,43.69 98.08,42.02 100.52,42.02 TP2053.1
  BOTTOM w0.102: U2030.AR11 95.99,46.41 v1(96.05,46.35)
APU_TEST470: length 1.3
  TOP w0.102: TP2054.1 86.52,52.82 v1(86.91,52.43)
  BOTTOM w0.102: U2030.AJ21 86.91,52.41 v1(86.91,52.43)
APU_TEST471: length 1.5
  TOP w0.102: v1(86.04,50.54) 85.66,50.91 TP2055.1
  BOTTOM w0.102: U2030.AK21 v1(86.04,50.54)
APU_THERMTRIP#: length 46.5
  TOP w0.102: v1(84.29,29.35) 84.34,29.35 84.96,28.73 85.29,28.73 88.56,25.46 96.81,25.46 97.26,25.91 98.83,25.91 98.97,26.05 101.69,26.05 102.77,27.13 Q14.1
  IN3 w0.089: v1(85.83,31.62) 86.08,31.87 86.97,31.87 87.87,32.76 88.41,32.76 88.83,33.19 88.83,33.73 89.56,34.45 89.56,34.67 90.74,35.85 90.74,39.61 92.39,41.26 92.39,46.09 v1(90.89,47.59)
  BOTTOM w0.102: v1(85.83,31.62) 85.69,31.48 R2526.2 84.74,31.05 84.95,30.84 84.95,29.96 84.34,29.35 v1(84.29,29.35) ; v1(90.89,47.59) U2030.AP16
APU_TMS: length 16.1
  TOP w0.102: v1(111.95,49.82) 111.95,49.39 111.16,48.6 106.97,48.6 103.67,45.3 102.29,45.3 v1(102.24,45.35)
  BOTTOM w0.102: v1(111.95,49.82) 111.67,50.1 R12313.2 CN2021.4 ; v1(102.24,45.35) 101.69,45.35 101.35,45.01 U2030.AU3
APU_TRST#: length 25.9
  TOP w0.102: v1(106.49,45.58) 108.02,47.12 110.85,47.12 111.98,48.25 118.36,48.25 118.65,47.97 120.36,47.97 v2(120.58,47.74) 120.74,47.59 v2(121.73,47.59)
  BOTTOM w0.102: U2030.AV3 101.19,43.83 101.55,43.83 101.69,43.69 102.6,43.69 104.49,45.58 v1(106.49,45.58) ; v2(121.73,47.59) 121.34,47.97 121.34,48.25 121.06,48.53 R12316.1 C869.1 R554.2
APU_VDDIO_MEM_FB_H: length 0.7
  TOP w0.152: PR9301.2 TP9089.1
APU_VDDP_RUN_FB_H: length 53.4
  TOP w0.127: v1(95.7,47.62) 96.07,47.99 98.11,47.99 98.74,48.63 103.2,48.63 105.67,51.1 108.41,51.1 110.15,52.83 112.31,52.83 113.76,51.38 116.18,51.38 TP9091.1 117.64,49.92 121.5,49.92 121.61,50.03 v1(121.73,50.03)
  IN1 w0.089: v1(121.73,50.03) 121.22,49.52 121.22,43.29 122.36,42.15 122.36,37.83 125.06,35.14 130.11,35.14 v2(130.39,35.42)
  BOTTOM w0.102: v2(130.39,35.42) 129.91,35.9 PR2012.1
  BOTTOM w0.127: v1(95.7,47.62) U2030.AN11
APU_VDDP_RUN_FB_L: length 26.8
  TOP w0.127: v1(95.69,49.39) 96.18,49.39 TP9092.1 96.57,49.01 103.07,49.01 108.14,54.08 111.57,54.08 113.91,51.74 116.97,51.74 117.95,50.76 PR9296.1
  BOTTOM w0.127: v1(95.69,49.39) U2030.AM11
AUX_ZVSS: length 4.6
  BOTTOM w0.102: U2029.BA12 97.2,98.77 96.93,98.51 R2673.1
BAT-V: length 25.6
  TOP w0.457: PD4.1 127.87,33.52 v2(128.1,33.75)
  IN3 w0.508: v2(128.1,33.75) 128.72,33.13 128.72,29.97 125.96,27.21 121.77,27.21 121.09,26.52 119.24,26.52 v2(118.63,25.91)
  BOTTOM w0.152: PR266.2 111.94,25.99 112.13,26.18 113.7,26.18 114.11,25.77 PR271.1
  BOTTOM w0.508: 113.85,25.01 118.02,25.01 118.63,25.61 v2(118.63,25.91)
BATLED0#: length 72.2
  TOP w0.102: v2(175.58,19.01) 175.58,19.37 174.08,20.86 170.65,20.86 169.34,19.56 167.94,19.56 166.89,18.51 166.89,17.46 166.38,16.96 U13.29
  IN3 w0.089: v2(175.58,19.01) 176.31,18.27 183.56,18.27 184.77,19.48 187.7,19.48 188.75,20.52 189.46,20.52 194.48,15.5 204.07,15.5 205.24,16.67 205.77,16.67 207.52,18.42 211.14,18.42 211.74,19.02 212.88,19.02 213.15,19.29 213.15,22 212.2,22.96 212.2,25.12 213.89,26.82 213.89,29.79 215,30.9 v2(215,32.37)
  BOTTOM w0.102: CN6.21 214.47,32.9 v2(215,32.37)
BATLED1#: length 75.5
  TOP w0.102: v2(168.64,20.48) 168.17,20.02 167.75,20.02 166.29,18.56 U13.25
  IN1 w0.089: v2(215.63,32.37) 215.63,26.09 213.23,23.69 213.23,18.73 212.47,17.97 212.47,16.32 211.12,14.97 209.87,14.97 206.82,11.92 200.23,11.92 199.72,12.43 194.68,12.43 193.51,13.61 193.51,15.84 191.44,17.9 186.35,17.9 185.31,16.86 177.16,16.86 174.11,19.91 172.42,19.91 172.22,20.1 171.18,20.1 171,19.93 169.22,19.93 169.09,20.05 169.07,20.05 v2(168.64,20.48)
  BOTTOM w0.102: v2(215.63,32.37) 214.61,33.4 CN6.20
BI: length 121.1
  IN2 w0.089: v2(24.95,44.44) 25.7,43.69 25.7,42.93 26.1,42.53 26.1,41.51 27.65,39.96 27.65,30.39 27.23,29.97 27.23,26.33 27.99,25.57 30.41,25.57 31.42,24.56 38.5,24.56 39.29,23.78 43.64,23.78 44.11,24.24 50.25,24.24 53.46,21.04 67.71,21.04 68.22,20.53 80.44,20.53 82.37,22.47 88.41,22.47 91.34,21.25 91.98,20.61 94.51,20.61 94.7,20.8 97.21,20.8 v2(98.87,22.47)
  BOTTOM w0.203: v2(24.95,44.44) 25.33,44.44 25.84,44.94 25.84,56.37 24.83,57.39 R622.2 19.46,57.74 19.75,58.03 20.89,58.03 21.25,58.39 SW3.1 SW3.2
BIT_CLK_AUDIO: length 126.2
  IN1 w0.089: v2(198.82,26.25) 198.37,26.25 198,26.62 196.49,26.62 196.2,26.33 191.68,26.33 190.89,25.54 190.89,24.64 190.73,24.47 v2(190.73,24.46)
  IN3 w0.089: v2(190.73,24.46) 190.79,24.4 190.79,23.65 187.76,20.62 183.01,20.62 182.06,21.57 178.08,21.57 177.66,21.99 171.57,21.99 170.15,23.41 168.03,23.41 167.83,23.61 166.52,23.61 164.87,25.26 163.62,25.26 162.71,26.17 158.88,26.17 158.4,26.66 156.65,26.66 156.25,26.25 155.34,26.25 154.9,26.7 146.53,26.7 145.27,25.44 122.51,25.44 121.21,24.14 116.15,24.14 114.96,25.33 114.09,25.33 113.14,26.27 113.14,30.52 111.05,32.61 111.05,32.84 110.2,33.69 110.2,35.02 110.98,35.8 111.06,35.8 111.99,36.73 111.99,40.33 112.98,41.32 112.98,45.95 111.82,47.1 109.53,47.1 v1(108.7,47.94)
  BOTTOM w0.102: U30.6 199.03,26.46 v2(198.82,26.25) 197.94,25.37 C667.2 ; R2426.2 109.03,48.37 109.3,48.1 C2580.2 108.77,47.87 v1(108.7,47.94)
BL#: length 3.8
  TOP w0.102: v2(56.45,100.57) R24.1 Q4.3 57.23,102.23 57.11,102.35 56.68,102.35 56.58,102.25 Q4.2
BL_ON: length 8.5
  TOP w0.102: Q3.3 56.7,109.33 56.61,109.23 R13.1 56.32,108.7 v2(56.07,108.44) ; D1.2 55.18,103.75 55.65,103.28 Q4.6 v2(55.93,104.89) 55.93,105.64 56.2,105.9 v2(56.2,106.29)
  BOTTOM w0.102: v2(56.2,106.29) 56.22,106.31 CN2.26 56.22,108.29 v2(56.07,108.44)
BOARD_ID0: length 9
  BOTTOM w0.089: U2030.BC18 89,41.1 89,40.48 89.09,40.39 89.09,39.62 89.39,39.32
  BOTTOM w0.102: 89.39,39.32 89.39,35.87 88.71,35.18 88.71,34.82 88.45,34.55 87.72,34.55 87.59,34.43 R2357.2 R2376.1
BOARD_ID1: length 10
  BOTTOM w0.089: 90.95,39.92 90.95,40.29 90.82,40.42 90.82,40.84 90.58,41.08 90.49,41.08 90.01,41.55 U2030.BA17
  BOTTOM w0.102: 90.95,39.92 90.87,39.83 90.87,37.96 91.12,37.71 91.12,36.95 90.71,36.54 90.71,36.2 90.87,36.04 90.87,35.57 90.46,35.16 90.28,35.16 89.47,34.35 R2359.2 89.19,34.25 88.93,33.99 R2358.1
BOARD_ID2: length 7.9
  BOTTOM w0.089: U2030.BC16 91.02,41.1 91.02,40.5 91.15,40.38 91.15,39.79
  BOTTOM w0.102: R2360.1 91.17,33.77 91.53,34.12 91.53,35.73 R2361.2 91.6,36.59 91.45,36.74 91.45,37.88 91.12,38.21 91.12,39.77 91.15,39.79
BOARD_ID3: length 11.8
  BOTTOM w0.089: 88.85,39.59 88.85,40.37 88.81,40.4 88.81,40.85 88.51,41.15 U2030.BB19
  BOTTOM w0.102: 88.85,39.59 89.17,39.27 89.17,35.96 88.57,35.37 87.51,35.37 87.31,35.17 86.2,35.17 86.07,35.04 R2363.2 86.07,34.64 86.7,34.01 R2362.1
BOARD_ID4: length 109.8
  TOP w0.102: v1(91.08,42.39) 91.96,41.51 91.96,39.56 91.27,38.87 91.27,37.73 91.52,37.48 91.52,35.18 v1(91.12,34.78)
  IN3 w0.089: v1(91.08,42.39) 91.5,42.81 91.5,43.67 91.12,44.06 90.99,44.06 90.23,44.82 90.23,49.77 90.96,50.5 90.96,52.58 90.32,53.23 90.32,58.27 88.5,60.09 88.5,62.85 88.34,63.01 87.28,63.01 86.86,63.43 86.86,65.58 87.55,66.26 87.55,68.93 87.69,69.07 87.69,71.87 89.42,73.6 89.42,77.15 90.26,78 90.26,80.39 91.83,81.95 91.83,87.52 91.44,87.91 86.61,87.91 85.26,89.27 82.89,89.27 81.38,90.77 71.3,90.77 70.63,91.43 68.7,91.43 66.57,93.57 66.13,93.57 63.57,96.13 v2(63.18,96.13)
  BOTTOM w0.102: R2364.1 89.37,33.67 89.58,33.88 90.17,33.88 90.31,34.02 90.31,34.03 90.56,34.28 R2365.2 90.77,34.43 v1(91.12,34.78) ; R517.1 56.15,104.56 56.2,104.51 C541.2 56.63,103.53 56.63,99.25 57.08,98.79 57.08,98.28 57.33,98.04 57.77,98.04 58.05,98.31 58.05,98.74 58.23,98.92 59.5,98.92 v2(60.26,98.16) 61.02,97.4 61.53,97.4 62.8,96.13 v2(63.18,96.13) ; U2030.BB16 90.51,41.92 90.98,42.39 v1(91.08,42.39)
BOARD_ID5: length 30.4
  TOP w0.102: v1(96.61,51.55) 96.61,51.52 96.96,51.17 97.65,51.17 97.7,51.12 103.96,51.12 107.85,55 111.8,55 114.16,52.64 118.3,52.64 118.58,52.92 120.27,52.92 120.58,52.61 121.05,52.61 121.34,52.32 122.22,52.32 122.33,52.21 R2350.2 R2349.1
  BOTTOM w0.102: U2030.AK9 96.61,51.31 v1(96.61,51.55)
BOARD_ID6: length 121.1
  TOP w0.102: v2(60.64,109.83) C532.2 59.7,110.14 R516.1 ; R2351.1 121.12,52.03 120.87,52.28 R2352.2 120.05,52.69 118.7,52.69 118.43,52.41 114.04,52.41 111.68,54.77 107.94,54.77 104.06,50.89 97.62,50.89 v1(97.24,50.51)
  IN2 w0.089: v2(71.47,92.44) 71.47,96.19 67.75,99.91 67.75,102.6 63.18,107.17 63.18,108.57 61.92,109.83 v2(60.64,109.83)
  IN3 w0.089: v2(71.47,92.44) 71.91,92.01 78.1,92.01 78.94,91.17 81.53,91.17 83.05,89.65 85.42,89.65 86.77,88.3 91.6,88.3 93.02,86.87 93.02,82.15 92.12,81.25 92.12,79.56 92.41,79.27 92.41,73.78 88.66,70.03 88.66,65.83 88.84,65.65 88.84,63.68 90.1,62.42 90.1,59.29 90.7,58.69 90.7,53.91 91.23,53.38 91.49,53.38 91.71,53.16 91.71,52.88 91.96,52.63 92.22,52.63 92.49,52.36 92.49,51.3 93.07,50.72 97.03,50.72 v1(97.24,50.51)
  BOTTOM w0.102: v1(97.24,50.51) 96.91,50.18 U2030.AL9
BOARD_ID7: length 27.1
  TOP w0.102: v1(119.79,52.28) 119.69,52.18 113.95,52.18 111.66,54.47 108.01,54.47 104.2,50.66 100.9,50.66 100.26,50.02 99.38,50.02 v1(98.87,49.52)
  BOTTOM w0.102: R2355.2 120.81,51.45 120.71,51.55 120.46,51.55 120.36,51.65 R2354.1 120,52.28 v1(119.79,52.28) ; v1(98.87,49.52) 98.49,49.52 97.99,50.01 U2030.AL8
BOARD_ID8: length 14.6
  TOP w0.102: R77862.1 104.61,41.23 104.58,41.26 R77863.2 104.3,41.54 103.69,42.15 101.92,42.15 101.53,42.53 99.88,42.53 98.87,43.55 97.85,43.55 97.27,44.13 96.9,44.13 96.64,44.39 96.64,44.57 96.46,44.76 96.46,46.52 96.22,46.76 95.83,46.76 v1(95.06,45.99)
  BOTTOM w0.102: v1(95.06,45.99) 94.68,45.61 U2030.AT12
BOARD_ID9: length 7.5
  BOTTOM w0.089: U2030.BA11 95.01,41.56 95.31,41.26 95.31,40.96 95.2,40.85 95.2,40.49 95.27,40.42 95.27,39.65 95.64,39.28
  BOTTOM w0.102: R77873.2 97.44,36.69 96.71,37.43 ; R77872.1 96.56,37.43 96.71,37.43 ; 96.71,37.43 96.71,38.21 95.64,39.28
BP_0: length 15.6
  TOP w0.102: v2(112.55,113.11) 112.76,113.32 112.76,114.9 116.72,118.86 117.65,118.86 119.31,120.52 119.31,120.75 119.57,121.01 119.57,123.53 TP8002.1 119.48,123.98 119.72,124.22 R2226.2
  BOTTOM w0.102: U2029.AA38 112.37,112.92 v2(112.55,113.11)
BP_1: length 13.4
  TOP w0.102: R2231.2 119.85,121.24 120.03,121.07 TP8001.1 119.75,120.64 112.99,113.88 112.99,112.76 v1(112.56,112.33)
  BOTTOM w0.102: v1(112.56,112.33) 112.35,112.12 U2029.AA37
BRIGHT: length 1.5
  TOP w0.102: R26.1 R21.2 R25.2
BT_EN: length 10.1
  TOP w0.102: R402.2 186.09,24.02 186.24,23.86 R825.1 187.67,23.45 188.28,22.85 188.28,21.14 188.41,21.01 188.41,19.36 189.01,18.75 189.01,18.55 v2(189.24,18.32)
  BOTTOM w0.102: CN9.54 189.69,17.88 v2(189.24,18.32)
C1: length 2.2
  TOP w0.102: U2032.12 26.73,18.15 26.63,18.05 R817.2 R824.1
C2: length 2.2
  TOP w0.102: R785.2 R775.1 31.08,17.86 30.8,18.15 U2032.6
C_IN_CLK: length 9.3
  IN3 w0.089: v2(12.56,76.22) 12.85,75.93 13.36,75.93 13.58,76.15 13.58,76.6 13.19,77 12.72,77 12.39,76.67 11.78,76.67 11.6,76.5 CN4.10
  BOTTOM w0.102: R2706.1 16.6,76.2 16.44,76.04 16.18,76.04 16.07,76.16 R589.1 15.53,76.16 15.29,75.92 14.36,75.92 14.24,76.05 14.24,76.19 14.12,76.31 D25.2 13.78,76.14 13.65,76.01 12.77,76.01 v2(12.56,76.22)
C_IN_CLK#: length 9.3
  IN3 w0.089: v2(12.56,75.58) 12.7,75.72 13.44,75.72 13.79,76.07 13.79,76.69 13.27,77.2 12.63,77.2 12.31,76.88 11.92,76.88 CN4.12
  BOTTOM w0.102: v2(12.56,75.58) 12.77,75.79 13.41,75.79 13.71,75.49 D26.2 14.08,75.49 14.29,75.71 R589.2 16.07,75.71 16.18,75.82 16.44,75.82 16.6,75.66 R2705.1
C_IN_CLK#_R: length 3.6
  TOP w0.102: v2(23.4,75.5) 23.61,75.71 23.84,75.71 23.97,75.58 C2742.2
  BOTTOM w0.102: U26.10 22.17,76.87 22.26,76.96 22.47,76.96 22.73,76.7 22.73,75.99 22.99,75.74 23.17,75.74 v2(23.4,75.5)
C_IN_CLK_R: length 3.6
  TOP w0.102: C2743.2 23.97,76.05 23.84,75.93 23.61,75.93 v2(23.4,76.14)
  BOTTOM w0.102: v2(23.4,76.14) 23.22,75.95 23.08,75.95 22.95,76.08 22.95,76.79 22.56,77.18 22.26,77.18 22.17,77.27 U26.9
C_TX0_HDMI+: length 17.9
  IN3 w0.089: v2(13.86,78.03) 14.12,77.77 14.33,77.77 14.67,78.1 14.67,79.97 13.12,81.52 11.75,81.52 10.98,80.76 10.98,75.44 10.71,75.17 10.25,75.17 10.05,74.97 CN4.7
  BOTTOM w0.102: R2700.1 16.31,77.8 16.2,77.8 16.07,77.94 R606.1 15.55,77.94 15.32,77.7 14.95,77.7 14.82,77.83 D31.2 14.57,78.12 14.27,77.82 14.07,77.82 v2(13.86,78.03)
C_TX0_HDMI+_R: length 3.3
  TOP w0.102: v2(23.62,78.04) 23.83,77.83 24.02,77.83 24.14,77.96 C2737.2
  BOTTOM w0.102: v2(23.62,78.04) 23.36,77.78 23.25,77.78 23.18,77.86 23.18,78.09 22.87,78.4 22.24,78.4 22.16,78.47 U26.6
C_TX0_HDMI-: length 17.9
  IN3 w0.089: v2(13.86,77.4) 14.02,77.56 14.42,77.56 14.87,78.01 14.87,80.05 13.2,81.72 11.66,81.72 10.78,80.84 10.78,75.53 10.63,75.37 10.38,75.37 CN4.9
  BOTTOM w0.102: v2(13.86,77.4) 14.07,77.61 14.26,77.61 14.56,77.31 D32.2 14.9,77.31 15.08,77.48 R606.2 16.07,77.48 16.17,77.58 16.35,77.58 R2699.1
C_TX0_HDMI-_R: length 3.2
  TOP w0.102: v2(23.62,77.41) 23.83,77.61 24.02,77.61 24.14,77.49 C2736.2
  BOTTOM w0.102: v2(23.62,77.41) 23.47,77.56 23.46,77.56 23.45,77.56 23.16,77.56 22.96,77.77 22.96,78 22.78,78.18 22.27,78.18 22.17,78.07 U26.7
C_TX1_HDMI+: length 14
  IN1 w0.089: v2(13.04,80.25) 13.26,80.03 13.9,80.03 14.81,79.12 14.81,77.44 14.11,76.74 14.11,75.37 12.28,73.54 11.94,73.54 CN4.4
  BOTTOM w0.102: v2(13.04,80.25) 13.13,80.17 13.28,80.17 13.29,80.16 13.51,80.16 13.69,80.34 D29.2 14.07,80.34 14.37,80.04 14.61,80.04 15.18,79.47 15.41,79.47 15.53,79.59 R601.1 16.09,79.59 16.21,79.47 16.44,79.47 16.6,79.63 R2702.1
C_TX1_HDMI+_R: length 3.2
  TOP w0.102: C2739.2 24.22,79.89 24.09,79.76 23.91,79.76 v2(23.7,79.97)
  BOTTOM w0.102: U26.4 22.22,79.27 22.32,79.18 22.64,79.18 23.22,79.76 23.49,79.76 v2(23.7,79.97)
C_TX1_HDMI-: length 13.9
  IN1 w0.089: v2(13.04,79.62) 13.26,79.83 13.82,79.83 14.61,79.04 14.61,77.53 13.9,76.82 13.9,75.46 12.2,73.75 11.73,73.75 11.6,73.87 CN4.6
  BOTTOM w0.102: v2(13.04,79.62) 13.38,79.95 13.65,79.95 13.78,79.82 D30.2 14.07,79.53 14.37,79.82 14.52,79.82 15.09,79.25 15.41,79.25 15.53,79.14 R601.2 16.09,79.14 16.21,79.25 16.47,79.25 16.6,79.13 R2701.1
C_TX1_HDMI-_R: length 3.2
  TOP w0.102: v2(23.7,79.34) 23.91,79.55 24.09,79.55 24.22,79.42 C2738.2
  BOTTOM w0.102: v2(23.7,79.34) 23.49,79.55 23.31,79.55 22.73,78.96 22.27,78.96 22.18,78.87 U26.5
C_TX2_HDMI+: length 19.7
  IN1 w0.089: CN4.1 10.4,72.05 10.66,72.05 11.42,71.28 11.92,71.28 16.06,75.42 16.06,81.01 15,82.08 14.16,82.08 v2(14.01,82.24)
  BOTTOM w0.102: R2704.1 16.85,82.22 16.64,82.01 16.41,82.01 16.3,82.13 R595.1 15.32,82.13 D27.2 14.73,82.03 14.22,82.03 v2(14.01,82.24)
C_TX2_HDMI+_R: length 3.8
  TOP w0.102: C2741.2 23.59,81.95 23.46,81.82 23.27,81.82 v2(23.06,82.03)
  BOTTOM w0.102: U26.1 22.19,80.47 22.28,80.38 22.45,80.38 22.55,80.48 22.55,80.69 22.39,80.86 22.39,81.59 22.62,81.82 22.85,81.82 v2(23.06,82.03)
C_TX2_HDMI-: length 19.7
  IN1 w0.089: v2(14.01,81.6) 14.01,81.7 14.18,81.88 14.91,81.88 15.86,80.93 15.86,75.51 11.84,71.49 11.5,71.49 10.74,72.25 10.18,72.25 10.05,72.38 CN4.3
  BOTTOM w0.102: R2703.1 16.85,81.67 16.73,81.79 16.44,81.79 16.32,81.68 R595.2 15.81,81.68 15.58,81.91 15.2,81.91 15.07,81.78 D28.2 14.76,81.56 14.5,81.81 14.22,81.81 v2(14.01,81.6)
C_TX2_HDMI-_R: length 3.8
  TOP w0.102: v2(23.06,81.39) 23.27,81.6 23.46,81.6 23.59,81.48 C2740.2
  BOTTOM w0.102: U26.2 22.19,80.07 22.28,80.16 22.54,80.16 22.77,80.39 22.77,80.78 22.61,80.95 22.61,81.5 22.71,81.6 22.85,81.6 v2(23.06,81.39)
CASA0B: length 26
  TOP w0.102: 123.19,104.29 v2(121.39,104.29)
  TOP w0.127: 123.19,104.29 123.35,104.13 128.66,104.13 129.33,104.8 129.51,104.8 130.13,104.18 130.31,104.18 130.48,104.34 130.48,104.55 129.87,105.16 129.87,105.34 130.05,105.52 130.23,105.52 130.9,104.85 131.08,104.85 131.26,105.03 131.26,105.21 130.59,105.88 130.59,106.05 130.77,106.23 130.95,106.23 131.58,105.6 131.76,105.6 131.93,105.77 131.93,105.97 131.31,106.59 131.31,106.77 131.53,107 131.74,107 131.94,106.79 132.12,106.79 132.65,107.33 137.97,107.33 v2(138.42,107.78)
  BOTTOM w0.102: U2029.D23 121.2,104.48 v2(121.39,104.29)
  BOTTOM w0.127: v2(138.42,107.78) 138.42,107.74 138.78,107.38 VRAM2001.L3
CASA1B: length 30
  TOP w0.102: v2(121.39,100.95) 122.5,100.95 123.58,99.86 124.4,99.86
  TOP w0.127: 124.4,99.86 125.91,98.35 129.88,98.35 130.07,98.16 130.49,98.16 130.61,98.28 130.61,98.56 130.74,98.69 130.99,98.69 131.12,98.56 131.12,98.28 131.25,98.16 131.5,98.16 131.63,98.28 131.63,98.56 131.76,98.69 132.01,98.69 132.14,98.56 132.14,98.28 132.26,98.16 132.69,98.16 132.81,98.28 132.81,98.56 132.94,98.69 133.19,98.69 133.32,98.56 133.32,98.28 133.45,98.16 133.7,98.16 133.83,98.28 133.83,98.56 133.96,98.69 134.21,98.69 134.34,98.56 134.34,98.28 134.46,98.16 135.22,98.16 135.34,98.03 135.34,97.14 135.47,97.01 136.43,97.01 136.56,96.89 136.56,96.63 136.43,96.51 135.47,96.51 135.34,96.38 135.34,96.02 135.47,95.9 137.58,95.9 138.93,94.54 138.93,94.13 139.3,93.75 139.3,92.72 v2(139.18,92.59)
  BOTTOM w0.102: U2029.D17 121.2,101.13 v2(121.39,100.95)
  BOTTOM w0.127: VRAM2002.G3 v2(139.18,92.59)
CKEA0: length 27.8
  TOP w0.102: v2(120.69,103.1) 121.06,103.48 122.15,103.48 122.73,102.9 123.3,102.9 123.54,102.66
  TOP w0.127: 123.54,102.66 123.95,102.25 133.55,102.25 133.67,102.37 133.67,102.91 133.8,103.03 134.05,103.03 134.18,102.91 134.18,102.37 134.31,102.25 134.56,102.25 134.69,102.37 134.69,102.91 134.82,103.03 135.07,103.03 v2(135.2,102.91) 135.2,102.37 135.32,102.25 135.81,102.25 139.36,105.8 139.36,106.36 v2(140.78,107.78)
  BOTTOM w0.102: v2(120.69,103.1) 120.51,103.1 119.89,103.72 U2029.G21
  BOTTOM w0.127: VRAM2001.J3 140.38,107.38 v2(140.78,107.78)
CKEA1: length 30
  TOP w0.102: 124.83,100.39 123.91,100.39 122.67,101.63 120.81,101.63 120.31,102.13 v2(120.15,102.13)
  TOP w0.127: v2(140.78,92.59) 140.33,93.05 140.33,94.71 135.23,99.81 134.47,99.81 134.34,99.94 134.34,100.19 134.22,100.32 133.96,100.32 133.84,100.19 133.84,99.94 133.71,99.81 133.35,99.81 133.23,99.94 133.23,100.16 133.1,100.29 132.85,100.29 132.72,100.16 132.72,99.94 132.59,99.81 132.15,99.81 132.02,99.94 132.02,100.14 131.9,100.27 131.64,100.27 131.52,100.14 131.52,99.94 131.39,99.81 131.13,99.81 131.01,99.94 131.01,100.14 130.88,100.27 130.63,100.27 130.5,100.14 130.5,99.94 130.37,99.81 130.12,99.81 129.99,99.94 129.99,100.14 129.86,100.27 129.61,100.27 129.48,100.14 129.48,99.94 129.36,99.81 125.41,99.81 124.83,100.39
  BOTTOM w0.102: U2029.E19 120.4,102.38 v2(120.15,102.13)
  BOTTOM w0.127: VRAM2002.J3 v2(140.78,92.59)
CLK_GFX_N_R: length 14.2
  BOTTOM w0.089: U2030.AN4 101.24,48.26 101.3,48.21 101.46,48.21 101.77,48.32 102.22,48.32 102.3,48.4
  BOTTOM w0.102: 102.3,48.4 103.85,48.4 104.33,48.88 105.47,48.88 106.21,49.62 109.94,49.62 110.68,50.35 110.68,50.99 110.88,51.19 110.88,51.5 111.01,51.62 111.63,51.62 111.89,51.88 R2402.1
CLK_GFX_P_R: length 14.1
  BOTTOM w0.089: U2030.AN2 102.1,48.51 102.21,48.61
  BOTTOM w0.102: 102.21,48.61 103.76,48.61 104.24,49.1 105.38,49.1 106.12,49.83 109.85,49.83 110.46,50.44 110.46,51.08 110.67,51.28 110.67,51.59 110.92,51.84 111.54,51.84 111.67,51.97 111.67,52.21 111.57,52.31 110.81,52.31 110.7,52.41 110.7,52.56 110.79,52.64 R2401.1
CLK_LPC_DEBUG: length 122.6
  IN1 w0.089: v1(101.71,29.07) 101.71,28.89 100.85,28.03 100.85,20.99 105.88,15.96 114.49,15.96 114.61,15.84 115.73,15.84 115.85,15.96 138.24,15.96 139.69,17.41 141.87,17.41 142.35,16.93 142.35,16.39 143.1,15.65 145.31,15.65 148.27,12.69 153.83,12.69 155.36,14.21 165.42,14.21 167.52,12.1 186.9,12.1 187.13,11.87 187.13,10.65 187.51,10.27 190.94,10.27 191.5,10.83 192.26,10.83 192.72,11.29 192.72,12.86 v2(192.16,13.42)
  BOTTOM w0.102: R77883.2 95.18,32.12 96.21,31.09 96.21,30.68 96.51,30.39 97.52,30.39 98.18,29.73 100.22,29.73 100.88,29.07 v1(101.71,29.07) ; v2(192.16,13.42) 192.19,13.4 C701.1 192.86,13.48 192.44,13.91 192.44,14.39 R706.1
CLK_PCIE_LANN: length 108.8
  TOP w0.102: U1.16 46.04,102.73 45.96,102.65 45.96,102.53 46.57,101.92 46.57,101.54 46.7,101.41 46.93,101.41 v2(47.06,101.54)
  IN3 w0.089: v2(47.06,101.54) 47.17,101.43 49.78,101.43 50.18,101.03 50.65,101.03 51.06,101.43 56.61,101.43 57.62,102.44 58.86,102.44 59.27,102.04 62.6,102.04 63.49,101.15 66.27,101.15 67.47,99.95 67.96,99.95 70.78,97.13 73.49,97.13 75.23,95.38 82.09,95.38 83.12,94.35 87.5,94.35 88.77,93.08 91.46,93.08 92.87,91.68 94.41,91.68 96.87,89.22 96.87,86.66 97.47,86.07 97.47,84.31 98.06,83.73 98.06,81.51 99.11,80.45 100.35,80.45 105.17,75.64 105.17,71.19 105.89,70.47 110.46,70.47 111.4,69.53 111.86,69.53 112.58,68.8 112.58,68.01 114.11,66.48 114.11,63.05 114.25,62.91 114.25,61.43 113.73,60.91 113.73,60.3 112.58,59.15 112.58,58.53 111.45,57.4 110.88,57.4 v2(110.73,57.25)
  BOTTOM w0.102: R2413.2 110.06,53.09 109.93,53.22 109.93,57.28 110.17,57.52 110.46,57.52 v2(110.73,57.25)
CLK_PCIE_LANN_R: length 11.5
  BOTTOM w0.102: U2030.AM4 101.02,49.35 101.22,49.27 101.29,49.2 101.55,49.2 101.6,49.26 101.98,49.39 102.6,49.39 103.72,50.51 104.61,50.51 105.7,51.59 109.78,51.59 110.14,51.95 110.14,52.49 R2413.1
CLK_PCIE_LANP: length 108.8
  TOP w0.102: U1.15 45.64,102.75 45.74,102.64 45.74,102.44 46.35,101.83 46.35,101.45 46.61,101.19 46.77,101.19 v2(47.06,100.91)
  IN3 w0.089: v2(110.73,57.88) 111.01,57.6 111.37,57.6 112.37,58.61 112.37,59.24 113.52,60.38 113.52,61 114.04,61.52 114.04,62.83 113.91,62.96 113.91,66.39 112.38,67.92 112.38,68.72 111.77,69.33 111.31,69.33 110.37,70.27 105.8,70.27 104.96,71.11 104.96,75.55 100.26,80.25 99.03,80.25 97.85,81.43 97.85,83.65 97.27,84.23 97.27,85.98 96.67,86.58 96.67,89.13 94.33,91.48 92.78,91.48 91.38,92.88 88.69,92.88 87.41,94.15 83.03,94.15 82.01,95.18 75.15,95.18 73.4,96.93 70.7,96.93 67.87,99.75 67.39,99.75 66.19,100.95 63.4,100.95 62.52,101.83 59.18,101.83 58.77,102.24 57.71,102.24 56.7,101.23 51.14,101.23 50.73,100.82 50.1,100.82 49.69,101.23 47.38,101.23 v2(47.06,100.91)
  BOTTOM w0.102: R2433.2 109.71,53.27 109.71,57.37 110.08,57.73 110.58,57.73 v2(110.73,57.88)
