# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VPCU_EC: length 53.7
  TOP w0.203: U13.50 174.02,13.14 v2(174.2,12.95) 174.15,12.9 C477.1 C478.1
  TOP w0.508: v2(166.18,33.01) L6.2 ; L10.1 187.01,19.43 187.11,19.52 v2(187.11,20.18)
  IN1 w0.508: v2(174.2,12.95) 174.2,13.17 173.81,13.56 168.17,13.56 163.58,18.16 163.58,18.53 163.5,18.6 v2(163.5,19)
  IN2 w0.508: v2(163.5,19) 163.5,18.56 163.92,18.15 164.63,18.15 165.82,19.33 170.28,19.33 171.26,20.31 173.08,20.31 v2(173.09,20.31) 173.09,19.93 173.39,19.62 176.13,19.62 177.74,18.01 179.13,18.01 179.37,18.26 181.63,18.26 184.31,20.94 186.81,20.94 187.11,20.64 v2(187.11,20.18)
  BOTTOM w0.508: R401.2 172.96,20.44 v2(173.09,20.31) 173.09,20.74 173.67,21.32 173.67,22.97 172.67,23.97 172.67,25.25 v2(172.02,25.89)
  vias: v1(172.82,30.94) v2(168.95,31.51) v2(182.69,26.4) v2(184.42,25.69)
+3VPCU_HALL: length 21
  TOP w0.508: v2(36.38,122.41) 35.85,122.95 HE1.2 ; v2(46.25,122.29) HE2.2
  IN1 w0.508: v2(36.38,122.41) 37.15,121.65 45.61,121.65 v2(46.25,122.29)
  BOTTOM w0.508: R507.2 D22.2 41.3,122.07 40.96,122.41 39.43,122.41 39.31,122.3 C508.1 36.5,122.3 v2(36.38,122.41)
+3VRTC: length 143.2
  TOP w0.508: v2(73.21,30.97) 73.21,31.74 76.5,35.03 80.34,35.03 82.61,32.75 83.84,32.75 85.53,31.06 85.53,30.36 87.09,28.79 87.61,28.79 89.62,26.78 94.39,26.78 95.35,27.75 95.46,27.75 96.15,28.43 96.71,28.43
  IN1 w0.508: v2(73.21,30.97) 70.45,29.83 69.68,29.83 69.42,29.56 60.4,29.56 60.04,29.92 51.94,29.92 51.02,30.85 48.19,30.85 47.31,31.74 47.31,42.15 47.56,42.4 47.56,58.53 50.71,61.68 50.71,68.62 49.57,69.76 49.57,94.19 50.35,94.98 v2(50.35,96.51)
  BOTTOM w0.508: v2(50.35,96.51) 50.1,96.51 49.85,96.76 49.85,97.4 51.37,98.92 55.18,98.92 56.27,97.83 56.71,97.83 57.14,97.4 58.1,97.4 58.66,96.84 61.3,96.84 62.65,95.49 63.55,95.49 63.8,95.74 65.21,95.74 65.34,95.87
  vias: v2(96.2,31.23)
+5V: length 20.7
  TOP w0.508: v2(198.94,29.96) 199.38,29.53 199.38,27.84 C379.2 200.31,27.51 200.48,27.68 C378.1 200.98,28.05 201.41,28.48 L7.1 ; v2(40.07,16.5) v2(41.08,16.5) 41.72,16.5 42.43,15.78 43.7,15.78 45.91,13.58 45.91,12.86 v2(45.96,12.81)
  BOTTOM w0.203: 197.55,18.78 197.28,18.52 197.28,18.28 R827.1
  BOTTOM w0.305: v2(45.96,12.81) 45.57,12.81 44.45,11.7 CN17.6
  BOTTOM w0.381: R573.1 v2(212.52,14.8)
  BOTTOM w0.508: v2(198.31,19.67) 198.31,19.66 197.55,18.89 197.55,18.78
  vias: v2(60.48,95.74) v2(61.12,95.74) v2(94.04,16.5) v2(94.04,15.86) v2(94.04,15.23) v2(94.68,16.5) v2(94.68,15.86) v2(94.68,15.23) v2(115.38,14.85) v2(116.01,14.85) v2(116.65,14.85) v2(117.28,14.85) v2(178.24,28.15) v2(178.24,27.52) v2(197.8,14.72) v2(214.95,16.12) v2(214.95,15.48) v2(214.95,14.85) v3(16.09,29.83) v3(16.09,28.92) v3(16.57,85.84) v3(16.57,85.08) v3(16.72,30.21) v3(16.7,29.35) v3(30.41,96.13) v3(31.18,96.13) v3(199.74,16.92) v3(200.48,16.89)
+5V_HDMIC: length 4.3
  TOP w0.508: D5.3 16.57,86.73 16.21,87.09 15.15,87.09 14.41,86.35 14.41,85.2
  vias: v2(14.03,83.55)
+5V_KB:
  vias: v2(198.69,12.81)
+5V_PVDD: length 15.9
  BOTTOM w0.203: C637.1 199.32,21.45 199.73,21.86 200.87,21.86 201.26,22.24 201.26,22.52 201.73,23 U30.46 ; C647.1 203.01,21.32 203.64,21.96 203.64,22.85 203.73,22.94 U30.41
  BOTTOM w0.381: C650.1 200.68,18.93 201.48,18.93 202.27,18.15 L14.2 ; C650.1 200.07,20.96 199.62,21.41 C637.1 ; C650.1 200.72,19.54 200.98,19.8 200.98,20.18 201.34,20.54 C641.1 C647.1
+5V_S5: length 253.8
  TOP w0.203: v2(25.59,13.83) 25.59,14.37 R244.2
  TOP w0.305: PR6001.1 151.92,53.67 v2(151.99,53.6)
  TOP w0.381: PR6002.2 140.47,50.08 140.78,49.77 140.78,47.56 v2(141.29,47.05) ; v2(25.54,13.12) 25.36,12.94 R6523.2
  TOP w0.483: PR2.1 71.04,125.11 v2(71.27,125.34)
  TOP w0.508: v2(148.02,38.47) 148.02,41.77 146.37,43.42 144.71,43.42 143.1,45.03 143.1,45.24 v2(141.29,47.05) ; v2(197.55,15.96) 198.54,15.96 200.67,13.83 v2(201.23,13.83)
  IN1 w0.381: v2(151.99,53.6) 151.99,53.57 154.24,51.32 154.24,50.79 154.49,50.53 154.49,49.87 152.94,48.32 152.55,48.06 150.37,48.06 149.79,47.48 144.71,47.48 143.86,46.63 141.71,46.63 v2(141.29,47.05)
  IN1 w0.508: v2(71.27,125.34) 71.05,125.12 71.05,122.03 71.56,121.53 71.56,119.85 72.88,118.53 72.88,117.6 72.28,117 71.86,117 70.85,115.98 69.34,115.98 68.36,115 68.36,113.86 v2(68.67,113.55)
  IN2 w0.305: 73.37,114.62 73.37,115.96 72.96,116.37 v1(72.93,116.37) ; 73.37,114.62 73.93,114.05 74.74,114.05 76.41,112.39 77.34,112.39 78.21,113.26 78.21,114.86 v2(78.23,114.87) ; 73.37,114.62 72.81,114.05 71.13,114.05 70.62,113.55 v2(68.67,113.55)
  IN3 w0.508: v2(148.02,38.47) 147.76,38.21 147.76,34.57 150.95,31.39 153.51,31.39 153.62,31.5 162.04,31.5 163.18,30.36 166.66,30.36 167.5,29.53 170.43,29.53 174.44,25.51 180.78,25.51 181.22,25.08 185.15,25.08 185.74,24.49 188.2,24.49 188.78,25.08 191.15,25.08 191.5,24.72 191.5,20.74 196.28,15.96 v2(197.55,15.96) ; v2(68.67,113.55) 63.58,113.55 63.05,113.02 54.16,113.02 53.66,112.51 48.32,112.51 47.81,113.02 47.81,113.91 47.28,114.44 42.31,114.44 41.62,113.74 41.62,112.04 42.51,111.15 42.51,108.33 42.84,108 42.84,106.71 42.12,105.99 42.12,104.5 41.6,103.98 41.6,103.41 39.43,101.24 39.43,100.29 35.88,96.73 31.96,96.73 31.43,97.27 v2(30.03,97.27)
  BOTTOM w0.203: PR9101.1 72.55,115.99 v1(72.93,116.37) 73.32,115.98 PR9100.1
  BOTTOM w0.254: PR9001.1 68.6,113.61 v2(68.67,113.55)
  BOTTOM w0.508: v2(78.23,114.87) 78.23,114.54 PR9002.2 ; v2(24.06,43.8) 25.59,43.8 26.6,44.82 26.6,79.11 28.51,81.01 28.51,96.38 29.4,97.27 v2(30.03,97.27)
  vias: v2(17.08,39.86) v2(17.08,39.23) v2(17.59,27.42) v2(17.71,40.02) v2(19.37,40.07) v2(20.08,24.7) v2(20.71,24.7) v2(21.35,24.37) v2(21.98,24.37) v2(22.03,18.27) v2(22.41,18.78) v2(23.43,43.8) v2(23.43,43.17) v2(24.06,43.17) v2(26.22,13.83) v2(26.86,13.83) v2(100.65,14.46) v2(101.28,14.46) v2(101.92,14.46) v2(102.55,14.46) v2(201.23,13.07) v2(201.86,13.83) v2(201.86,13.07) v2(208.14,19.11) v2(208.52,19.7) v2(208.77,19.11) v2(209.15,19.72) v3(16.06,27.29) v3(16.06,26.53) v3(16.7,27.67) v3(16.7,26.91) v3(16.7,26.15)
+5VA: length 11.9
  TOP w0.508: v2(206.69,30.59) 207.07,30.97 C366.1 206.47,31.57 206.06,31.99 C375.2 205.51,30.56 205.2,30.24 L7.2
  BOTTOM w0.203: C623.1 208.09,31.36 207.71,30.97 207.71,29.37 206.79,28.46 U30.26
  BOTTOM w0.381: C623.1 C627.1 206.94,30.85 v2(206.69,30.59)
+5VPCU: length 191.8
  TOP w0.203: v2(27.82,28.66) 27.47,28.31 PR93.2 ; R222.2 v2(23.66,49.47) R225.2
  IN1 w0.381: v2(23.66,49.47) 22.87,49.47 20.98,47.57 19.07,47.57 v2(18.73,47.23)
  IN1 w0.508: v2(146.37,46.51) 146.6,46.74 147.36,46.74 148.02,46.09 148.02,45.33 148.52,44.82 150.3,44.82 v2(150.43,44.69) 150.7,44.42 150.7,39.47 152.69,37.48 155.94,36.13 157.8,34.28 v2(157.8,30.09)
  IN2 w0.508: v2(157.8,30.09) 158.68,30.97 162.11,30.97 162.75,30.34 166.3,30.34 166.94,29.7 168.72,29.7 168.95,29.48 174.2,29.48 174.79,30.07 179.96,30.07 181.47,31.58 185.13,31.58 185.35,31.36 v2(186.5,31.36)
  IN3 w0.381: v2(186.5,31.36) 187.38,31.36 188.02,30.72 189.04,30.72 190.64,32.32 191.65,32.32 192.47,33.13 193.42,33.13 193.68,33.39 196.15,33.39 196.66,33.9 197.8,33.9 198.31,34.4 202.13,34.4 204.03,36.31 v2(205.17,36.31)
  IN3 w0.508: v2(117.64,82.16) 116.77,82.16 116.01,81.39 116.01,79.74 118.55,77.2 118.55,74.66 119.82,73.39 139.13,73.39 140,74.26 140.78,74.26 141.22,73.83 141.22,73.4 143,71.61 145.48,71.61 147.38,69.71 147.38,65.26 148.52,64.12 148.52,63.02 149.76,61.78 v2(149.76,61.71) 149.76,61.44 149.54,61.22 149.54,59.91 150.81,58.64 150.81,55.99 150.3,55.49 150.3,54.85 150.94,54.22 150.94,48.24 150.56,47.86 150.56,44.82 v2(150.43,44.69)
  BOTTOM w0.203: v2(157.8,30.09) 157.8,28.69 157.47,28.37 156.97,28.37 156.4,28.94 PR260.2 ; PR9124.2 146.56,61.31 146.56,61.09 147.33,60.31 149.55,60.31 149.76,60.53 v2(149.76,61.71) ; PR2005.2 147.51,44.06 147.65,44.2 147.65,45.13 147.95,45.43 147.95,46.83 147.8,46.98 147.12,46.98 147,46.85 146.72,46.85 146.38,46.51 v2(146.37,46.51)
  BOTTOM w0.381: R694.1 v2(205.17,36.31)
  BOTTOM w0.457: v2(149.76,61.71) 149.76,61.99 149.57,62.19 PR9121.1 ; v2(146.37,46.51) 146.36,46.5 PR2002.1
  BOTTOM w0.508: v2(185.81,11.52) 185.81,12.25 186.51,12.95 186.51,16.91 187.11,17.51 188,17.51 188.5,18.02 188.5,18.49 189.62,19.6 189.62,23.02 189.01,23.62 189.01,24.54 189.22,24.75 189.22,26 186.75,28.47 186.75,29.66 186.5,29.91 v2(186.5,31.36)
  vias: v2(18.1,47.23) v2(18.22,45.96) v2(19.24,46.09) v2(23.13,25.44) v2(27.14,19.37) v2(27.14,18.73) v2(27.06,17.61) v2(27.06,16.98) v2(27.7,19.67) v2(27.7,19.04) v2(27.7,17.61) v2(27.7,16.98) v3(23.3,26.28) v3(23.63,29.96) v3(23.68,30.85) v3(23.81,25.56) v3(24.09,29.37) v3(24.09,27.01) v3(24.06,26.28) v3(24.37,30.21) v3(24.57,25.59)
+A3VPCU: length 5.2
  TOP w0.102: 182.72,19.36 v2(182.69,19.36)
  TOP w0.203: U13.74 182.56,19.36
  TOP w0.305: 182.72,19.36 183.01,19.36 183.19,19.54 C433.1 184.09,19.54 184.58,19.04 C434.2 186.23,19.04 L10.2 ; 182.56,19.36 v2(182.69,19.36)
+V3A_LX_R: length 1.4
  BOTTOM w0.559: PC247.1 PR258.2
+V3A_OUT: length 3.6
  BOTTOM w0.152: 151.06,37.27 151.06,38.83 150.82,39.07 149.53,39.07 PR236.2
  vias: v2(149.54,34.4) v3(150.4,35.42) v3(150.79,36.05) v3(151.17,35.42) v3(151.55,36.05) v3(151.93,35.42) v3(152.31,36.05)
+V5P5A_LX:
  vias: v2(42.1,21.07)
+V5P5A_LX_R: length 1.5
  BOTTOM w0.61: PR114.2 43.06,22.16 43.23,22.32 PC115.1
+V5P5A_OUT: length 4.5
  BOTTOM w0.152: PR277.1 40.19,14.21 v2(40.07,14.34) 38.8,15.61 37.02,15.61
+VCC_CORE: length 156
  IN2 w0.152: v2(149.62,45.57) 149.44,45.76 149.44,46.19 148.42,47.2 145.06,47.2 143.84,48.43 141.62,48.43 140.55,47.36 136.06,47.36 135.5,47.91 133.75,47.91 132.45,49.21 v2(132.45,49.43) ; v1(151.19,46.88) 150.27,46.88 149.08,48.08 145.4,48.08 144.2,49.27 141.19,49.27 140.16,48.25 136.44,48.25 135.87,48.82 134.37,48.82 132.46,50.72 127.09,50.72 126.24,51.57 126.24,54.53 128.46,56.76 128.89,56.76 v2(129.13,56.52)
  BOTTOM w0.178: PR6069.1 149.64,45.59 v2(149.62,45.57)
  BOTTOM w0.203: PL6002.2 130.11,52.83 130.77,52.18 130.77,50.47 131.81,49.43 v2(132.45,49.43) ; PL6001.2 127.29,60.01 127.91,59.38 127.91,57.73 v2(129.13,56.52) ; PR6072.1 150.91,46.88 v1(151.19,46.88)
  BOTTOM w0.254: v1(93.01,67.96) 92.89,67.96 92.54,67.61 U2030.K14 ; U2030.K12 94.16,67.96 v1(94.04,67.96) ; U2030.T15 v1(91.31,61.81) ; U2030.G12 94.61,70.01 v1(95.07,69.56) 95.16,69.56 U2030.H11 v1(96.01,69.71) 96.21,69.71 U2030.G10 96.87,70.37 v1(97.06,70.37) ; U2030.T7 98.51,62.02 98.9,62.41 v1(98.9,62.52) ; v1(91.31,63.41) 91.71,63.81 U2030.P15 ; v1(90.51,59.41) 90.91,59.81 U2030.W16 v1(91.31,60.21) U2030.V15 v1(92.05,60.95) U2030.U14 v1(92.92,61.82) U2030.T13 v1(93.68,62.58) ; U2030.AJ10 96.62,52.52 v1(96.7,52.52) ; U2030.Y8 97.98,58.74 97.98,58.51 ; U2030.Y8 97.3,59.42 v1(97.3,59.51) ; U2030.Y8 98.11,59.4 98.11,59.6 U2030.W7 98.89,59.63 v1(98.89,59.52) ; U2030.AF10 96.61,54.51 v1(96.69,54.51) 97.21,54.51 U2030.AE8 98.18,54.54 98.18,54.34 U2030.AF7 ; U2030.L8 97.91,67.21 v1(97.91,67.51) ; U2030.G7 97.98,69.47 v1(97.86,69.47) 97.51,69.13 U2030.H8 97.51,68.9 v1(97.85,68.56) 97.96,68.56 U2030.K7 98.93,68.43 v1(98.93,68.53) ; U2030.G7 98.92,69.6 v1(98.92,69.5) 99.5,69.5 v1(99.52,69.48) ; U2030.G7 98.18,70.34 v1(97.98,70.34) ; v1(92.07,68.84) 91.88,68.84 U2030.H15 91.86,69.56 92.03,69.56 v1(92.06,69.58) 92.49,70.01 U2030.G14 ; v1(98.23,65.54) 98.23,65.73 U2030.M7 ; v1(96.69,62.51) 96.61,62.51 U2030.T10 95.72,62.4 v1(95.72,62.59) ; v1(96.38,66.53) 96.38,66.28 U2030.M10 ; v1(97.34,62.52) 97.71,62.89 U2030.R8 ; U2030.AD10 95.69,56.43 v1(95.69,56.5) ; 97.98,58.51 98.01,58.51 U2030.AA7 98.02,57.52 v1(96.63,57.52) 96.6,57.52 U2030.AA10 96.61,58.51 v1(96.69,58.51) 97.98,58.51 ; U2030.P10 95.72,63.61 v1(95.72,63.51) ; U2030.AK19 88.91,50.61 89.71,50.61 U2030.AK17 ; v1(98.93,56.51) 98.93,56.43 U2030.AD7 ; v1(98.26,51.52) 98.26,51.76 U2030.AJ7 ; U2030.P7 98.51,64.07 v1(98.97,64.53)
  BOTTOM w0.279: v1(92.13,59.43) U2030.W14
  BOTTOM w0.305: v1(96.69,59.51) 96.19,60.01 U2030.W10 ; v1(93.69,59.42) 93.69,59.39 U2030.Y13 U2030.AA14 92.51,58.19 v1(92.91,57.78) 93.29,57.41 U2030.AB13 ; U2030.T15 91.71,62.33 v1(91.99,62.61) 92.11,62.61 U2030.R14 92.57,63.01 v1(92.95,63.4) 93.31,63.75 U2030.P13 ; U2030.AF13 93.31,54.21 v1(92.91,54.61) U2030.AE14 v1(92.11,55.41) U2030.AD15 91.71,55.83 v1(91.34,56.21) 90.94,56.61 U2030.AC16 90.66,56.86 U2030.AB17 U2030.AA18 89.31,58.21 U2030.Y17 v1(90.51,59.41) ; U2030.AD13 v1(92.91,56.21) U2030.AC14 92.51,56.61 v1(92.11,57.01) U2030.AB15 v1(91.34,57.78) U2030.AA16 U2030.Y15 v1(92.13,59.43) ; U2030.P15 91.99,64.08 v1(91.99,64.21) 92.11,64.21 U2030.N14 ; U2030.V13 92.99,60.29 v1(92.99,60.21) 92.91,60.21 U2030.W14 ; U2030.AH13 93.31,52.61 v1(92.94,52.98) U2030.AG14 v1(92.11,53.81) U2030.AF15 91.71,54.23 v1(91.34,54.61) 91.31,54.61 U2030.AE16 U2030.AD17 v1(89.71,56.21) U2030.AC18 v1(88.91,57.01) U2030.AB19 ; U2030.AK13 v1(92.9,51.42) U2030.AJ14 v1(92.11,52.21) U2030.AH15 91.71,52.63 v1(91.34,53.01) 91.31,53.01 U2030.AG16 U2030.AF17 v1(89.71,54.61) U2030.AE18 v1(88.91,55.41) U2030.AD19 ; U2030.AK17 v1(89.71,51.41) U2030.AJ18 v1(88.91,52.21) U2030.AH19 ; U2030.AK15 91.71,51.03 v1(91.34,51.41) 91.31,51.41 U2030.AJ16 U2030.AH17 90.11,52.61 v1(89.71,53.01) U2030.AG18 v1(88.91,53.81) U2030.AF19 ; U2030.V17 v1(90.51,61.01) 90.91,61.41 U2030.U16 v1(91.31,61.81) ; v1(91.31,63.41) U2030.R16 v1(90.51,62.61) U2030.T17
  vias: v1(94.04,67.17) v1(95.06,68.82) v1(95.06,68.06) v1(96.07,68.57) v1(96.96,68.57) v1(97.09,69.46) v1(97.93,63.51) v1(97.9,55.51) v1(99.5,70.47) v1(99.48,51.53) v2(93.15,66.53) v2(103.77,70.09) v2(106.18,67.5) v2(106.36,66.41) v2(106.45,57.9) v2(106.87,57.39) v2(107,66.41) v2(109.66,64.25) v2(128.28,55) v2(128.92,55) v2(129.56,55.59) v2(129.56,54.95) v2(129.55,54.31) v2(130.19,55.59) v2(130.19,54.95) v2(130.19,54.31) v2(130.83,55.58) v2(130.83,54.94) v2(130.83,54.28) v2(130.81,53.56) v2(130.86,52.88) v2(131.41,55.23) v2(131.42,54.59) v2(131.42,53.95) v2(131.45,53.28) v3(105.55,63.64) v3(106.08,64.17) v3(106.61,63.02) v3(106.74,64.5) v3(106.87,67.55) v3(110.32,69.46) v3(111.06,64.88) v3(111.44,62.62) v3(111.82,64.88) v3(113.35,67.93) v3(113.88,67.42) v3(114.95,70.7) v3(115.12,71.51) v3(115.5,70.22) v3(115.63,70.98) v3(115.56,69.48) v3(116.27,70.22) v3(116.29,69.46) v3(116.51,66.11) v3(117.03,69.46) v3(117.23,64.22) v3(117.24,63.44) v3(117.23,62.65) v3(117.24,61.87) v3(117.28,66.11) v3(117.96,64.14) v3(117.97,63.4) v3(117.96,62.57) v3(117.97,61.83) v3(118.7,64.13) v3(118.72,63.4) v3(118.7,62.56) v3(118.72,61.83) v3(119.35,63.78) v3(119.32,62.98) v3(119.3,61.38) v3(119.36,62.19) v3(120.14,67.45) v3(120.19,68.99) v3(120.21,68.21) v3(120.58,66.81) v3(120.64,61.48) v3(120.73,60.31) v3(120.93,69) v3(120.92,67.46) v3(120.96,68.2) v3(121.17,62.01) v3(121.15,60.94) v3(121.2,59.74) v3(121.37,66.8) v3(121.72,68.22) v3(121.7,67.45) v3(121.73,66.15) v3(122.11,66.83) v3(122.67,57.77) v3(122.67,57.03) v3(122.67,56.3) v3(122.67,55.56) v3(123.4,65.26) v3(123.4,64.5) v3(123.4,63.74) v3(123.4,57.77) v3(123.4,57.03) v3(123.4,56.3) v3(123.4,55.56) v3(123.79,62.98) v3(123.79,62.22) v3(124.14,65.26) v3(124.14,64.5) v3(124.14,63.74) v3(124.14,57.77) v3(124.14,57.03) v3(124.14,56.3) v3(124.14,55.56) v3(124.52,62.98) v3(124.52,62.22) v3(125.28,62.98) v3(125.28,62.22)
+VCC_V3A: length 1.4
  BOTTOM w0.229: PU11.9 145.07,35.33 PC234.1
+VCC_V5P5A: length 1.4
  BOTTOM w0.229: PU15.11 43.33,16.96 43.42,16.87 43.42,16.5 PC265.1
+VDD_08: length 34.1
  TOP w0.203: PR9108.2 88.83,117.84 89.34,118.35 92.09,118.35 92.48,117.96
  TOP w0.381: PR77863.1 127.42,119.2 v1(127.42,120.15)
  IN1 w0.381: v1(127.42,120.15) 127.42,119.91 126.95,119.44 125.74,119.44 124.76,118.46 119.3,118.46 114.23,113.4 114.23,110.6 113.75,110.12 v1(112.41,110.12)
  BOTTOM w0.305: v2(108.19,110.15) 108.19,110.81 U2029.AG35 109.23,110.79 v2(109.23,110.12)
  BOTTOM w0.381: U2029.AC32 110.94,109.72 v2(111.39,110.17) ; U2029.AJ34 107.2,110.12 v2(106.93,110.12) 106.91,110.12 U2029.AL34 ; v1(112.41,110.12) 112.8,109.72 U2029.W32 ; v2(109.23,110.12) 108.83,109.72 U2029.AG32 108.28,110.15 v2(108.19,110.15) 107.77,109.72 U2029.AJ32
  vias: v2(93.91,117.33) v3(95.36,117.51) v3(95.92,118.02)
+VDD_18:
  vias: v1(83.25,30.36) v1(83.25,29.57) v1(83.65,29.97) v1(84.09,30.31) v1(88.07,49.78) v1(88.07,49.01) v2(82.23,26.91)
+VDD_18_S5: length 1.4
  TOP w0.305: C2514.1 88.71,49.14 v1(88.83,49.01) 88.72,48.89 C2515.1
  vias: v2(93.74,38.47) v2(93.74,37.83) v2(93.84,34.91)
+VDDCI: length 29.8
  IN2 w0.305: v2(72.3,120.33) 72.3,121.5 74.4,123.6 86.27,123.6 88.43,121.45 v2(88.43,121.42)
  BOTTOM w0.203: PL9002.2 88.94,120.28 88.43,120.79 v2(88.43,121.42) ; v2(72.3,120.33) 72.32,120.31 PR9073.1
  BOTTOM w0.381: v2(116.49,107.21) U2029.L29 ; U2029.U11 114.05,98.72 v2(114.44,98.34) ; U2029.L17 117.49,101.24 v2(117.49,101.08) ; v2(110.6,98.28) 110.44,98.28 U2029.AE11 ; U2029.N11 116.52,99.24 v2(116.52,99.3) ; U2029.L13 117.36,100.08 v2(117.36,100.19) ; U2029.AA11 v2(112.46,98.26) ; v2(116.67,106.23) 117,105.9 U2029.L25 ; U2029.L21 116.65,103.37 v2(116.65,103.24)
  vias: v2(116.55,108.14) v2(117.16,99.43) v3(93.11,122) v3(93.11,121.23) v3(93.11,120.46) v3(93.11,119.7) v3(93.11,118.94) v3(93.83,120.16) v3(93.83,119.4)
+VDDCR_SOC: length 34.3
  TOP w0.203: v2(144.23,60.77) 144.57,60.44 145.65,60.44 145.68,60.46 148.12,60.46 148.55,60.03 PR6075.1
  IN2 w0.178: v2(144.23,60.77) 143.74,60.28 142.73,60.28 139.72,63.28 139.72,72.11 138.04,73.8 138.04,76.82 137.47,77.38 134.97,77.38 v2(134.83,77.53)
  BOTTOM w0.203: v2(134.83,77.53) 134.24,77.53 133.28,76.57 133.28,75.43 133.02,75.17 PL6000.2
  vias: v1(87.32,64.92) v1(87.41,64.21) v1(87.41,63.41) v1(87.41,61.81) v1(87.42,60.19) v1(87.92,66.39) v1(88.07,65.54) v1(88.07,64.96) v1(88.11,63.39) v1(88.11,61.8) v1(88.07,60.18) v1(88.91,61.81) v1(88.91,61.02) v1(88.92,60.2) v1(88.96,62.6) v1(89.22,65.54) v1(89.72,65.01) v1(89.7,63.36) v1(90.16,65.54) v1(90.51,64.21) v1(90.61,65.01) v1(90.93,65.55) v1(90.99,66.28) v1(91.3,64.9) v1(91.51,65.46) v1(92.09,65.56) v2(91.25,81.14) v2(107,79.87) v2(107.63,79.87) v2(111.44,79.87) v2(112.08,79.87) v3(90.71,80.2) v3(92.57,80.07) v3(118.55,79.87) v3(119.31,80.12) v3(120.08,80.12) v3(124.25,78.28) v3(124.24,77.52) v3(124.22,76.69) v3(124.22,75.93) v3(124.22,75.17) v3(124.25,79.03) v3(124.99,79.03) v3(124.98,78.28) v3(124.97,77.52) v3(124.95,76.69) v3(124.95,75.93) v3(124.95,75.17) v3(124.95,74.43) v3(125.69,76.69) v3(125.69,75.93) v3(125.69,75.17) v3(125.69,74.43) v3(126.45,76.69) v3(126.45,75.93) v3(126.45,75.17) v3(126.45,74.43) v3(127.19,76.69) v3(127.19,75.93) v3(127.19,75.17) v3(127.19,74.43) v3(127.93,76.69) v3(127.93,75.93) v3(127.93,75.17) v3(127.93,74.43) v3(128.74,79.79) v3(128.74,79.01) v3(128.75,78.23) v3(128.75,77.49) v3(128.66,76.69) v3(128.66,75.93) v3(128.66,75.17) v3(128.66,74.43)
+VDDQ: length 99
  TOP w0.508: PR9.2 69.84,119.16 v1(70.04,119.37) ; v2(48.32,60.92) 48.32,59.93 50.35,57.9 R2682.1
  IN1 w0.508: v2(48.32,60.92) 48.32,61.2 49.57,62.44 49.57,68.15 47.71,70 47.71,91.07 47.81,91.17 v2(47.81,92.57) ; v2(39.18,98.16) 39.18,106.67 40.19,107.68 40.19,112.38 42.25,114.44 44.79,114.44 45.02,114.67 62.93,114.67 67.63,119.37 v1(70.04,119.37)
  BOTTOM w0.508: v2(47.81,92.57) 47.81,93.71 47.05,94.47 39.81,94.47 39.18,95.11 v2(39.18,98.16)
+VDDQ_BOOT1: length 1.3
  TOP w0.483: PR132.1 61.09,120.06 60.77,119.75 PC139.1
+VDDQ_P: length 6.2
  TOP w0.203: PR6.1 61.5,118.48 62.01,117.97 64.07,117.97 64.45,117.59 66.1,117.59 66.74,118.22 PR9300.1
  vias: v2(50.23,121.14) v3(54.22,122.76) v3(54.22,121.9) v3(54.97,122.77) v3(55.03,121.93) v3(55.74,122.77) v3(55.79,121.98) v3(56.52,122.76) v3(56.55,121.98)
+VDDQ_SR: length 2.4
  BOTTOM w0.102: v2(63.01,123.89) PC136.1
  BOTTOM w0.508: PC136.1 PR129.2
+VDDQ_VTT: length 150.2
  TOP w0.203: 28.64,78.6 28.64,77.71 28.89,77.46 33.46,77.46 33.62,77.61 R2344.1
  IN3 w0.508: v2(61.08,117.86) 61.08,117.39 60.26,116.57 53.53,116.57 52.16,115.2 45.02,115.2 44.51,115.71 42.51,115.71 40.85,114.06 40.85,111.72 41.74,110.83 41.74,108.01 42.07,107.68 42.07,107.02 41.36,106.31 41.36,104.82 40.83,104.29 40.83,103.72 38.67,101.56 38.67,100.61 36.93,98.87 30.37,98.87 29.4,97.9 v3(29.4,91.93)
  BOTTOM w0.508: 48.47,30.24 47.28,29.04 47.28,27.9 46.26,26.88 38.32,26.88 33.21,31.99 32.15,31.99 28.89,35.25 28.89,42.73 29.68,43.52 29.68,44.75 28.51,45.92 28.51,64.65 30.36,66.51 30.36,67.75 29.88,68.24 29.14,68.24 28.51,68.87 28.51,72.25 30.54,74.28 30.54,78.95 29.4,80.1 v3(29.4,91.93) ; PR130.2 62.03,120.25 60.89,119.11 60.89,118.05 v2(61.08,117.86)
  vias: v2(41.46,91.3) v2(48.45,31.71) v2(48.96,32.22) v2(49.08,30.59)
+VIN: length 105.5
  TOP w0.152: PR19.2 53.1,114.96 53.1,116.74 53.26,116.9 PR12.2
  TOP w0.381: PR9128.1 132.04,121.42 v2(131.76,121.14) 132.4,120.51 PR77861.1
  IN1 w0.508: v1(141.83,59.29) 141.83,60.61 142.94,61.71 147.25,61.71 149.41,63.87 149.41,66.66 v2(148.27,67.8)
  IN2 w0.508: v2(148.27,67.8) 148.91,68.44 148.91,72.5 149.67,73.27 149.67,77.33 148.91,78.09 148.91,95.11 149.41,95.62 149.41,105.9 148.91,106.41 148.91,117.72 147.38,119.24 140.14,119.24 137.48,121.91 132.52,121.91 v2(131.76,121.14)
  BOTTOM w0.254: PR6003.1 144.69,58.8 143.8,59.7 142.12,59.7 141.21,60.61 141.18,60.61 141.18,60.64 PC6033.1 140.88,60.64
  BOTTOM w0.508: v2(79.34,91.76) 78.78,92.32 72.32,92.32 71.44,91.43 PR9284.1 PR9289.1
  vias: v1(125.5,65.23) v1(126.08,65.23) v1(126.67,65.23) v1(127.25,65.23) v1(136.74,59.56) v1(136.74,58.93) v1(138.49,55.93) v1(139.96,49.62) v1(141.84,58.19) v1(142.05,57.64) v1(142.06,58.73) v1(143.84,58.96) v1(143.84,58.38) v1(143.84,57.8) v2(55.94,115.81) v2(77.28,16.12) v2(77.28,15.48) v2(77.91,16.12) v2(77.91,15.48) v2(79.31,122.41) v2(80.45,121.65) v2(81.72,121.53) v2(81.67,120.79) v2(82.41,120.76) v2(82.61,121.53) v2(125.38,35.7) v2(126.06,35.7) v2(126.75,35.7) v2(132.4,63.87) v2(140.93,36.74) v2(141.57,36.74) v2(142.2,36.74) v2(142.84,36.74) v3(72.96,103.11) v3(72.96,102.35) v3(72.96,101.33) v3(72.96,100.57)
+VIN_BLIGHT:
  vias: v2(63.31,106.54) v3(63.82,107.81) v3(64.02,107.1) v3(64.55,107.61)
+VIN_GPU:
  vias: v2(77.79,104.76)
AVDD2: length 4.7
  BOTTOM w0.203: U30.40 204.13,22.99 204.28,22.85 204.28,21.83 204.02,21.57 C619.1 ; v2(205.27,20.26) 205.16,20.14 L13.2
  BOTTOM w0.381: L13.2 204.28,20.69 204.02,20.95 C619.1
DVDD_IO: length 6.2
  TOP w0.381: v2(198.82,27.47) 198.27,27.47 C385.1 ; C385.1 198.19,27.92 197.8,28.31 R373.2 ; C385.1 R374.1
  BOTTOM w0.203: v2(198.82,27.47) 198.74,27.55 198.31,27.55 198.06,27.79 C661.1 199.2,27.93 199.47,27.66 U30.9
GND: length 1665.5
  TOP w0.079: U2031.N2 69.86,35.63 70.32,35.63
  TOP w0.102: 70.32,35.63 70.57,35.88 v2(70.57,36.13) ; U2031.A6 67.61,28.24 v2(67.42,28.05) ; v2(57.85,101.71) 57.85,102.09 57.23,102.71 Q4.4
  TOP w0.152: U2031.C4 68.13,30.86 v1(67.99,30.86) ; U2031.N5 U2031.P6
  TOP w0.203: R460.1 206.89,16.5 v2(206.94,16.55) ; R2214.1 v2(122.49,121.73) R8042.2 ; v2(51.62,76.96) 51.62,76.95 C2684.2 ; C2224.2 v2(149.69,85.33) ; v2(41.96,54.49) 41.87,54.59 C2679.2 C2710.2 ; v2(117.56,107.56) 117.48,107.48 C2254.2 ; C2412.2 29.75,45.58 v2(29.5,45.83) ; U13.91 180.16,26.16 v2(180.1,26.22) ; v2(144.77,114.19) 144.74,114.17 C2232.2 ; C2231.2 v2(132.83,105.02) ; C2280.2 v2(116.65,98.28) ; v2(47.24,16.72) 46.66,16.13 PR118.1 ; C61.2 56.54,107.4 R27.2 55.81,107.78 v2(55.64,107.96) ; v2(32.32,83.43) 32.32,82.89 32.68,82.54 33.7,82.54 U2018.T7 ; C2685.1 31.07,77.96 C2351.1 ; v2(45.93,42.47) 45.63,42.77 C2431.2 ; C2709.2 v2(51.62,73.77) ; U5.9 16.99,54.89 v2(16.57,54.47) ; R235.1 16.29,47 v2(15.94,47.36) ; C2696.2 32.48,32.53 v2(32.7,32.75) ; v2(42.48,78.09) 42.35,78.22 C2350.1 R2338.2 ; R730.2 105.12,42.5 104.71,42.91 v1(104.51,42.91) ; v2(147.44,116.72) 147.44,116.73 C2219.2 ; v2(120.07,96.54) 119,96.54 C2291.2 ; PU1.3 65.27,119.28 v2(65.04,119.06) ; v1(66.6,34.38) 66.6,33.89 U2031.K8 ; C2307.2 143.73,95.36 v2(143.85,95.23) 143.99,95.36 C2210.2 ; v1(121.73,53.31) 121.97,53.31 R2350.1 ; R2693.2 40.22,31.33 v2(39.94,31.61) 39.66,31.33 C2688.1 ; C2494.1 C2496.2 87.31,56.98 v1(87.34,57.01) ; v2(51.57,84.57) 51.45,84.44 C2680.2 ; C2198.2 v2(149.69,106.92) ; v2(133.58,92.59) 133.58,92.62 133.57,92.63 C2321.2 ; C2213.2 141.95,102.11 v2(141.9,102.06) ; C491.1 v2(38.92,5.14) ; C451.2 213.55,19.04 213.04,19.55 v2(212.75,19.55) 212.75,19.07 212.81,19.01 C450.2 ; C2259.2 133.95,104.66 134.13,104.85 v2(134.13,104.97) ; R2668.1 111.31,124.07 111.62,124.37 v2(111.82,124.37) ; R12296.2 128.61,121.2 v2(128.37,120.95) ; v2(184.47,21.7) 184.31,21.55 R421.1 ; C2344.2 144.73,84.64 v2(144.78,84.59) ; C2687.1 31.02,40.68 31.33,40.37 v2(32.37,40.37) ; v2(207.43,17.33) 207.38,17.39 R446.1 ; C2502.2 87.16,53.99 v1(87.34,53.81) ; v1(99.67,31.25) 100.01,30.9 C2512.2 ; C2228.2 141.58,106.29 v2(141.58,106.18) ; U15.23 122.44,19.21 122.32,19.34 v2(121.68,19.34) 121.68,19.06 121.83,18.91 C432.2 C413.2 ; R376.2 97.49,36.84 97.35,36.99 96.75,36.99 v1(96.67,36.91) ; v2(67.88,17.39) 68.18,17.69 R464.1 ; C2480.2 96.01,50.63 C2481.2 ; C478.2 C477.2 173.7,12.79 v2(173.54,12.95) 173.62,13.03 U13.49 ; v2(143.58,117.08) 143.44,117.08 143.16,116.8 C2217.2 ; U2014.T7 34.02,47.23 33.34,47.23 32.98,46.87 31.15,46.87 30.79,47.24 C2410.2 ; C365.2 173.31,31.05 v1(173.42,30.95) ; v1(54.75,58.23) 54.75,58.48 54.95,58.69 R2283.1 ; v2(184.51,18.3) 184.28,18.53 R459.2 ; C2470.1 38.54,42.91 38.92,42.53 38.92,42.43 v2(38.95,42.4) 38.7,42.15 C2694.2 ; C2260.2 135.85,104.61 v2(135.85,105.12) ; U2014.T1 33.74,52.31 31.56,52.31 30.89,52.97 C2703.1 30.39,52.97 30.01,53.35 v2(30.01,53.83) ; v2(163.76,30.97) 163.51,31.23 C370.2 C374.1 ; U5.8 18.02,55.68 v2(18.22,55.49) ; C2245.2 143.42,104.97 v2(143.35,104.9) ; C2253.2 119.82,107.05 120.08,107.3 v2(120.08,107.63) ; C2211.2 v2(149.69,86.47) ; C2347.2 v2(147.21,82.88) ; v2(30.08,22.9) 30.62,22.9 31.43,22.08 R785.1 ; v2(51.53,32.29) 51.49,32.24 C2700.2 ; v2(145.08,82.86) 144.76,82.54 C2346.2 ; v2(141.67,105.27) 141.31,104.92 C2270.2 ; C2715.1 51.6,74.92 v2(51.63,74.94) ; U11.8 17.56,35.49 17.28,35.22 v2(17.28,35.09) 17.68,34.69 U11.9 ; PR283.2 194.53,30.95 v2(194.63,30.85) ; v2(120.04,104.32) 119.59,104.76 C2263.2 ; U11.3 v2(20.51,35.09) ; D3.1 17.85,83.92 v2(17.71,84.06) ; C2225.2 v2(149.69,91.05) ; U2031.J5 68.38,33.38 v1(68.64,33.64) ; U13.1 v2(164.4,28.16) ; v2(114.79,95.87) 115.66,96.74 C2312.2 ; v2(112.58,96.63) 112.84,96.89 C96275.2 R77828.2 113.76,98.12 v2(113.6,98.28) 113.34,98.28 113.09,98.03 C2298.2 ; R2311.2 114.71,38.73 C2567.2 ; v2(149.69,110.98) C2241.2 149.18,111.39 149.42,111.63 C2658.1 ; v2(146.38,108.58) 146.8,108.58 147.19,108.97 C2240.2 ; C2273.1 119.1,102.77 118.78,102.45 C96274.2 ; C2342.2 146.91,89.66 v2(146.38,90.19) ; R471.1 R477.1 v2(206.94,13.83) ; R6593.2 v2(31.3,89.52) ; R2229.2 114.26,119.21 v2(114.49,118.99) 114.71,119.21 R2230.2 ; D4.1 19.73,84 v2(19.8,84.06) ; v2(119.14,111.16) 118.68,110.7 C2235.2 ; v2(144.78,86.19) 145.26,86.67 C2343.2 ; v2(57.29,108.14) 57.95,107.48 R19.2 ; C2208.2 v2(149.69,88.76) ; C2702.1 49.24,36.41 v2(48.96,36.69) ; U5.3 v2(19.85,55.29) ; C2686.1 51.57,45.07 v2(51.62,45.12) ; v2(107.2,120.34) 106.83,120.71 R77861.1 ; R720.2 201.99,32.8 v2(201.46,33.34) ; C2718.1 31,74.82 31.1,74.92 33.47,74.92 33.67,75.12 v2(33.67,75.13) 34.07,75.53 U2017.T1 ; R817.1 26.35,18.68 v2(25.97,19.06) ; v2(146.07,104.13) 145.45,104.76 C2255.2 ; R2240.2 143.61,111.92 v2(143.98,112.29) ; v2(206.94,12.94) 206.82,12.81 R485.1 ; C96274.2 118.35,101.86 R2665.2 ; C96274.2 118.91,101.86 119.44,101.33 120.31,101.33 v2(120.69,100.95) ; C2579.1 96.44,29.81 96.1,29.48 C2517.2 ; v2(38.67,78.6) 38.67,78.35 38.37,78.04 R2685.2 C2690.2 ; v2(41.84,31.61) 41.69,31.45 R2694.1 ; R698.2 158.98,29.73 v2(159.04,29.67) ; R2301.1 v2(43.49,64.88) ; R6520.2 13.4,14.08 13.14,13.83 v2(12.63,13.83) ; C2386.2 C2714.2 ; U2031.H10 65.34,32.87 v2(65.11,32.65) ; C2319.1 C2318.1 47.46,32.1 v1(48.07,32.7) ; C490.1 v2(35.62,4.66) ; v2(41.21,64.88) 41.31,64.98 41.31,65.53 C2681.2 ; v2(48.83,34.05) 49.03,34.25 C2704.1 ; C2697.2 43.02,31.45 v2(42.86,31.61) ; v2(48.96,54.49) 49.31,54.85 C2369.2 C2368.1 ; v2(12.33,16.12) 12.74,15.71 R6518.2 ; R2253.2 142.4,86.97 v2(142.34,87.02) ; v1(106.18,42.91) 106.54,43.26 R385.2 R732.2 ; R77854.1 112.36,118.51 v2(112.23,118.38) 111.92,118.38 111.16,119.14 R77865.1 ; v2(45.78,78.09) R2339.1 ; R223.1 v2(16.13,48.73) ; C2212.2 v2(149.69,84.19) ; v2(40.09,64.88) 40.17,64.94 C2711.2 ; R466.1 206.8,15.61 206.87,15.68 v2(206.89,15.68) ; C2227.2 C2266.2 v2(134.22,117.87) C2196.2 ; R2661.1 108.87,122.01 v2(109.23,121.65) ; R2692.2 36.41,44.08 36.92,44.6 v2(36.92,45.11) ; v2(144.78,106.18) 144.66,106.3 C2252.2 ; C2207.2 v2(149.69,92.19) ; C2323.1 C2322.1 56.14,31.66 55.58,32.22 v2(55.58,32.34) ; v2(36.03,76.06) 36,76.08 C2693.1 ; R2232.1 125.16,118.73 125.44,119.01 v2(125.44,120.18) R8104.2 ; C386.2 184.11,26.28 184.47,26.63 v2(184.47,26.86) ; v1(115.71,38.09) 116.55,37.24 R2390.1 ; v2(51.62,78.71) 51.6,78.73 C2349.1 ; v2(51.53,51.58) 51.85,51.9 R2270.2 ; C2695.2 45.37,54.65 v2(45.53,54.49) ; C2221.2 147.22,114.14 v2(147.18,114.18) ; v2(143.98,93.39) 143.67,93.7 C2317.2 ; v2(207.17,19.67) 207.17,18.63 206.82,18.27 R436.1 ; C2214.2 146.85,106.39 v2(147.37,106.92) ; C2223.2 v2(149.69,82.92) ; C2197.2 v2(149.69,109.97) ; v2(144.8,94.17) 144.88,94.09 C2320.2 ; C676.1 175.67,32.72 175.78,32.83 v2(175.78,32.98) ; U2031.P6 v1(67.61,36.38) ; v2(36.26,121.39) 36.47,121.17 C498.2 ; C2215.2 v2(142.43,100.11) C2199.2 ; v2(17.46,88.38) 17.31,88.53 R93.1 ; C2678.2 C2385.1 35.78,64.99 v2(35.72,64.94) ; R2236.1 139.16,116.67 v2(139.2,116.63) ; R281.1 209.58,25.59 v2(209.41,25.41) ; v2(166.81,33.01) 166.81,32.22 C372.2 ; v2(28.71,20.2) 29.02,19.9 U2032.9 ; v2(214.31,18.4) 214.16,18.25 C449.2 ; C2490.2 91.35,59.38 v1(91.31,59.41) ; C2682.2 43.34,54.78 v2(43.62,54.49) 43.91,54.78 C2701.1 ; v2(119.72,47.31) 119.14,46.72 C8165.2 ; C2242.2 142.58,82.18 142.98,82.58 v2(143.36,82.58) ; C2380.2 38.19,31.58 v2(38.16,31.61) R2696.2 ; R6519.2 24.6,17.26 v2(24.88,16.98) ; R355.2 199.61,22.08 199.46,22.24 v2(198.79,22.24) ; R275.2 206.54,21.48 206.87,21.14 v2(207.05,21.14) ; R2300.2 42.1,65.01 v2(41.97,64.88) ; v1(31.2,34.25) 31.07,34.12 C2698.2 ; v2(36.92,68.71) 36.41,68.2 R2688.2 ; C2308.2 145.51,96 v2(145.76,96.24) ; C2244.2 C2233.2 145.79,112.23 v2(145.58,112.44) ; PU7.11 PU7.15 ; C2352.2 34.13,55.87 v1(33.63,56.37) ; C2195.2 v2(149.69,89.9) ; C2243.2 145.63,81.39 v2(145.38,81.13) ; R2642.1 v2(149.69,114.03) ; C2218.2 145.67,115.87 v2(145.58,115.78) ; v2(169.63,32.45) 169.61,32.42 C364.2 R348.2 ; v2(51.62,86.6) C2713.2 ; C2492.1 87.16,55.58 v1(87.34,55.41) ; v2(145.58,108.58) 145.58,108.62 144.85,109.34 C2234.2 ; v2(32.32,3.29) 32.32,2.91 32.19,2.78 R501.2 ; v2(147.76,93.79) 147.67,93.89 C2313.2 ; R6510.1 v2(23.81,22.92) ; R6527.1 v2(23.35,16.37) ; R2689.2 40.98,42.56 40.83,42.4 v2(40.19,42.4) ; C2269.2 v2(149.69,107.94) ; U2031.E7 67.11,31.37 66.59,30.85 v1(66.41,30.85) ; v1(67.63,32.63) 67.88,32.38 U2031.G5 ; R440.1 162.24,20.43 162.29,20.38 v2(162.29,20.31) ; U2031.P4 68.61,36.16 v1(68.39,36.38) ; C2229.2 v2(149.69,108.95) ; RV8.1 v2(9.31,11.92) ; v2(24.19,47.74) 24.12,47.66 R234.2 ; C2789.1 v2(23.1,19.67) ; v2(29.65,69.16) 29.65,69.18 29.68,69.21 C2381.2 ; D16.1 130.62,20.8 v2(130.53,20.89) ; U13.104 v2(176.82,28.6) ; RV9.1 v2(9.33,10.65) ; v2(20.32,27.91) 20.46,28.05 PU6.11 ; 164.53,17.64 164.65,17.76 U13.27 ; C2340.2 143.1,89.93 v2(143.21,90.05) ; v1(119.79,51.7) 119.92,51.83 R2352.1 ; v2(120.92,121.14) 120.97,121.09 R2211.1 ; v2(123.25,124.27) R2213.1 ; v2(197.01,24.5) 197.29,24.5 197.58,24.78 R375.1 ; C395.1 v2(62.19,24.24) ; PC79.1 143.64,35.61 143.47,35.77 PR230.1 ; v2(51.6,81.44) 51.52,81.52 C2712.2 ; C2345.2 143.22,81.51 v2(143.47,81.26) ; v2(41.34,78.07) C2733.2 ; C2341.2 v2(145.01,88.57) ; R8041.2 R2212.1 v2(122.19,125.31) ; v2(117.36,104.2) C2258.2 ; R6590.2 97.38,77.71 97.42,77.75 v2(97.42,78.24) 97.39,78.24 97.37,78.22 97.09,78.22 R2550.2 ; C2209.2 v2(149.69,87.62)
  TOP w0.254: v2(29.91,74.64) 29.91,74.66 30.06,74.82 C2718.1 ; U2013.N9 36.53,33.88 v2(36.76,33.64) ; U16.12 v2(64.66,20.61) ; v2(38.01,56.02) 37.75,55.76 C2469.2 ; U2014.H9 40.61,45.44 40.61,44.91 40.18,44.48 v2(40.13,44.48) ; U17.18 213.04,16.37 v2(213.14,16.27) ; C2689.1 35.9,55.72 36.33,56.15 v2(36.41,56.15) ; U16.13 64.16,20.39 v2(63.94,20.61) ; v2(36.92,80.06) 36.92,80.11 U2018.N9 ; U17.13 v2(210.25,13.45) ; U16.10 v2(65.66,20.61) ; U16.5 v2(66.16,15.78) ; PR6016.2 153.19,51.61 v1(153.7,51.1) 153.25,50.65 PR6009.1 ; U2014.N9 36.92,45.13 v2(36.92,45.11) ; U17.3 U17.21 ; v2(36.92,68.71) 36.92,68.73 U2017.N9
  TOP w0.305: U2013.K9 38.53,33.75 v2(38.53,33.73) ; v1(87.18,51.04) 86.67,50.52 C2509.2 C2510.2 ; v2(65.04,119.06) 65.19,118.91 PC18.2 ; U2013.T7 32.83,35.75 v2(32.75,35.67) ; v2(39.31,80.13) U2018.K9 ; U7.14 19.31,48.88 v2(19.59,49.16) ; C453.1 184.47,17.51 v2(184.59,17.64) ; C2515.2 87.22,48.37 v1(87.05,48.54) ; Q4.4 57.23,103.86 57.42,104.06 57.97,104.06 v2(58.15,103.88) ; v2(124.27,21.83) 123.94,22.16 U15.16 ; C61.2 56.71,107.56 v2(57.29,108.14) ; v2(12.33,16.12) RV1.3 RV1.8 10.25,16.12 v2(10.12,15.99) ; U2017.T7 33.98,70.88 32.25,70.88 31.73,70.36 v2(30.8,70.36)
  TOP w0.356: U2013.F1 v2(41.73,40.95) 41.65,41.03 41,41.03 U2013.H1 v2(40.13,40.95) 40.01,41.07 39.44,41.07 U2013.K1 ; U2014.D2 v2(44.13,51.53) ; v2(40.93,68.7) 40.93,68.73 U2017.H9 ; U2017.D2 44.11,75.12 v2(44.11,75.13) ; v2(44.93,45.95) 44.93,45.93 U2014.C9 ; U2014.G8 40.93,46.72 v2(40.89,46.72) ; PR84.1 147.3,36.5 v2(146.9,36.11) ; U2014.K9 39.98,44.48 v2(40.13,44.48) ; U2013.C9 44.13,33.75 v2(44.11,33.75) ; v2(46.65,33.78) 46.65,34.43 U2013.A8 ; v2(41.34,78.07) 41.34,77.9 39.26,75.82 39.22,75.82 U2017.K1 ; U2013.E8 43.3,34.58 v2(43.3,34.55) ; U2014.A8 46.5,45.95 v2(46.53,45.95) ; v2(42.53,75.93) 42.53,75.93 U2017.E1 ; U2017.F1 v2(41.73,75.93) ; v2(43.7,37.48) 42.93,38.25 U2013.E3 ; U2014.E3 v2(43.33,50.73) ; v2(36.31,41.05) 36.53,40.84 U2013.N1 ; U2014.B2 v2(45.73,51.53) 46.13,51.13 U2014.A2 ; v2(42.54,70.32) 42.54,70.29 42.9,69.93 U2017.E8 ; U2013.D8 v2(44.13,34.55) ; U2013.E1 43.33,40.15 v2(43.33,40.15) 43.33,40.15 U2013.D2 ; v2(40.93,33.75) U2013.H9 ; U2014.H1 v2(40.93,51.53) ; U2018.A2 46.53,86.51 v2(46.54,86.51) ; v2(42.53,81.68) 42.55,81.68 U2018.E8 ; v2(41.74,72.88) 41.89,72.89 U2017.E3 ; U2018.D8 v2(44.13,80.91) ; U2013.G8 v2(40.93,34.55) ; v2(45.74,75.13) 45.73,75.13 U2017.B2 ; v2(36.26,52.69) 36.53,52.42 U2014.N1 ; C2386.2 45.39,65.91 v2(44.89,66.41) ; U2014.E1 v2(42.53,51.53) U2014.F1 ; U2018.G8 v2(40.93,80.91) ; U2017.C9 v2(44.11,69.54) ; U2017.H1 v2(40.93,75.13) ; v2(44.11,86.51) 44.11,86.49 U2018.D2 ; v2(46.54,75.13) 46.53,75.13 U2017.A2 ; U2014.K1 39.22,52.22 39.22,52.35 40.18,53.31 v2(41.22,53.31) ; U2018.C9 44.53,80.45 v2(44.9,80.07) ; U2018.F1 42.13,86.99 v2(42.51,87.33) 42.93,86.96 U2018.E1 ; U2018.T1 33.6,87.43 v2(33.29,87.43) ; v2(41.72,84.29) 41.91,84.29 U2018.E3 ; U2013.A2 46.13,39.73 v2(45.73,39.33) 45.33,39.73 U2013.B2 ; v2(45.73,80.87) 46.13,81.27 U2018.A8 ; v2(39.31,87.38) 39.31,87.29 U2018.K1 ; v2(40.91,87.33) 40.91,87.29 U2018.H1 ; v2(36.53,88.06) U2018.N1 ; U2017.K9 v2(39.33,68.73) ; U2017.A8 v2(46.53,69.53) ; U2017.D8 v2(44.13,70.33) ; v2(45.74,86.51) 45.73,86.51 U2018.B2 ; U2013.T1 32.55,40.55 v2(32.37,40.37) ; U2017.N1 36.53,75.56 v2(36.03,76.06) ; U2018.H9 v2(40.93,80.11) ; v2(40.93,69.5) 40.93,69.53 U2017.G8
  TOP w0.381: v2(59.32,110.64) 59.35,110.61 C532.1 ; PC2.2 PC1.1 65.16,125.47 v2(65.04,125.59) ; C2384.2 38.68,66.09 v2(38.49,66.28) ; v1(89.71,55.41) 89.93,55.19 C2547.2 91.12,55.19 v1(91.34,55.41) ; PC79.1 143.93,36.16 v2(143.85,36.24) ; C368.1 22.56,31.73 v2(22.41,31.58) ; C2396.1 52.57,57.91 v1(52.87,58.2) 52.87,58.63 53.52,59.29 C2377.2 ; Q4.1 55.93,102.32 55.8,102.45 v2(55.41,102.45) ; R2719.2 v2(23.56,15.35) ; PC101.2 v2(25.6,25.64) ; C2537.2 90.87,48.25 90.89,48.22 C2485.2 91.49,48.64 91.27,48.86 v1(91.27,48.98) ; HE2.3 v2(45.3,122.41) ; R6516.1 v2(18.1,19.16) ; v1(48.96,67.93) 49.34,67.93 49.72,68.31 C2376.1 C2379.1 ; C37.1 v2(53.41,109.25) ; Q2039.1 v2(25.78,21.59) ; C352.2 21.28,37.06 v2(21.02,37.32) ; v1(88.11,64.21) 88.7,64.8 C2474.2 89.17,64.8 v1(89.74,64.23) ; C384.2 184.23,28.82 v2(184.47,28.58) ; C454.2 v2(216.99,17.13) ; v2(89.72,123.71) PC9047.2 ; C2567.2 115.45,38.35 v1(115.71,38.09) ; C2410.2 29.62,47.24 v2(29.5,47.36) ; C711.1 v2(12.63,13.83) ; C239.2 v2(20.37,88.63) ; C373.2 159.13,29.58 v2(159.04,29.67) ; PQ10.1 124.07,36.76 v2(123.76,37.07) ; v2(42.73,102.48) C93.2 ; PC9164.2 196.09,31.92 v2(195.9,32.12) ; PC6039.2 102.37,60.44 v1(102.5,60.31) ; C377.2 201.99,19.29 v2(202.14,19.14) ; v2(18.5,26) 18.5,26.3 18.85,26.65 PC98.2 PC92.2 ; PC6041.2 102.29,54.27 v1(102.55,54.01) ; v2(135.7,122.54) 135.66,122.54 PR77859.2 ; L9.2 187.31,16.24 v2(187.64,16.57) ; U26.34 21.66,80.88 C222.2 ; PQ9069.1 129.29,120.06 v2(129.09,120.26) ; v1(89.07,66.43) 88.69,66.82 C2472.2 ; C39.2 v2(43.11,109.98) C45.2 ; v1(90.48,63.41) 89.72,62.65 C2475.2 90.17,62.16 v1(90.51,61.81) ; C2311.1 51.37,30.34 v2(51.88,30.85) 51.37,31.36 C2310.2 ; v2(162.29,20.31) 162.3,20.3 C440.1 ; v1(94.42,34.53) 94.68,34.53 95.02,34.18 C2516.2 95.02,33.55 95.26,33.31 C2498.2 ; R130.1 117.93,40.11 118.21,39.82 118.21,38.38 v2(118.17,38.34) ; PC87.2 v2(26.22,29.32) ; C2706.1 46.14,77.46 45.78,77.81 v2(45.78,78.09) ; C367.1 181.3,30.54 v2(181.29,30.54) ; v2(53.66,51.55) 53.41,51.79 C2389.1 ; v1(88.91,51.41) 88.71,51.61 C2526.2 ; U8022.2 v2(115.76,46.72) ; Y1.2 v2(43.09,113.18) ; C2487.2 91.93,51.26 v1(92.11,51.43) ; v2(116.52,22.65) 116.27,22.4 C396.2 ; v2(192.09,25.21) 192.09,25.21 192.09,25.54 192,25.62 PC6229.1 ; v2(45.12,31.61) 45.03,31.52 C2434.2 ; PC93.2 v2(26.22,28.31) ; v2(184.47,13.45) 184.33,13.31 C480.1 ; v1(88.99,47.46) 88.83,47.3 C2532.2 ; v1(95.88,26.29) 96.33,26.29 U2021.2 ; v1(99.51,54.51) 99.48,54.47 PC6040.2 ; C2536.2 110.68,46.09 111.05,46.46 v1(111.31,46.46) ; v2(112.68,121.91) 111.67,120.89 U2028.4 ; C2546.2 97.6,57.01 97.98,56.63 v1(97.98,56.5) ; v2(214.69,17.39) 214.69,17.26 214.19,16.76 C461.2 ; C58.2 C65.2 50.82,106.31 v2(50.82,106.29) ; C2476.2 87.15,59.13 v1(87.41,59.39) ; C397.2 v2(117.28,22.65) ; v3(139.37,41.24) 139.36,41.22 PC245.2 ; C2486.2 91.35,47.26 v1(90.89,46.8) ; C2377.2 54.04,58.53 54.34,58.23 v1(54.75,58.23) ; C2377.2 54.54,59.29 54.67,59.42 56.2,59.42 56.33,59.29 C2394.1 ; v2(51.75,48.35) 51.73,48.37 C2731.2 ; v2(22.54,34.78) 23.04,34.28 C363.1 ; v2(48.98,104.29) 49.2,104.51 R30.1 ; v2(73.19,20.13) 73.22,20.1 C439.2 ; C22.2 47.44,109.85 v2(47.31,109.71) ; C2705.1 46.41,42.95 v2(45.93,42.47) ; PR567.1 42.56,24.18 v2(42.56,24.75) ; v2(119.89,97.69) 119.68,97.9 119.03,97.9 R2662.1 ; v2(11.63,20.05) D39.1 ; D21.1 v2(39.52,120.72) ; v1(86.14,66.42) 86.68,65.88 C2477.2 87.34,65.61 v1(87.49,65.46) ; v2(36,120.64) 35.82,120.64 HE1.3 ; PR77854.2 90.83,96.54 91.56,95.81 PQ9065.1 v2(93.15,95.81) ; C31.2 C42.2 42.86,99.81 v2(42.73,99.68) ; v2(184.41,23.11) C390.2 ; C399.2 v2(119.31,22.65) ; v1(88.07,50.6) 88.53,50.6 C2514.2 C2531.2 C2538.2 90.98,50.41 91.32,50.08 91.32,49.71 v1(91.33,49.7) ; v1(87.34,61.01) 87.34,61.11 C2479.2 ; C2782.2 24.84,13.68 v2(24.94,13.58) ; v1(89.71,53.81) 89.85,53.67 C2551.2 91.2,53.67 v1(91.34,53.81) ; v2(194.93,27.04) 195.13,26.83 195.13,26.2 PU3003.2 ; C183.2 14.95,88.25 v2(15.35,88.66) 15.77,88.24 VC1.2 ; v2(25.21,56.13) C287.1 ; v2(162.7,35.99) 162.49,35.78 D10.2 C381.2 ; v2(66.16,15.78) 66.16,15.55 66.49,15.22 C467.2 ; C249.2 23.31,88.38 v2(23.94,88.38) ; C210.2 18.62,81.16 v2(18.4,81.16) ; C2579.1 96.96,30.09 v1(97.09,29.96) ; v2(48.96,52.46) 49.1,52.31 C2674.2 ; C387.1 v2(184.97,24.24) ; C2692.1 46.15,54.71 45.93,54.49 v2(45.53,54.49) ; v1(48.96,63.59) 49.57,63.59 49.72,63.74 C2390.2 50.1,63.75 C2388.2 ; C2663.2 117.5,125.46 v2(117.03,125.46) ; v2(59.75,51.55) 59.75,51.42 60.13,51.04 C2405.2 ; C398.2 v2(118.3,22.65) ; v2(147.28,105.16) 147.64,104.8 C2268.1 ; C280.2 v2(22.03,56.87) ; PR9135.2 132.94,122.54 v2(132.78,122.54) ; v2(52,114.03) 52.26,113.78 C29.1 ; v2(43.09,112.38) 43.09,111.52 43.23,111.37 C32.2 ; C385.2 196.91,27.55 v2(196.66,27.8) ; PC6042.2 102.04,57.2 102.04,57.62 v1(102.3,57.87) 102.13,58.03 PC6037.2 ; Q3.1 v2(56.05,110.6) ; v1(100.11,57.47) 100.05,57.53 PC6038.2 ; v2(150.98,55.21) 151.36,54.84 PC6001.1 ; Y1.4 45.85,112.09 v2(46.19,111.75) 46.19,111.36 C33.1 ; C2351.1 v2(29.25,77.96) ; PC2001.2 PC2002.2 145.42,40.44 v2(145.09,40.76) ; v2(67.88,17.39) 67.88,17.07 68.14,16.8 C464.2 ; v2(123.88,121.4) C2185.2 ; PC99.2 v2(26.22,27.29) ; v2(62.8,20.61) 62.63,20.44 C436.2 ; C28.1 v2(55.19,109.26) ; v2(24.32,53.57) C295.1 ; R6.1 v2(42.23,112.38) ; C270.2 v2(22.08,59.43) ; C2216.1 139.47,116.36 v2(139.2,116.63) ; v2(165.16,33.01) C371.2 ; C2406.2 54.42,51.7 v2(54.54,51.57) ; C2513.2 v1(99.88,28.05) C2499.2 ; PC6043.2 100.1,53.5 v1(100.1,53.5) ; C2267.1 146.28,96.76 v2(145.76,96.24) ; v2(216.47,41.64) 216.1,42.01 C343.2 v2(216.98,42.53) ; v2(69.33,125.58) 69.23,125.58 69.13,125.48 PC3.2 ; v1(102.91,55.31) 102.53,55.68 PC6045.2 ; C465.2 v2(216.09,12.94) ; C345.2 v2(21.02,39.62) ; C182.2 v2(23.94,87.64) ; C438.1 v2(12.25,18.4) ; v2(70.54,20.13) C460.2
  TOP w0.406: PC6002.1 140.11,54.39 139.91,54.59 138.96,54.59 138.84,54.71 v2(138.58,54.71)
  TOP w0.457: PQ13.1 46.94,16.72 v2(47.24,16.72)
  TOP w0.508: PC9188.2 116.39,110.37 v2(115.81,110.96) ; v2(36.13,22.72) 37.15,22.72 37.62,23.19 PC551.1 ; v2(48.96,89.04) 49.25,89.33 C2691.1 ; PC9187.2 v2(111.52,109.08) ; v1(117.28,109.21) 117.41,109.08 117.47,109.08 C2246.1 ; C97.2 26.86,102.35 v2(26.22,101.71) ; v2(85.93,27.48) 85.96,27.44 85.96,26.86 85.56,26.45 84.96,26.45 C2511.2 ; v2(150.18,13.45) 150.18,14.46 148.92,15.72 Q20.1 ; v2(28.88,44.65) C2448.1 ; C2273.1 119.1,103.55 v2(118.44,104.21) ; v2(29.63,67.57) C2403.1 ; C2416.1 v2(32.81,29.45) ; D19.1 v2(15.81,8.24) ; C2533.2 90.32,30.5 v2(90.99,29.83) 91.54,30.37 C2539.2
  BOTTOM w0.102: U2029.C21 121.94,103.69 121.94,102.66 U2029.C19 ; 105.85,121.4 105.24,120.79 105.24,119.65 105.09,119.49 105.09,118.44 104.32,117.66 102.76,117.66 102.53,117.89 101.79,117.89 101.03,117.13 101.03,115.71 101.3,115.43 U2029.AY41 ; R559.1 v2(101.81,87.88)
  BOTTOM w0.152: U2029.A17 123.42,101.52 123.56,101.38 123.96,101.38 v2(124.14,101.21) ; U2029.A21 123.6,103.72 124.08,103.24 v2(124.33,103.24) ; v2(125.36,105.07) 124.93,105.5 124.3,105.5 123.88,105.92 U2029.A25 ; v2(124.41,107.86) 123.98,108.29 123.47,108.29 U2029.A29
  BOTTOM w0.178: U26.14 v2(20.25,74.71)
  BOTTOM w0.198: PR86.1 136.66,28.74 PU12.34 ; PU12.22 133.02,29.98 PU12.36
  BOTTOM w0.203: C2574.2 89.95,27.5 v2(89.83,27.62) ; R6515.2 13.75,17.03 v2(14.03,16.75) ; D27.1 v2(14.46,82.85) ; C2672.1 147.02,79.22 146.69,79.55 R2678.1 ; v2(122.08,119.01) 121.68,118.6 R2638.1 ; D28.1 v2(14.46,81.08) ; v2(13.17,78.98) 13.23,79.04 D30.1 ; R2355.1 120.33,51.17 v1(119.79,51.7) ; v1(111.31,46.46) R2503.2 ; C2569.1 104.71,80.25 ; R77861.1 106.83,120.71 v2(107.2,120.34) ; v2(136.76,83.81) 136.76,84.58 VRAM2002.E12 ; R8485.1 v2(124.37,89.22) ; v1(105.85,39.69) v1(105.85,40.28) ; 120.03,120.69 119.72,120.69 R2636.1 119.92,120.13 120.33,120.13 120.53,119.92 120.53,119.32 120.2,118.99 R2637.1 ; VRAM2001.N1 137.57,106.18 137.57,106.99 VRAM2001.N3 ; v2(123.99,99.17) 123.84,99.32 U2029.A13 ; 96.62,97.64 96.48,97.78 R2673.2 ; v1(91.11,36.37) 91.15,36.33 R2361.1 91.15,35.46 90.57,34.88 R2365.1 90.4,34.88 89.92,34.41 R2359.1 ; R2622.1 v2(112.23,118.38) ; R2363.1 86.62,34.88 R2357.1 87.54,34.88 87.61,34.96 v1(88.28,34.96) ; R2624.1 v2(114.49,118.99) R2627.1 ; C150.2 66.51,30.95 v1(66.41,30.85) ; R834.2 212.18,17.57 212.28,17.66 212.28,18.38 v2(212.23,18.43) ; v2(67.91,104.38) 68.3,103.99 PC9013.1 ; C869.2 120.23,49.01 v1(119.72,49.01) ; v2(194.75,29.96) 194.5,29.7 194.19,29.7 C718.2 C716.2 ; VRAM2002.E3 137.58,91.79 137.58,90.99 ; R2623.1 114.23,122.03 v2(114.49,121.78) 114.74,122.03 R8053.1 ; R77856.1 117.28,122.44 v2(117.28,122.49) ; v2(15.43,76.83) D32.1 ; PC9018.2 66.77,111.3 66.36,110.89 v2(66.36,110.81) 66.52,110.66 66.57,110.66 PR9007.1 ; R22.2 v2(55.18,104.56) ; v1(96.67,36.91) 96.99,36.58 R77873.1 ; v2(212.15,34.28) 212.15,34.4 212.65,34.9 CN6.17 ; v2(110.17,42.28) 110.42,42.53 C8164.2 ; U2029.AC39 110.93,113.59 111.97,113.59 U2029.AA39 112.03,113.59 113.07,113.59 U2029.W39 113.13,113.59 114.17,113.59 U2029.U39 ; R718.1 v2(201.23,35.29) ; v2(94.85,98.92) R67859.1 C2668.1 ; R2651.1 103.6,119.01 v2(103.82,119.24) 104.18,119.6 U8021.6 ; v1(153.7,51.1) 153.38,51.42 PR6024.1 ; C2673.1 141.4,79.09 141.73,79.42 R2680.1 ; R2626.1 114.62,120.51 v2(114.49,120.38) 114.36,120.51 R2625.1 ; PC9006.2 72.32,117.87 v1(72.3,117.84) ; C2596.2 90.18,79.59 89.85,79.26 v2(89.85,78.98) ; C149.2 65.5,33.03 v2(65.11,32.65) ; v2(72.32,28.05) 72.32,28.18 72.04,28.46 C146.2 ; v2(66.17,112.83) 66.17,112.7 66.51,112.36 PC9000.2 ; v2(86.66,38.97) 86.51,39.11 U2030.BD21 ; C2671.1 130,88.91 130.33,89.24 R2675.1 ; PC9178.1 71.05,117.82 v2(71.36,117.82) 71.36,117.78 70.96,117.37 PC9011.2 ; C2666.1 94.2,97.57 v2(94.15,97.52) ; v2(129.47,113.4) R2654.1 130.01,113.04 129.72,112.75 C2662.1 ; v2(89.82,76.96) 89.82,77.02 89.64,77.2 R2521.2 ; v2(112.68,121.91) R2620.2 R2601.2 ; v2(13.17,76.44) 13.52,76.79 D25.1 ; v1(110.68,48.11) 110.82,48.11 111.09,47.84 C926.2 ; VRAM2002.B10 134.88,86.7 v2(134.88,87.57) ; R2619.2 109.56,119.27 109.21,118.91 v2(109.1,118.91) 108.97,118.91 108.62,119.26 R2618.2 ; U2029.BA17 U2029.AY17 ; J1.2 99.97,27.96 v1(99.88,28.05) ; v2(13.14,75.3) 13.43,75.01 D26.1 ; R560.1 121.06,47.51 121.17,47.41 R12317.1 R575.1 v2(121.73,46.34) ; R2502.2 95.43,79.21 v1(95.53,79.11) 95.63,79.21 R2505.2 ; R2634.1 117.48,118.99 v2(116.9,118.41) 116.75,118.57 R2633.1 ; R700.2 161.89,22.9 v2(162.2,22.58) ; v2(166.73,25.74) 166.73,25.71 166.59,25.57 C388.2 166.3,25.13 166.21,25.23 C679.2 ; CN17.1 46.95,11.7 v2(47.31,12.05) ; 125.03,118.6 R2639.1 ; C96269.2 v2(16.75,38.09) ; v1(96.51,40.2) U2030.BD10 ; D31.1 v2(14.21,78.61) ; R6517.2 12.89,18.81 v2(13.09,19.01) ; C2661.2 v2(129.98,115.71) ; R2632.1 117.21,120.51 v2(117.28,120.43) 117.36,120.51 R2635.1 ; v2(103.14,91.86) 103.2,91.93 U2029.AU1 ; v2(13.02,80.89) 13.08,80.82 D29.1
  BOTTOM w0.229: PU11.8 144.62,35.36 PC234.2 ; v2(45.03,16.65) 44.68,16.99 PU15.8
  BOTTOM w0.254: v1(78.6,70.11) 79.11,70.11 U2030.G32 ; v1(81.47,62.47) 81.47,62.47 v1(82.12,62.47) ; v2(100.3,104.45) 100.68,104.82 U2029.BA23 100.77,104.76 101.34,104.76 U2029.AY23 101.49,104.74 102.02,104.74 U2029.AW23 ; v2(54.89,50.36) 54.89,50.06 55.74,49.21 CN2019.181 ; U2030.AK8 97.71,51.13 v1(97.29,51.55) ; VRAM2002.K14 141.24,83.45 141.24,84.14 VRAM2002.K13 ; v1(97.93,64.52) 97.93,64.79 U2030.N8 ; CN2019.103 60.05,70.71 v2(60.13,70.62) ; U2030.N4 100.59,64.53 100.13,64.53 v1(100.12,64.53) ; U2030.AU13 93.75,44.81 v1(94.02,44.54) 94.02,44.5 U2030.AV12 ; v2(56.45,79.86) 56.45,79.62 56.86,79.21 CN2019.69 ; CN2019.180 52.33,49.46 52.98,50.11 v2(52.98,50.35) ; PC9001.1 65.96,114.18 v2(65.46,114.68) 65.92,115.14 PR9012.2 PR9023.1 ; CN2019.107 57.34,69.71 56.7,70.34 v2(56.7,70.6) ; v2(52.39,73.77) 51.57,72.96 CN2019.94 ; v2(100.32,101.15) 100.33,101.15 U2029.BA17 ; U2030.AM28 80.94,48.84 80.94,48.52 ; U2029.J5 118.81,95.53 v2(119.18,95.53) ; v2(54.31,33.92) 55.75,35.36 57.1,35.36 57.45,35.71 CN2019.235 ; U2029.C21 121.87,103.75 121.87,104.79 U2029.C23 121.9,105.09 121.83,105.17 121.83,105.6 121.9,105.67 U2029.C25 ; U2030.BD7 98.74,40.48 v1(98.74,40.25) ; v1(102.5,60.31) 102.4,60.21 102.25,60.21 102.06,60.01 U2030.W1 ; U2030.E20 87.34,71.59 v1(87.02,71.59) ; CN2019.243 57.27,33.71 56.92,33.36 56.1,33.36 55.8,33.65 v2(55.8,33.9) 55.8,34.04 56.47,34.71 CN2019.239 ; CN2019.196 51.29,45.46 v2(51.62,45.12) ; CN2019.56 51.75,82.46 v2(51.75,82.46) ; U2029.A37 123.83,112.52 v2(123.91,112.61) ; v1(102.3,57.87) 101.95,57.87 U2030.AA1 ; v1(87.04,46.81) 86.91,46.81 U2030.AR21 ; v1(80.91,45.56) 80.91,45.81 U2030.AR28 ; v1(80.91,45.56) 81.11,45.36 U2030.AU28 ; v1(80.91,45.56) 80.91,45.42 80.68,45.19 80.68,45.07 ; v2(53.53,45.1) 53.53,44.82 52.67,43.96 CN2019.202 ; v1(105.92,37.34) v1(104.86,38.39) 103.75,39.5 102.64,39.5 101.91,40.24 v1(101.4,40.24) ; CN2019.210 51.24,41.96 51.3,41.9 51.88,41.9 52.39,42.4 v2(52.39,42.48) 51.83,43.04 51.33,43.04 51.24,42.96 CN2019.206 ; CN2019.102 51.22,70.96 51.62,71.36 v2(51.62,71.77) 51.44,71.96 CN2019.98 ; U2030.AR14 92.95,46.85 v1(93.05,46.85) 93.15,46.85 U2030.AP13 ; v1(99.53,68.53) 99.53,68.39 U2030.K5 ; v2(57.08,86.6) 57.19,86.71 CN2019.39 ; U2029.AR35 104.3,111.46 v2(103.76,112) ; U2030.AY12 U2030.AY11 95.89,42.61 v1(96.02,42.48) ; CN2019.43 56.32,85.71 55.67,85.06 v2(55.67,84.61) ; CN2019.189 56.64,47.21 56.2,46.76 v2(56.2,46.47) 56.2,46.34 56.6,45.93 57.08,45.93 57.35,46.21 CN2019.193 ; CN2019.205 59.5,43.21 59.75,42.95 v2(59.75,42.47) ; CN2019.197 57.49,45.21 57.37,45.08 v2(57.08,45.08) ; CN2019.64 51.19,80.46 51.37,80.63 52.26,80.63 52.89,81.27 v2(52.89,81.44) ; CN2019.247 57.39,32.71 56.52,31.83 55.98,31.83 55.58,32.23 v2(55.58,32.34) ; U2030.E11 95.41,71.41 v1(95.03,71.03) ; v1(90.94,68) 90.91,68 U2030.K16 90.96,67.17 v1(91.04,67.17) 91.4,66.81 U2030.L15 ; v1(102.91,55.31) 102.2,56.01 U2030.AD1 ; v2(51.6,81.44) 51.59,81.46 CN2019.60 ; v1(100.12,64.53) 100.12,64.8 U2030.N5 100.12,65.22 v1(100.12,65.53) 100.12,65.8 U2030.M5 100.1,66.2 v1(100.1,66.53) 100.1,66.82 U2030.L5 100.07,67.17 v1(100.07,67.52) 100.07,67.85 U2030.K5 ; v1(100.12,64.53) 100.12,64.22 U2030.P5 100.13,63.79 v1(100.13,63.53) 100.13,63.23 U2030.R5 100.12,62.8 v1(100.12,62.52) 100.12,62.22 U2030.T5 ; v2(56.46,51.57) 56.46,51.94 57.23,52.71 CN2019.167 ; CN2019.68 51.21,79.46 51.62,79.86 v2(51.75,79.86) ; v2(123.77,110.59) 123.6,110.59 123.33,110.32 U2029.A33 ; U2029.AE1 109.8,91.94 109.77,91.91 v2(109.77,91.88) ; CN2019.209 57.35,42.21 v2(57.08,42.47) ; v2(71.98,123.43) 71.59,123.04 PR9305.1 71.3,122.44 71.3,122.03 PC9176.1 ; v2(51.57,84.57) 51.46,84.46 CN2019.48 ; U2030.G19 88.51,69.98 88.12,69.59 v1(88.09,69.59) ; CN2019.15 55.19,92.71 54.38,91.89 v2(54.38,91.72) ; v2(105.19,91.73) 105.4,91.95 U2029.AN1 ; U2029.AN41 105.4,115.11 v2(106.36,116.06) ; v1(85.28,65.52) 84.91,65.89 U2030.M23 ; v1(95.06,46.85) 94.95,46.85 U2030.AR12 ; PR9117.2 145.79,61.34 145.79,61.34 ; U2030.BD26 82.26,40.45 82.26,40 v2(82.08,39.83) ; U2030.AY8 97.59,42.69 v1(98.01,42.69) 98.09,42.61 U2030.AY7 ; CN2019.10 v2(51.58,93.96) ; v2(53.78,86.6) 53.78,86.47 52.77,85.46 CN2019.44 ; U2029.K21 118.59,103.13 119.09,103.13 U2029.G19 ; CN2019.201 59.52,44.21 59.75,44.44 v2(59.75,45.08) ; U2030.A30 80.11,73.33 v1(79.75,73.7) ; v1(100.09,73.87) 100.01,73.8 U2030.A5 ; v2(51.6,35.93) 51.57,35.96 CN2019.234 ; U2030.T5 99.91,62.02 99.51,62.42 v1(99.51,62.52) ; U2030.T5 100.12,61.8 v1(100.12,61.51) 100.12,61.22 U2030.V5 99.9,61.01 v1(99.41,60.51) 99.91,60.01 U2030.W5 99.51,59.61 99.51,59.51 v1(99.51,59.51) 99.51,59.5 99.51,59.41 U2030.Y5 99.91,58.68 v1(100.12,58.48) 100.12,58.22 U2030.AA5 100.11,57.81 v1(100.11,57.47) 100.11,57.21 U2030.AC5 99.51,56.61 v1(99.51,56.51) 99.51,56.41 U2030.AD5 100.11,55.81 v1(100.11,55.51) 100.11,55.21 U2030.AE5 99.51,54.61 v1(99.51,54.51) 99.51,54.41 U2030.AF5 100.1,53.82 v1(100.1,53.5) 100.1,53.48 99.91,53.3 U2030.AG5 U2030.AJ5 99.91,51.72 v1(100.1,51.53) 99.91,51.35 U2030.AK5 99.91,50.67 v1(100.1,50.48) 99.91,50.3 U2030.AL5 99.91,49.7 v1(100.12,49.49) 99.91,49.27 U2030.AM5 ; v2(118.07,115.23) 118.27,115.02 U2029.J41 118.55,114.97 118.55,114.37 U2029.J40 U2029.J39 ; CN2019.248 51.37,32.46 v2(51.53,32.29) ; v1(102.55,64.1) 102.46,64.01 U2030.P1 ; CN2019.89 57.41,74.21 57.21,74.41 56.2,74.41 55.82,74.79 v2(55.82,75) ; U2030.A3 101.36,73.31 v1(101.41,73.27) 101.41,72.91 U2030.C3 ; v2(54.4,84.61) 54.4,84.46 55.16,83.71 CN2019.51 ; 80.94,48.52 80.94,48.18 U2030.AN28 ; 80.94,48.52 v1(80.94,48.53) ; U2030.AN5 99.91,47.77 v1(100.12,47.56) 99.91,47.35 U2030.AP5 U2030.AR5 99.6,45.7 99.6,45.32 U2030.AU5 99.91,44.79 100.12,44.58 v1(100.12,44.56) 99.91,44.35 U2030.AV5 ; CN2019.172 51.41,51.46 v2(51.53,51.58) ; U2030.K32 78.93,68.01 78.6,67.68 v1(78.24,67.68) ; v2(56.46,95.99) 57.24,95.21 CN2019.5 ; PU9005.19 148.16,66.29 148.4,66.53 v2(148.52,66.53) ; v2(57.08,82.41) 57.11,82.41 57.32,82.21 CN2019.57 ; CN2019.35 57,87.71 56.45,88.25 v2(56.45,88.91) ; U2029.B1 122.7,91.64 v2(122.82,91.52) ; U2030.A21 86.51,73.93 v1(86.53,73.94) ; v1(105.85,40.28) 105.44,40.28 104.54,41.18 102.83,41.18 v1(102.78,41.23) ; U2029.N1 116.4,91.73 v2(116.39,91.73) ; U2029.BA5 100.19,94.41 v2(100.19,94.09) ; v2(51.53,39.02) 51.47,38.96 CN2019.222 ; CN2019.31 59.38,88.71 59.75,88.33 v2(59.75,88.25) ; U2030.K1 101.81,68.28 v1(102.04,68.52) ; U2039.3 194.08,24.84 193.86,24.62 v2(193.41,24.62) ; v2(57.08,81.39) 57.27,81.21 CN2019.61 ; CN14.A1 v2(8.19,13.15) ; v2(51.75,48.35) 51.73,48.35 51.7,48.37 51.51,48.37 51.43,48.46 CN2019.184 ; U2029.A2 123.43,92.9 123.43,92.21 v2(123.84,91.81) ; v2(57.08,76.95) 57.34,77.21 CN2019.77 ; U2030.E15 91.71,71.61 v1(92.04,71.61) 92.32,71.61 U2030.E14 ; v2(59.75,36.94) 59.51,36.71 CN2019.231 ; CN2019.14 v2(51.58,92.96) ; U2030.A19 88.51,73.75 v1(88.33,73.94) ; v2(56.32,36.94) 56.85,37.47 57.2,37.47 57.44,37.71 CN2019.227 ; v1(88.47,40.22) 88.47,40.22 88.47,40.67 U2030.BD19 ; v2(51.62,73.77) 51.44,73.96 CN2019.90 ; CN2019.30 51.46,88.96 51.5,88.92 v2(51.62,88.92) ; v1(102.42,69.71) 102.11,69.71 U2030.G1 ; CN2019.106 51.36,69.96 52.13,70.73 53.25,70.73 v2(53.27,70.7) ; v2(118.58,91.81) 118.6,91.83 U2029.J1 ; U2030.AL16 91.32,49.8 91.32,49.71 v1(91.33,49.7) 91.45,49.7 91.71,49.43 U2030.AM15 ; U2029.AY40 101.4,114.17 101.95,113.62 U2029.AW39 ; CN14.A12 v2(8.32,18.65) ; CN2019.171 59.59,51.71 v2(59.75,51.55) ; U2030.A7 98.51,73.95 v1(98.56,74) ; v1(102.27,66.18) 102.1,66.01 U2030.M1 ; U2030.AG8 97.94,53.24 v1(97.94,53.52) ; U2030.AV32 78.92,43.71 v1(78.92,43.61) ; PR9304.2 74.98,120.26 v1(75.03,120.31) ; v2(108.14,95.74) 108.02,95.74 U2029.AJ5 ; v2(78.17,64.48) 78.74,64.48 U2030.P32 ; v1(96.51,74.25) U2030.A10 ; CN2019.19 v2(57.08,91.71) ; U2029.AW3 102.1,94.16 102.14,94.2 102.14,94.9 102.12,94.92 U2029.AW5 102.57,95.39 v2(102.57,95.5) 102.57,95.56 U2029.AW7 102.2,96.11 102.2,97.03 U2029.AW9 U2029.AY9 101.32,97.04 100.79,97.04 U2029.BA9 100.32,97.5 v2(100.32,97.73) ; v2(55.05,39.03) 55.05,39.36 55.9,40.21 CN2019.217 ; CN2019.65 59.47,80.21 59.8,79.87 v2(59.8,79.86) ; U2030.E7 98.3,71.62 v1(98.06,71.62) 97.72,71.62 U2030.E8 ; U2030.T1 102.02,62.22 v1(102.8,62.22) ; v2(77.59,45.56) 77.59,45.75 77.89,46.05 78.52,46.05 78.57,46.01 U2030.AR32 ; v2(121.04,116.39) 121.04,116.08 120.8,115.84 U2029.E41 ; U2030.AM8 97.74,48.98 97.74,48.68 v1(97.91,48.51) ; v2(78.4,48.01) U2030.AN32 ; v1(53.66,88.92) 53.66,88.63 52.48,87.46 CN2019.36 ; PU2000.19 142.22,45.45 142.52,45.75 PC2004.2 ; U2030.K5 100.12,68.22 v1(100.12,68.53) 100.12,68.8 U2030.H5 100.1,69.2 v1(100.1,69.48) 100.1,69.82 U2030.G5 100.12,70.22 v1(100.12,70.51) 100.12,70.9 U2030.F5 100.12,71.12 v1(100.12,71.51) ; PC265.2 43.73,14.87 v2(43.65,14.79) ; U2030.A12 94.14,73.68 v1(94.14,73.77) 92.97,73.77 U2030.A14 92.07,73.75 v1(90.91,73.75) 90.91,73.7 U2030.A16 ; CN2019.27 56.39,89.71 56.07,90.03 v2(55.39,90.03) ; v2(57.08,39.03) 57.08,39 57.38,38.71 CN2019.223 ; v2(48.96,52.46) CN2019.168 ; CN2019.214 51.61,40.96 v2(51.61,40.95) ; CN2019.82 52.01,75.96 52.92,75.04 v2(52.92,74.94) ; U2030.H13 93.77,68.95 v1(94.04,68.95) ; U2029.C19 121.9,102.47 v2(121.52,102.09) 121.9,101.71 U2029.C17 121.87,101.49 121.87,100.45 U2029.C15 121.87,100.39 121.87,99.35 U2029.C13 121.9,99.09 v2(121.59,98.78) 121.9,98.47 U2029.C11 121.9,98.01 v2(121.66,97.76) 121.9,97.52 U2029.C9 121.9,96.75 v2(121.69,96.54) 121.9,96.33 U2029.C7 121.9,95.65 v2(121.7,95.45) 121.9,95.25 U2029.C5 121.82,94.84 v2(121.37,94.84) 121.12,94.84 U2029.E4 U2029.E3 120.4,93.82 v2(120.25,93.98) 120.09,93.82 U2029.G3 119.4,93.82 v2(119.2,94.02) 119.01,93.82 U2029.J3 118.38,93.82 v2(118.09,94.12) 117.79,93.82 U2029.L3 117.12,93.82 v2(116.93,94.02) 116.73,93.82 U2029.N3 116.16,93.82 v2(115.84,94.14) 115.51,93.82 U2029.R3 115.16,93.82 v2(114.81,94.18) 114.45,93.82 U2029.U3 114.06,93.82 v2(113.71,94.18) 113.35,93.82 U2029.W3 112.96,93.82 v2(112.61,94.18) 112.25,93.82 U2029.AA3 111.86,93.82 v2(111.51,94.18) 111.15,93.82 U2029.AC3 110.76,93.82 v2(110.41,94.18) 110.05,93.82 U2029.AE3 109.66,93.82 v2(109.31,94.18) 108.95,93.82 U2029.AG3 108.7,93.84 108.68,93.86 107.63,93.86 107.6,93.84 U2029.AJ3 107.25,93.82 v2(106.99,94.07) 106.74,93.82 U2029.AL3 106.46,93.86 105.45,93.86 U2029.AN3 ; U2030.A23 84.51,73.96 v1(84.5,73.97) ; U2029.L7 117.5,96.09 v2(118.03,95.56) ; v2(52.98,40.95) 52.98,40.84 52.1,39.96 CN2019.218 ; U2030.M32 78.22,66.01 v1(77.86,65.65) ; v2(51.62,78.71) 51.37,78.46 CN2019.72 ; U2030.E16 90.72,71.62 v1(90.99,71.62) 91.01,71.64 U2030.D16 ; U2030.AY15 91.72,42.4 v1(92.01,42.4) ; CN2019.213 57.34,41.21 57.09,40.95 v2(57.08,40.95) ; v2(123.94,94.79) 123.8,94.92 U2029.A5 ; v2(114.26,91.89) 114.2,91.95 114.2,92.42 U2029.U1 ; PC9177.1 PR9306.1 71.39,118.82 71.39,117.84 v2(71.36,117.82) ; v1(97.34,60.51) 97.71,60.88 U2030.V8 ; CN2019.26 51.49,89.96 v2(51.61,90.07) ; CN2019.260 51.24,29.46 51.24,29.45 51.62,29.07 v1(51.62,28.94) ; U2029.AW31 102.39,108.93 v2(102.39,108.63) 102.39,108.41 U2029.AW29 102.03,108.19 101.48,108.19 U2029.AY29 101.33,108.19 100.78,108.19 U2029.BA29 100.68,108.15 100.37,108.15 100.24,108.28 v2(100.24,108.34) v2(100.24,108.98) ; v2(120.86,91.86) 120.8,91.92 U2029.E1 ; U2030.BB32 79.19,41.61 78.55,40.97 v2(78.55,40.83) ; v1(90.99,70.36) 90.83,70.36 90.51,70.03 U2030.G16 ; v1(102.55,54.01) U2030.AF1 ; v2(56.98,93.84) 57.35,94.21 CN2019.9 ; CN2019.78 v2(51.62,76.96) ; CN2019.244 51.46,33.46 v2(51.9,33.9) ; v2(52.85,39.02) 51.79,37.96 CN2019.226 ; U2030.AY6 99.86,42.51 100.01,42.66 U2030.AW5 v1(100.52,43.01) ; CN2019.1 57.79,96.21 57.36,96.63 57.01,96.63 v2(56.45,97.19) ; v2(108.27,115.43) 108.39,115.43 108.7,115.12 U2029.AG41 108.65,114.97 108.65,114.38 U2029.AG40 U2029.AG39 ; v1(59.75,76.95) 59.75,76.57 59.39,76.21 CN2019.81 ; v2(112.46,91.68) 112,92.13 U2029.AA1 ; CN2019.23 56.68,90.71 55.67,91.72 v2(55.67,91.74) ; CN2019.175 57.3,50.71 v2(56.96,50.37) ; U2030.K19 88.24,67.88 v1(87.97,67.88) ; CN9.75 184.16,12.63 184.47,12.94 v2(184.47,13.45) ; v2(51.88,30.85) 51.27,31.46 CN2019.252 ; v2(141.21,101.6) 141.21,101.61 140.89,101.93 R2663.1 ; v2(51.62,86.6) 51.48,86.46 CN2019.40 ; CN2019.85 57.42,75.21 v2(57.16,74.94) ; U2030.E12 94.3,71.62 v1(94.04,71.62) 93.72,71.62 U2030.E13 ; v1(78.04,73.01) 78.55,73.01 79.15,72.41 U2030.C32 ; CN2019.192 v2(51.86,46.46) ; v2(84.26,38.52) 84.14,38.64 84.14,39.66 84.51,40.03 U2030.BD23 ; CN2019.185 57.23,48.21 v2(57.08,48.35) ; v2(57.07,84.61) 57.17,84.71 CN2019.47 ; v2(53.13,48.35) 53.13,48.33 52.26,47.46 CN2019.188 ; v2(56.32,30.72) 57.31,31.71 CN2019.251 ; v1(93.98,66.49) 94,66.49 94.48,66.01 U2030.M12 ; U2030.A26 82.36,73.46 v1(82.36,73.77) ; U8023.3 112.68,125.35 v2(112.53,125.21) ; CN2019.18 51.58,91.96 v2(51.61,91.98) ; CN2019.176 51.48,50.46 v2(51.6,50.34) ; v1(60.13,71.42) 59.85,71.71 CN2019.99 ; v2(124,96.92) 123.86,97.07 123.36,97.07 U2029.A9 ; CN2019.238 52.04,34.96 52.88,35.79 v2(52.88,35.93) ; CN2019.256 51.3,30.46 52.26,29.5 v2(52.26,28.94) ; v2(52.88,90.07) 52.88,90.19 52.12,90.96 CN2019.22 ; v2(51.63,74.94) 51.61,74.94 51.6,74.96 CN2019.86 ; v2(56.96,73.75) 56.96,73.52 57.27,73.21 CN2019.93 ; U2030.BD30 80.11,40.56 v2(79.82,40.27) ; v1(102.37,42.63) 103.16,42.63 103.44,42.91 v1(104.51,42.91) v1(106.18,42.91) 106.18,42.92 106.61,43.34 C2577.2 106.61,43.66 107,44.06 108.23,44.06 108.39,43.9 109.82,43.9 109.96,43.76 109.96,42.49 v2(110.17,42.28) v2(110.17,41.35) 110.17,41.01 110.65,40.52 110.65,38.49 v2(110.8,38.34) v2(110.8,37.58) 110.8,36.3 110.53,36.03 107.28,36.03 106.87,36.43 C2576.1 ; v1(95.72,48.4) U2030.AN10 ; v2(73.32,22.26) CN12.4 73.32,20.26 v2(73.19,20.13) ; CN2019.52 52.04,83.46 52.88,84.3 v2(52.88,84.57) ; U2030.N19 v1(88.11,64.21) U2030.P20 ; v2(56.32,78.71) 56.32,78.6 56.83,78.09 57.34,78.09 57.45,78.21 CN2019.73 ; CN2019.2 v2(51.58,95.96) ; v2(51.55,36.96) CN2019.230 ; v1(87.05,48.54) U2030.AN21 ; CN2019.6 v2(51.61,94.96) ; 87.51,42.13 U2030.BB20 ; PR275.1 45.48,16.19 v2(45.03,16.65)
  BOTTOM w0.279: CN6.22 214.31,32.4 214.34,32.37 v2(214.36,32.37) ; v1(93.69,61.84) 93.69,61.78 U2030.U13 U2030.V14 v1(92.11,60.2) U2030.W15 91.71,59.81 v1(91.31,59.41) ; CN18.57 v2(25.85,8.44) ; v1(91.31,64.21) U2030.N15 v1(92.06,64.95) ; v1(93.66,60.18) 93.31,59.83 U2030.W13 92.99,59.49 v1(92.99,59.41) 92.91,59.41 U2030.Y14 ; CN9.18 189.79,26.88 189.57,27.09 v2(189.57,27.27) ; HD1.9 214.58,12.32 v2(214.95,12.69) ; U8001.3 83.61,88.03 v2(83.75,88.17) ; U2030.N13 92.98,64.28 v1(92.98,64.21) 92.58,63.81 U2030.P14 92.11,63.41 v1(91.99,63.41) 91.99,63.28 U2030.R15 v1(91.31,62.61) ; v2(213.04,13.7) 213.16,13.82 HD1.6 ; U2030.R12 94.51,62.89 v1(94.93,62.47) 95.31,62.85 U2030.R11 ; v1(91.31,61.01) 91.71,61.41 U2030.U15 91.99,61.69 v1(91.99,61.81) 92.38,62.21 U2030.T14 v1(92.92,62.62) U2030.R13 ; CN6.24 214.27,31.4 v2(214.44,31.23)
  BOTTOM w0.305: 39.56,7.86 39.35,8.07 CN18.3 ; 39.56,7.86 39.85,8.15 CN18.1 ; 39.56,7.86 39.56,7.1 38.42,5.96 v2(38.29,5.96) ; U2030.BB1 102.4,41.61 v1(102.78,41.23) ; v2(136.76,114.98) 137.16,114.58 VRAM2001.N12 ; CN2.9 47.72,107.84 47.94,108.06 v2(48.32,108.06) 48.96,108.06 49.22,107.8 CN2.12 ; v1(84.02,70.35) 84.06,70.35 84.4,70.01 U2030.G23 ; v2(27.11,8.37) 27.11,8.5 27.35,8.73 CN18.51 ; VRAM2001.E12 143.22,114.94 v2(143.18,114.94) ; U2029.AU29 103.6,108.18 v2(103.16,108.62) ; VRAM2001.C11 145.18,113.78 v2(144.77,114.19) ; v1(88.99,58.61) 88.91,58.61 U2030.AA19 ; U2030.N22 85.27,65.45 85.27,65.51 v1(85.28,65.52) ; v1(82.16,68.52) 82.51,68.17 U2030.K26 ; VRAM2002.M5 142.78,90.48 v2(143.21,90.05) ; VRAM2002.R1 v2(144.8,94.17) ; VRAM2002.C12 135.18,85.4 v2(135.18,85.43) 135.54,85.79 VRAM2002.C11 ; v2(139.38,94.31) 139.58,94.11 VRAM2002.H1 VRAM2002.H2 ; v1(91.31,57.01) 91.34,56.98 U2030.AC15 v1(92.11,56.21) U2030.AD14 U2030.AE13 v1(93.71,54.62) ; U2030.AE19 v1(88.91,54.61) U2030.AF18 v1(89.71,53.81) U2030.AG17 U2030.AH16 91.31,52.21 ; U2030.AE19 U2030.AD20 87.71,55.79 ; U2030.AE19 U2030.AF20 87.71,54.19 v1(87.34,53.81) ; v2(212.15,36.31) 212.24,36.4 CN6.14 ; VRAM2002.E14 137.18,82.83 v2(137.34,82.67) ; U2030.H25 83.51,69.1 83.15,69.46 83.07,69.46 v1(83.04,69.49) 83.04,69.57 82.6,70.01 U2030.G26 ; U2030.BD16 90.51,40.19 v1(90.58,40.13) ; v1(96.02,42.48) 96.38,42.48 U2030.AY10 96.66,42.61 97.05,42.99 97.05,43.65 v1(97.07,43.67) 96.73,44.01 U2030.AV10 ; VRAM2001.K1 139.98,105.38 v2(139.98,105.19) ; v2(137.57,112.53) 137.57,112.63 137.92,112.98 VRAM2001.M10 ; v2(185.1,13.45) 185.1,14.72 184.19,15.63 CN9.63 ; 91.31,53.81 U2030.AF16 U2030.AE17 v1(89.71,55.41) U2030.AD18 v1(88.91,56.21) U2030.AC19 U2030.AB20 ; 91.31,53.81 v1(91.34,53.81) ; 91.31,53.81 U2030.AG15 v1(92.11,53.01) U2030.AH14 U2030.AJ13 93.36,51.81 v1(93.74,51.43) ; VRAM2001.E1 143.58,105.13 v2(143.35,104.9) ; v2(135.9,116.63) 135.9,116.47 135.6,116.18 VRAM2001.R14 ; U2029.AL32 105.93,110.3 105.93,110.8 ; v2(147.37,106.92) 146.91,107.38 VRAM2001.A3 ; VRAM2002.P10 v2(144.78,86.19) VRAM2002.R11 ; VRAM2001.R4 135.57,108.18 135.2,108.55 v2(135.2,108.58) 135.18,108.58 134.78,108.98 VRAM2001.T5 ; CN9.57 184.08,17.13 v2(184.59,17.64) ; v2(141.93,90.04) 141.93,90.54 VRAM2002.L5 ; v1(89.07,66.43) 89.45,66.81 U2030.L18 ; U2029.AR39 104.63,113.3 v2(104.81,113.3) 105.14,113.62 U2029.AN39 ; v2(143.98,112.29) 143.98,112.43 144.38,112.83 VRAM2001.D10 ; U2030.AA13 93.75,57.77 v1(93.89,57.77) ; U2030.G21 86.34,70.01 v1(86.02,70.33) ; U2029.L35 117.9,111.72 v2(118.07,111.72) 118.2,111.72 U2029.J37 ; U2030.W26 82.51,60.21 U2030.V25 83.31,61.21 U2030.T26 ; U2030.N17 v1(89.74,64.23) U2030.P18 ; CN9.69 184.16,14.13 184.47,13.83 v2(184.47,13.45) ; 91.31,52.21 v1(91.34,52.21) ; 91.31,52.21 U2030.AJ15 91.74,51.81 v1(92.11,51.43) 92.51,51.03 U2030.AK14 ; U2030.N25 83.31,65.12 v1(82.92,65.52) ; VRAM2002.N1 v2(143.98,93.39) ; v2(139.51,82.66) 139.58,82.73 VRAM2002.H14 139.59,83.39 139.71,83.52 139.71,84.07 139.59,84.19 VRAM2002.H13 ; CN9.33 184.39,23.13 v2(184.41,23.11) ; U2030.AB16 U2030.AA17 U2030.Y16 v1(91.31,59.41) ; 137.58,90.99 VRAM2002.F5 137.98,90.06 v2(137.98,90.06) ; v2(128.2,16.69) 128.2,16.74 128.35,16.9 CN15.18 ; CN9.13 184.06,28.13 184.47,28.53 v2(184.47,28.58) ; v1(87.09,68.79) U2030.H20 87.7,69.21 v1(88.09,69.59) ; v1(91.31,64.21) U2030.P16 90.51,63.41 v1(90.48,63.41) 90.48,63.38 U2030.R17 89.31,62.21 U2030.T18 U2030.U17 v1(90.51,61.81) U2030.T16 v1(91.31,62.61) ; v2(19.49,32.63) 19.71,32.41 U5400.5 ; U2030.AK18 v1(88.91,51.41) ; U2029.U5 113.86,94.98 v2(113.68,94.98) ; PC248.1 v1(129.39,28.99) ; U2030.AU15 91.62,44.81 v1(91.96,44.47) 92.05,44.47 U2030.AV14 ; U2030.T26 82.46,62.01 82.12,62.35 v1(82.12,62.47) ; U2030.T26 82.56,62.01 82.92,62.36 v1(82.92,62.47) 82.92,62.49 83.31,62.89 U2030.R25 ; v2(133.55,107.82) VRAM2001.U3 ; U2030.AK11 U2030.AK12 U2030.AL12 ; U2030.AK11 95.61,51.31 v1(95.61,51.52) ; U2030.AK11 96.11,50.21 U2030.AL10 ; v1(94.51,39.96) U2030.BD12 ; v2(184.51,18.3) 184.18,18.63 CN9.51 ; v2(133.58,92.59) VRAM2002.A3 ; VRAM2001.F10 142.78,112.44 v2(142.18,111.84) ; VRAM2001.E3 v2(143.18,107.78) ; U2029.AY41 101.3,114.72 101.4,114.62 U2029.AY40 100.8,114.32 U2029.BA40 100.7,114.99 v2(100.65,115.05) ; U2029.AJ1 107.6,92.04 v2(107.76,91.88) ; v1(84.54,49.54) 84.91,49.91 U2030.AL23 84.91,50.17 v1(85.3,50.56) 85.71,50.97 U2030.AK22 ; v1(110.32,111.01) 110.3,110.98 110.3,110.22 U2029.AE32 ; U2030.AC8 97.98,56.74 97.98,56.5 v1(97.98,56.5) ; U2030.V11 95.31,61.04 v1(94.87,61.49) 94.51,61.13 U2030.V12 ; PC254.1 129.53,27.78 129.5,27.75 v1(129.39,27.75) ; U2030.T20 87.71,62.24 87.74,62.24 v1(88.09,62.58) U2030.R19 ; U2029.N37 116.53,112.12 116.9,111.75 v2(116.93,111.75) ; v2(79.07,113) 78.6,112.52 PC9002.1 ; v1(87.02,71.59) 86.69,71.59 U2030.E21 86.34,71.59 v1(86.02,71.59) 85.69,71.59 U2030.E22 ; U2030.R30 80.5,63.01 81.04,62.47 v1(81.47,62.47) 81.11,62.11 U2030.T28 ; U2030.AG13 v1(93.72,53) 93.74,53.01 U2030.AG12 U2030.AG11 95.69,53.39 v1(95.69,53.5) ; U2029.C25 121.9,106.21 v2(121.63,106.49) 121.9,106.77 U2029.C27 121.9,107.3 v2(121.63,107.58) 121.9,107.86 U2029.C29 121.9,108.34 v2(121.58,108.67) 121.9,109 U2029.C31 121.9,109.46 v2(121.6,109.76) 121.9,110.07 U2029.C33 121.88,110.32 121.8,110.4 121.8,111.35 121.88,111.42 U2029.C35 121.7,111.62 v2(121.7,112.05) ; v1(83.03,48.5) 83.03,48.73 U2030.AM25 ; v2(147.21,82.88) 147.21,82.97 VRAM2002.U14 v2(146.39,83.78) ; VRAM2001.R11 v2(135.2,114.16) 135.58,114.55 VRAM2001.R12 ; v2(141.59,112.12) 141.98,112.5 VRAM2001.G10 ; v1(86.14,66.42) 86.14,66.39 86.51,66.02 U2030.M21 ; v2(53.85,106.29) 53.72,106.41 CN2.21 ; U2030.AU20 87.1,44.39 v1(87.04,44.39) 86.9,44.39 U2030.AV21 86.16,43.66 v1(86,43.66) ; U2029.AW25 102.1,106.19 v2(102.37,106.46) 102.1,106.73 U2029.AW27 ; U2030.AU8 97.51,44.98 v1(97.09,44.56) ; U2029.AC39 110.65,113.37 v2(110.35,113.37) 110.05,113.37 U2029.AE39 109.48,113.3 v2(109.23,113.3) 109.03,113.3 U2029.AG39 108.38,113.3 v2(108.11,113.3) 107.93,113.3 U2029.AJ39 107.6,113.6 107.28,113.27 v2(107.05,113.27) 106.91,113.27 106.55,113.62 U2029.AL39 106.18,113.3 v2(105.93,113.3) 105.6,113.62 U2029.AN39 ; VRAM2002.A14 133.98,83.39 134.3,83.07 v2(134.3,82.69) ; v2(142.79,109.57) 142.78,109.56 VRAM2001.F5 ; v2(31.85,10.81) CN18.33 ; VRAM2002.A1 133.98,93.96 v2(133.6,94.33) ; VRAM2001.C4 v2(145.58,108.58) ; U2030.M26 82.51,66.19 v1(82.16,66.55) ; U2030.R28 81.14,63.01 81.44,63.31 v1(81.44,63.61) 81.44,63.65 81.11,63.98 U2030.P28 80.96,64.16 80.96,64.86 U2030.N28 80.94,65.18 v1(80.94,65.5) 80.94,65.83 U2030.M28 80.94,66.18 v1(80.94,66.55) 80.94,66.83 U2030.L28 80.9,67.22 80.9,67.79 U2030.K28 81.11,68.22 80.89,68.45 80.89,68.78 U2030.H28 80.94,69.18 80.94,69.46 v1(80.91,69.49) 80.94,69.51 80.94,69.83 U2030.G28 80.91,70.21 v1(80.91,70.48) 80.91,70.91 U2030.F28 81.01,71.56 v1(81.02,71.57) 81.45,71.57 U2030.E27 81.63,71.62 v1(82.02,71.62) 82.3,71.62 U2030.E26 82.67,71.57 82.97,71.57 v1(83.02,71.62) 83.07,71.57 83.35,71.57 U2030.E25 83.67,71.57 v1(84.02,71.57) 84.35,71.57 U2030.E23 84.67,71.57 v1(85.02,71.57) ; VRAM2001.C3 v2(145.58,107.78) ; U2029.G15 119.6,100.42 119.93,100.09 v2(119.93,99.84) 120.4,99.36 U2029.E13 ; VRAM2002.M10 142.35,87.02 v2(142.34,87.02) 142.29,87.02 141.98,86.72 VRAM2002.L10 ; U2030.K21 86.62,67.61 v1(87.06,67.17) 87.15,67.17 U2030.L20 ; v2(37.2,7.15) 37.85,7.8 CN18.9 ; VRAM2002.N12 v2(143.98,84.59) ; VRAM2001.H1 v2(141.58,106.18) 141.18,106.58 VRAM2001.H2 ; VRAM2002.N3 v2(143.98,91.79) ; CN2.18 52.22,107.75 52.26,107.78 v2(52.26,108.01) ; U2030.P23 85.28,63.64 v1(85.28,63.51) 85.28,63.44 U2030.R22 ; U2030.V20 87.71,60.64 v1(87.34,61.01) ; VRAM2001.C14 v2(145.58,115.78) ; HD1.12 214.78,10.82 v2(214.95,10.65) ; v2(135.85,105.12) 135.58,105.39 VRAM2001.R1 ; v1(84.92,44.37) 85.36,44.81 U2030.AU22 ; U2029.K21 118,103.77 v2(118.44,104.21) ; U2030.AL26 82.51,49.95 v1(82.1,49.54) ; v2(134.42,112.52) 134.42,112.62 134.78,112.98 VRAM2001.T10 ; v2(136.52,87.22) 136.38,87.08 VRAM2002.D10 ; v1(95.76,64.51) 95.31,64.96 U2030.N11 ; CN15.4 v2(135.35,16.69) ; v2(10.12,15.99) 10.25,16.12 RV1.8 RV1.3 v2(12.33,16.12) ; v1(82.94,50.56) 82.94,50.64 U2030.AK25 ; CN13.5 v2(58.45,19.42) ; v2(143.36,82.58) 143.29,82.64 143.29,83.1 VRAM2002.N14 ; U2029.AE5 109.8,95.33 110.12,95.64 v2(110.35,95.64) 110.42,95.64 110.9,96.12 U2029.AC7 ; VRAM2002.C14 135.58,83.02 v2(135.9,82.69) ; U2029.E21 120.04,104.09 v2(120.04,104.32) 119.98,104.32 119.6,104.7 U2029.G23 ; v1(84.01,43.68) 84.34,44.01 U2030.AV23 ; VRAM2001.B5 145.98,108.98 v2(146.38,108.58) ; U2029.R7 115.05,95.87 v2(114.79,95.87) ; U2030.BD14 92.51,40.2 92.59,40.11 v1(92.59,39.96) ; U2030.AR21 86.51,46.39 86.09,45.97 v1(86,45.97) ; v2(118.04,113.35) 118.05,113.35 U2029.K40 ; v2(118.04,113.35) 118.33,113.35 U2029.J39 118.88,113.35 v2(119.11,113.35) 119.43,113.35 U2029.G39 119.95,113.37 v2(120.25,113.37) 120.51,113.62 U2029.E39 ; v2(118.04,113.35) 117.78,113.35 U2029.L39 117.23,113.35 v2(116.95,113.35) 116.68,113.35 U2029.N39 116.15,113.37 v2(115.8,113.37) 115.55,113.37 U2029.R39 115.25,113.62 115.15,113.52 114.3,113.52 U2029.U39 ; U2030.AU25 83.34,45.01 v1(82.89,44.56) 82.51,44.18 U2030.AV26 ; VRAM2001.L10 138.5,112.7 v2(138.5,112.53) ; v2(45.65,105.52) 46.22,106.09 CN2.6 ; VRAM2001.A12 v2(147.18,114.18) ; CN15.1 v2(136.85,16.69) ; VRAM2001.H14 VRAM2001.H13 140.8,115.01 v2(140.78,115.01) ; U2029.E25 120.41,105.92 120.69,105.64 v2(120.69,105.4) ; VRAM2001.N1 137.18,105.78 v2(136.78,105.38) ; U2029.AW19 102.1,102.89 v2(102.37,103.16) 102.1,103.43 U2029.AW21 ; U2030.M23 84.57,66.35 84.57,66.44 84.52,66.49 v1(84.52,66.52) ; CN9.7 184.39,29.63 v2(184.47,29.7) ; U2030.K22 85.43,67.61 v1(85.08,67.97) ; U2029.AL10 106.51,97.73 107.6,97.73 U2029.AJ10 107.94,98.06 v2(108.14,98.06) ; 105.93,110.8 106.45,111.32 U2029.AL35 ; 105.93,110.8 U2029.AN35 ; v2(137.4,94.47) 137.18,94.24 137.18,93.79 VRAM2002.E1 ; v1(82.89,46.51) 83.31,46.93 U2030.AP25 ; v2(139,87.1) 139,86.98 138.78,86.77 VRAM2002.G10 ; v1(102.27,52.16) 102.12,52.01 U2030.AJ1 ; v2(145.57,106.19) 145.18,105.79 VRAM2001.C1 145.18,105.78 v2(144.78,106.18) ; U2029.G11 119.6,98.13 119.89,97.85 v2(119.89,97.69) 119.89,97.64 U2029.E9 ; U2030.Y12 94.51,59.13 v1(94.87,59.49) 95.31,59.04 U2030.Y11 ; U2030.AP28 80.91,47.21 v1(80.91,47.54) 80.91,47.81 U2030.AN28 ; VRAM2001.P10 136.06,112.66 v2(136.06,112.52) ; VRAM2001.K2 v2(139.98,106.18) ; U2030.AC13 U2030.AB14 92.14,57.78 v1(92.11,57.78) 92.11,57.81 U2030.AA15 U2030.Y14 ; v2(119.14,111.16) 119.3,111.32 U2029.G35 ; v2(139.2,116.63) 139.58,116.25 VRAM2001.K14 VRAM2001.K13 ; U2030.AP8 97.99,46.73 v1(97.99,46.49) 98.47,46.01 U2030.AR7 ; U2030.AN26 82.51,47.94 v1(82.08,47.51) ; v2(145.58,91.79) VRAM2002.R3 v2(144.78,91.79) ; U2029.N5 116.71,95.32 v2(117.11,95.72) ; VRAM2002.U3 v2(147.77,92.19) ; CN9.45 184.39,20.13 v2(184.42,20.16) ; v2(106.11,95.73) 105.8,95.73 U2029.AN7 105.19,96.12 v2(104.92,96.39) 104.65,96.12 U2029.AR7 103.87,96.55 v2(103.87,96.58) 103.6,96.85 U2029.AU9 ; v2(135.17,90.21) 134.78,90.59 VRAM2002.B5 ; CN18.21 34.85,8.71 v2(35.11,8.44) ; v1(102.55,48.01) U2030.AN1 ; v1(82.16,64.51) 82.16,64.36 U2030.P26 ; VRAM2002.C1 135.81,94.02 v2(135.81,94.4) ; 87.34,57.03 v1(87.34,57.01) ; U2030.AR26 82.51,45.92 v1(82.15,45.56) ; 89.98,44.34 U2030.AU18 89.98,45.28 89.98,45.88 U2030.AR16 ; VRAM2001.A1 147.28,105.28 v2(147.28,105.16) ; U2030.E8 97.3,71.62 v1(97.05,71.62) 96.72,71.62 U2030.E10 ; v2(184.47,21.7) 184.39,21.63 CN9.39 ; U2030.BD3 100.94,40.71 v1(101.4,40.24) ; U2030.AN7 98.41,48.01 v1(97.91,48.51) ; CN15.17 v2(128.85,16.69) ; PC271.1 47.05,16.98 47.24,16.8 v2(47.24,16.72) 47.39,16.56 PC261.1 ; v2(134.13,104.97) 134.13,105.27 133.98,105.42 VRAM2001.U1 ; v1(88.14,57.83) U2030.AA19 ; U2030.AA19 U2030.AB18 v1(89.71,57.01) 90.11,56.61 U2030.AC17 U2030.AD16 91.31,55.41 v1(91.34,55.41) 91.71,55.03 U2030.AE15 v1(92.11,54.61) 92.51,54.21 U2030.AF14 ; VRAM2001.R3 135.2,107.76 v2(135.2,107.78) ; CN18.15 v2(36.35,10.81) ; PC267.1 46.43,15.94 45.84,16.54 45.8,16.54 45.69,16.65 v2(45.03,16.65) ; v2(184.59,30.97) 184.44,31.13 CN9.1 ; U2030.AN18 89.51,47.98 v1(88.99,47.46) 89.24,47.21 U2030.AP18 ; v1(88.04,46.14) 88.31,46.41 U2030.AR19 ; v2(30.35,10.81) CN18.39 ; U2030.AV1 102.23,44.01 v1(102.29,44.07) ; v2(111.56,94.88) U2029.AA5 112.42,95.74 v2(112.59,95.74) 112.72,95.74 U2029.W7 ; U2030.AG19 U2030.AH20 ; VRAM2002.A12 v2(133.53,85.45) ; U2029.G31 119.59,109.22 119.52,109.3 v2(119.52,109.79) 119.52,109.92 119.01,110.43 118.7,110.43 U2029.J34 ; U2030.L25 83.31,67.17 v1(82.92,67.56) ; VRAM2001.N14 137.19,116.18 138.19,117.18 v2(138.19,117.72) ; CN2.3 44.72,106.37 v2(44.64,106.29) ; U2029.AY17 U2029.AW17 102.1,101.27 102.42,100.95 v2(102.42,100.85) 102.42,100.74 U2029.AW15 102.29,100.24 v2(102.29,99.85) ; VRAM2002.C3 v2(135.98,92.59) ; v1(88.91,53.01) U2030.AH18 v1(89.71,52.21) U2030.AJ17 v1(90.51,51.41) U2030.AK16 ; VRAM2002.K2 v2(140.78,93.39) ; VRAM2001.L5 138.42,108.62 v2(138.42,108.58) ; v2(140.81,94.32) 141.18,93.95 VRAM2002.K1 ; v2(145.08,82.86) 145.18,82.96 VRAM2002.R14 ; VRAM2002.T5 v2(146.38,90.19) ; VRAM2001.U12 133.87,114.58 133.44,114.16 v2(133.44,114.16) ; v1(89.73,60.19) U2030.V18 ; v2(104.63,109.76) 104.64,109.76 104.64,109.46 U2029.AR31 ; VRAM2002.C4 v2(135.18,90.99) ; U2030.T23 84.91,61.81 U2030.V22 85.71,60.72 v1(85.91,60.51) ; v1(91.31,61.01) U2030.V16 v1(90.51,60.21) U2030.W17 ; U2030.AV7 98.01,43.51 v1(98.01,42.69) ; VRAM2002.R4 v2(145.58,90.99) ; U2029.AG7 109.08,95.74 v2(109.28,95.74) ; CN2.15 50.72,106.39 v2(50.82,106.29) ; v1(85.07,69.64) 85.5,69.21 U2030.H22 ; v1(93.98,66.49) 93.86,66.49 93.54,66.81 U2030.L13 ; v2(184,10.53) CN9.77 ; U2029.G7 120.07,96.49 120.07,96.54 v2(120.07,96.54) ; VRAM2002.K14 141.18,83.08 v2(140.88,82.78) ; U2030.AJ19 U2030.AK20 88.07,50.65 v1(88.07,50.6) ; v2(141.58,108.58) 141.98,108.98 VRAM2001.G5 ; VRAM2002.R12 v2(144.78,84.59) ; U2030.W19 U2030.Y18 89.31,59.01 ; v1(84.54,47.56) 84.91,47.93 U2030.AN23 84.91,48.21 U2030.AM22 ; U2030.U19 v1(88.12,61.02) ; U2029.AN39 U2029.AN40 ; VRAM2002.F10 137.69,86.88 v2(137.69,87.1) ; v1(102.27,46.16) 101.97,46.16 U2030.AR1 ; 88.99,71.25 88.99,70.49 U2030.G19 88.71,70.01 U2030.H18 ; v2(29.14,8.37) 29.14,8.47 28.85,8.76 CN18.45 ; VRAM2002.T10 v2(146.4,87.02) ; VRAM2001.M5 137.98,108.98 137.58,108.58 v2(137.55,108.58) ; VRAM2001.C12 v2(144.78,114.98) ; VRAM2002.U1 v2(147.76,93.79) ; v2(33.35,10.81) CN18.27 ; VRAM2002.G5 v2(139.18,90.19) ; v2(145.58,112.44) 145.58,112.58 VRAM2001.B10 ; U2030.N12 94.51,65.1 v1(94.93,65.52) ; U2029.AW9 102.33,97.35 102.33,97.65 102.35,97.68 v2(102.38,97.68) ; U2030.AP20 87.11,46.81 v1(87.04,46.81) ; U2030.AE12 94.51,55.12 v1(94.88,55.49) 95.31,55.06 U2030.AE11 ; v1(98.89,50.46) 98.51,50.07 U2030.AL7 ; VRAM2002.U12 v2(146.38,84.59) ; VRAM2001.E14 v2(143.58,117.08) ; CN9.19 184.24,26.63 v2(184.47,26.86) ; CN15.7 v2(133.85,16.69) ; v1(102.37,50.01) U2030.AL1
  BOTTOM w0.356: PC2000.2 145.33,40.52 v2(145.09,40.76) ; PC71.1 144.24,36.47 144.01,36.24 v2(143.85,36.24) ; PC227.2 146.53,36.48 v2(146.9,36.11) ; U2030.AU11 95.88,45.18 v1(96.05,45.18)
  BOTTOM w0.381: C2665.1 144.48,101.49 v2(144.74,101.22) ; v2(102.39,108.63) 103.15,108.63 v2(103.16,108.62) ; CN16.5 209.53,10.95 v2(209.61,11.04) ; v2(158.02,26) 156.55,24.52 CN8.29 156.55,22.45 156.91,22.08 v2(156.91,21.63) ; C551.2 v2(62.29,92.82) ; v2(210.25,13.45) 210.11,13.58 R6645.2 ; v2(93.15,95.81) 93.15,95.36 92.1,94.31 PQ9066.1 ; v2(75.12,88.45) 74.96,88.62 PQ8.1 ; U28.2 v2(19.39,44.18) ; v2(106.11,95.73) 106.12,95.73 106.5,96.11 U2029.AL7 ; v2(181.3,13.17) EC9.2 ; U2029.AL11 107.12,98.72 v2(107.48,98.36) 107.84,98.72 U2029.AJ11 ; v2(174.23,18.94) 174.23,18.58 174,18.35 CN10.2 ; v2(149.69,78.35) 149.5,78.15 PC9078.2 ; v2(93.66,89.14) 93.53,89.28 C2760.1 ; v2(116.95,76.05) 117.22,76.33 PR9136.2 ; v2(139.03,98.28) 138.99,98.24 C2667.1 ; v2(126.17,120.18) 126.17,119.49 125.28,118.6 125.03,118.6 ; U2029.L31 117.28,109 v1(117.28,109.21) 116.77,109.72 U2029.N32 ; v2(92.52,86.6) 92.24,86.6 91.98,86.86 C2766.2 ; PC9020.2 66.43,113.22 66.17,112.96 v2(66.17,112.83) ; C2765.2 91.27,83.78 v2(91.37,83.68) 91.27,83.58 89.89,83.58 ; U2030.AP15 91.1,46.8 v1(90.89,46.8) 90.89,46.79 U2030.AR16 ; v2(97.55,117.13) 97.21,117.47 R2653.1 ; v2(120.69,100.95) 120.69,101.23 U2029.E17 ; v2(39.52,120.72) 39.77,120.72 40.1,121.05 D22.1 ; v2(23.05,83.93) 22.8,83.93 C560.2 ; v2(39.13,108.7) 39.22,108.61 U21.25 ; v2(57.85,101.71) 57.85,102.82 C91.1 ; C2672.1 v2(148.02,79.22) ; v2(69.33,125.58) 69.25,125.5 PC126.1 ; C8155.1 v2(86.04,87.92) C2655.2 ; v2(131.92,87.58) 131.7,87.36 130.74,87.36 130,88.1 C2671.1 ; v2(117.03,125.46) 117.16,125.34 R77850.2 ; v2(129.52,34.59) 128.92,33.99 PC238.2 ; v2(54.93,24.12) 54.93,23.86 53.83,22.77 C455.1 ; Y2004.2 106.15,125.25 v2(106.36,125.46) ; C541.1 56.2,102.72 55.93,102.45 v2(55.41,102.45) ; PR160.2 v2(108.13,88.12) ; v2(116.67,102.22) 117,102.55 U2029.L19 ; PC9092.2 118.05,80.75 v2(117.54,81.27) 117.04,81.77 PC9179.2 ; PQ9007.1 132.46,122.23 v2(132.78,122.54) ; U2029.L23 117,104.56 v2(117.36,104.2) ; v2(62.29,93.94) 62.32,93.94 62.34,93.97 C550.2 ; v1(105.85,39.69) 106.41,39.69 C2575.1 107.24,39.24 107.29,39.19 Y2002.4 ; U2030.AN15 91.51,48.74 v1(91.27,48.98) ; 96.62,97.64 96.74,97.52 v2(97.95,97.52) ; U2035.2 14.29,24.12 v2(13.9,24.5) ; v2(131.68,120.24) 131.68,119.97 PQ9067.1 ; v2(19.8,84.06) 19.8,83.98 19.36,83.54 C558.2 ; v2(141.7,45.65) 141.7,45.87 142.07,46.24 PC2004.2 ; U17.22 211.14,17.26 C698.2 ; C28055.2 97.6,110.35 97.85,110.1 v2(97.85,109.84) 97.85,109.46 97.72,109.33 R77826.2 ; 89.89,83.58 90.12,83.81 Y2005.4 ; 89.89,83.58 89.24,83.58 v2(89.22,83.55) 89.19,83.58 87.54,83.58 87.31,83.81 v2(87.31,84.06) v2(87.31,87.11) 87.31,87.62 87.54,87.84 90.94,87.84 v2(91.3,87.49) 91.3,87.41 91.27,87.39 ; v2(208.47,23.99) 208.85,23.99 209.07,24.21 C622.2 ; C648.1 201.86,35.05 201.61,35.29 v2(201.23,35.29) ; v2(106.23,121.78) 106.24,121.79 C2657.2 ; D18.2 177.75,18.77 177.32,19.2 v2(177.32,19.54) 177.09,19.77 D17.1 ; U2029.G27 119.6,107.16 v2(120.08,107.63) 120.4,107.96 U2029.E29 ; v2(13.09,19.01) 12.86,19.24 C690.2 ; v1(107.53,45.62) 107.59,45.67 C2594.1 108.55,45.67 108.64,45.59 C2593.1 ; Y2004.4 102.79,123.65 101.85,124.59 v2(101.85,124.92) ; v2(108.9,77.66) 109.27,77.29 PQ9006.1 ; U2030.AC11 95.31,57.07 v1(94.88,57.5) 94.51,57.13 U2030.AC12 ; v2(64.07,111.37) 64.07,110.73 64.5,110.3 CN2.42 ; v2(195.69,27.09) 195.69,26.73 196.15,26.28 C659.2 ; C714.1 197,10.82 196.53,11.29 v2(196.53,11.42) ; C2763.1 C2764.1 99.24,81.07 v2(99.42,80.89) ; v2(19.24,9.38) 19.77,8.85 CN18.77 ; v2(139.64,74.84) 139.3,74.84 139.09,74.62 PC6065.2 ; PU9.8 112.58,87.36 v2(113.09,86.85) ; U2029.L27 117,106.89 117.56,107.45 v2(117.56,107.56) 117.56,107.68 U2029.K29 ; Q44.1 195.01,17.03 v2(195.01,14.72) ; PC104.2 69.4,89.15 68.74,89.8 v2(68.74,90.28) ; C661.2 196.78,27.93 v2(196.66,27.8) ; v2(70.57,36.13) 70.12,35.67 C148.2 ; U2029.R35 115.67,110.96 v2(115.81,110.96) ; EC6.1 v2(56.49,23.23) ; PU9006.2 117.92,38.09 v2(118.17,38.34) 118.17,38.47 117.79,38.85 PR194.2 ; PC111.2 156.65,27.41 155.92,26.68 v2(155.76,26.68) ; U2029.AC11 v2(111.48,98.25) U2029.AA10 ; v1(105.85,40.28) 106.38,40.28 C2568.2 ; PC9009.2 75.93,117.45 v2(75.94,117.45) 76,117.38 PC9003.2 ; C435.2 169.48,21.07 169.28,20.87 v2(169.28,20.43) ; v2(102.8,120.26) 102.43,120.63 C96272.2 ; v2(118.04,35.93) 118.55,35.93 118.87,35.61 PU9006.4 ; C2783.1 21.41,17.14 v2(20.76,16.5) ; v2(105.09,79.49) 105.09,79.87 104.71,80.25 ; SW1.3 v2(162.7,35.99) ; C1104.2 v2(16.06,74.54) ; v2(110.8,37.58) 110.39,37.58 Y2002.2 ; C64.2 41.25,107.43 v2(41.46,107.43) 41.59,107.43 41.82,107.2 C528.2 ; C508.2 36.38,121.52 v2(36.26,121.39) ; U2029.AL35 106.9,110.93 v2(106.93,110.93) 107.21,110.93 U2029.AJ35 ; v1(85.25,60.54) 85.25,60.35 U2030.W23 ; C28054.2 97.47,113.52 97.72,113.78 v2(97.72,114.02) 97.72,114.16 97.34,114.54 R77821.2 ; v2(117.28,122.49) 117.03,122.74 C96271.2 ; v1(110.32,111.01) 110.01,111.32 U2029.AE35 ; PQ9008.1 v2(130.81,122.29) ; v2(115.12,34.2) 115.32,34.39 PC164.2 ; C2757.1 96.98,93.72 v2(97.21,93.5) ; R77818.2 97.6,101.59 v2(97.85,101.84) 97.85,102.35 97.6,102.6 C28052.2 ; U2029.K25 118,106 v2(118.42,106.42) ; C593.1 v2(20.46,56.25) ; v2(34.45,114.89) 33.9,115.45 CN1.1 ; U2029.L11 116.65,98.37 v2(116.65,98.28) ; v2(199.2,10.65) 198.83,11.03 C713.1 ; v2(139.25,79.09) R2679.1 C2673.1 ; v2(55.56,24.12) 55.56,23.74 54.8,22.97 C456.1 ; C2573.2 97.3,34.81 v1(97.71,34.4) ; C147.2 70.54,31.86 70.79,32.12 v2(70.8,32.12) ; PC143.2 40.69,119.23 v2(40.96,119.49) ; PC9094.1 112.32,77.32 v2(112.2,77.2) ; U2038.4 90.16,22.85 v2(89.9,22.59) ; C393.1 53.49,16.08 v2(53.66,16.24) ; U2029.L15 v2(116.58,100.3) ; C529.2 43.36,105.66 v2(43.62,105.4) ; C637.2 199.32,19.58 C650.2 199.29,19.22 v2(199.58,18.93) ; U2029.AA32 112,109.57 v2(111.52,109.08) ; EC7.2 v2(59.2,23.23) ; 120.03,120.69 120.46,120.69 v2(120.92,121.14) ; v2(202.37,35.8) 202.38,35.8 C643.2 ; C666.2 198.68,22.24 v2(198.79,22.24) 198.88,22.24 C656.2 ; C624.2 207.2,21.3 v2(207.05,21.14) ; C663.1 197.15,25.14 C667.1 197.16,24.64 v2(197.01,24.5) ; v2(93.41,16.68) 92.6,16.68 PJ11.10 92.79,15.99 v2(93.41,15.99) ; R2640.1 135.57,120.64 v2(135.32,120.38) ; U2029.AP13 104.84,98.96 v2(104.84,98.79) 104.4,98.36 U2029.AR11 ; C705.1 198.47,17.19 v2(198.44,17.16) ; U2029.AN35 104.89,110.81 104,110.81 v2(103.95,110.86) ; C2580.1 110.32,48.11 v1(110.68,48.11) ; C2578.1 109.01,34.98 v2(108.95,35.04) ; v2(114.79,111.66) 114.66,111.66 U2029.U37 ; PC252.2 157.04,29.08 v2(157.27,28.85) ; C462.1 12.38,12.81 v2(12.63,12.56) ; C28053.2 97.34,106.67 v2(97.85,106.16) 97.34,105.65 R77820.2 ; C711.1 v2(12.63,13.83) ; v2(96.84,81.65) 96.84,81.01 96.57,80.75 C2758.1 ; C641.2 202.14,19.48 v2(202.14,19.14) 202.78,19.14 203.01,19.37 C647.2 ; U2029.R32 114.98,110.04 v2(114.77,110.04) 114.45,109.72 U2029.U32 ; C682.2 v2(76.52,24.24) ; v2(113.6,98.28) 113.5,98.28 113.05,98.72 U2029.W11 ; v2(147.44,116.72) 147.33,116.72 146.8,116.18 VRAM2001.A14 ; U2029.AG11 109,98.41 v2(109.28,98.13) 109.41,98.13 109.8,97.74 U2029.AE10 ; v2(79.69,22.21) C2792.2 ; C719.1 v2(193.63,31.74) ; PQ9068.1 138.04,123.36 137.6,122.92 136.08,122.92 v2(135.7,122.54) ; SW1.4 v2(167.13,35.99) ; v2(133.54,116.63) 133.54,116.61 133.97,116.18 VRAM2001.U14 ; C2656.2 102.42,122.67 v2(102.02,122.67) ; PC9182.2 v2(119.06,87.74) ; C2660.1 v2(100.38,118.85) ; v2(73.34,24.29) C680.2 ; C681.2 v2(74.48,24.24) ; v1(105.92,37.34) 106.57,36.68 C2576.1 ; R104.2 v2(18.6,74.79) ; v2(115.44,98.29) U2029.R11
  BOTTOM w0.406: v2(148.52,66.53) 149.22,65.82 PC9074.2 ; v2(140.43,73.65) 140.41,73.67 PC9071.2 ; v2(141.82,73.65) PC9066.2 ; v1(143,62.74) 142.77,62.74 PC9067.2 ; PR9117.2 145.34,60.95 v1(145.25,60.95)
  BOTTOM w0.457: PC125.1 66.16,125.59 v2(65.04,125.59) ; v2(65.04,119.06) 65.04,119.16 65.03,119.17 PC142.2 PC16.2
  BOTTOM w0.483: v1(143.6,60.75) 143.49,60.64 PC6033.2
  BOTTOM w0.508: v2(61.78,17.03) 61.78,17.81 CN13.9 62.42,17.85 v2(62.42,17) ; v2(159.56,28.05) 159.19,27.68 U33.4 ; CN8.2 153.07,27.68 PC110.2 ; v2(201.23,10.65) 200.93,10.95 CN16.6 ; PQ9015.1 66.51,87.58 66.86,87.24 v2(66.86,87.21) ; v2(67.24,20.61) 67.63,20.23 67.63,19.01 CN12.10 66.61,19.12 v2(66.61,20.61) ; PR9288.2 69.98,87.04 v2(70.17,86.85) ; PQ9057.1 72.77,85.27 v2(72.83,85.2) ; CN2021.3 119.06,50.41 119.72,49.74 v1(119.72,49.01) 119.59,49.14 CN2021.5 ; v2(55.81,19.42) 55.81,18.69 CN13.10 55.18,18.24 v2(55.18,19.42) ; CN1.6 v2(37.6,120.66) ; CN2021.17 v2(119.75,41.52) ; PQ7.1 76.96,91.11 v2(77.02,91.17) ; SW2.6 v2(67.35,101.84) ; v2(61.15,89.27) 61.18,89.24 PQ9013.1 ; CN9.76 v2(185.86,32.23) ; C545.1 64.08,90.8 63.69,90.41 v2(63.69,90.38) 63.66,90.38 63.15,89.87 PQ35.1 ; v2(178.37,12.95) 178.36,12.95 177.47,13.84 CN10.29 ; PJ11.9 v2(112.55,14.97) ; v2(79.94,18.27) 79.66,18.56 CN12.9 v2(78.47,17.43) ; v2(181.29,30.54) 180.46,31.38 FAN1.4 ; CN2021.7 119.16,47.87 v2(119.72,47.31) ; v2(114.46,19.06) 115,18.52 CN11.6 ; v2(43.11,109.98) 42.79,110.3 CN2.41 ; v2(121.68,19.34) 121.68,19.06 120.6,17.98 CN11.5 ; CN2020.2 v2(13.67,8.93) ; PR9287.2 72.32,91.3 v2(72.2,91.17) ; FAN1.5 174.39,24.44 v2(174.39,23.48)
  vias: v1(20.74,51.12) v1(40.94,40.14) v1(45.15,97.78) v1(45.15,96.13) v1(45.78,97.78) v1(45.78,96.13) v1(74.74,65.65) v1(75.09,71.66) v1(75.14,42.1) v1(75.57,70.19) v1(76.13,73.01) v1(76.07,65.65) v1(76.24,74.18) v1(76.29,71.66) v1(76.39,67.69) v1(76.46,66.73) v1(76.84,69.4) v1(76.92,70.19) v1(77.51,74.18) v1(77.46,71.66) v1(80.58,74.41) v1(80.91,44.56) v1(80.96,42.45) v1(81.24,74.92) v1(81.62,76.52) v1(82.03,42.46) v1(82.23,77.84) v1(82.94,42.39) v1(83.12,76.95) v1(83.63,81.42) v1(84.95,80.1) v1(87.03,42.43) v1(88.45,71.89) v1(89.04,42.43) v1(93.03,43.04) v1(93.89,56.25) v1(94.02,42.39) v1(94.89,60.58) v1(95.82,65.52) v1(96.1,67.55) v1(96.73,75.97) v1(96.69,60.52) v1(98.49,75.83) v1(98.92,34.12) v1(100.14,76.72) v1(100.14,74.92) v1(101.72,34.02) v1(101.81,74.84) v1(102.5,75.88) v1(103.19,72.5) v1(103.19,71.74) v1(103.19,70.98) v1(103.19,38.56) v1(103.85,116.47) v1(104.05,61.63) v1(104.05,52.16) v1(104.13,53.53) v1(104.35,34.02) v1(104.68,55.31) v1(105.09,116.45) v1(106.59,62.22) v1(108.98,53.45) v1(110.25,51.47) v1(110.7,102.25) v1(133.2,56.4) v1(133.21,55.8) v1(133.75,57.68) v1(133.78,60.17) v1(133.78,59.54) v1(133.78,58.9) v1(133.77,58.31) v1(133.79,56.39) v1(133.81,55.8) v1(134.39,60.16) v1(134.39,59.54) v1(134.38,58.89) v1(134.36,58.3) v1(134.35,57.66) v1(134.4,56.38) v1(134.41,55.78) v1(134.86,60.77) v1(135,60.11) v1(135,59.48) v1(135,58.84) v1(134.99,58.25) v1(134.95,57.66) v1(135.55,57.65) v1(135.56,60.77) v1(135.61,60.1) v1(135.61,59.48) v1(135.6,58.83) v1(135.58,58.24) v1(136.22,55.93) v1(136.19,55.33) v1(136.81,55.92) v1(136.78,55.33) v1(136.79,49.67) v1(136.85,66.23) v1(136.94,51.04) v1(136.93,50.41) v1(136.96,52.9) v1(136.96,52.27) v1(136.96,51.64) v1(137.05,49.14) v1(137.37,49.67) v1(137.5,66.22) v1(137.54,51.03) v1(137.53,50.39) v1(137.57,52.89) v1(137.57,52.27) v1(137.56,51.63) v1(137.63,49.14) v1(137.98,49.67) v1(138.12,66.22) v1(138.09,54.06) v1(138.08,53.43) v1(138.13,50.39) v1(138.18,52.84) v1(138.18,52.21) v1(138.18,51.57) v1(138.16,50.98) v1(138.22,49.11) v1(138.72,66.22) v1(138.69,54.05) v1(138.69,53.43) v1(138.73,50.39) v1(138.79,52.83) v1(138.79,52.21) v1(138.78,51.56) v1(138.76,50.97) v1(143.6,47.73) v1(143.6,47.15) v1(152.57,28.87) v2(0.95,122.03) v2(1.46,26.78) v2(2.22,25.01) v2(2.47,64.38) v2(2.6,111.11) v2(3.24,21.7) v2(3.62,46.85) v2(3.62,44.94) v2(3.62,43.42) v2(4,122.03) v2(4.51,105.22) v2(5.27,26.78) v2(5.4,20.69) v2(5.4,11.16) v2(5.55,109.36) v2(5.52,107.15) v2(5.65,121.02) v2(5.65,46.72) v2(5.78,112.13) v2(5.78,86.73) v2(5.78,84.95) v2(6.16,64.76) v2(6.28,67.55) v2(6.28,44.44) v2(6.92,62.22) v2(7.17,42.02) v2(7.68,121.91) v2(7.81,104.25) v2(7.94,88.12) v2(8.29,16.27) v2(8.57,44.44) v2(9.33,67.17) v2(9.71,84.95) v2(9.71,46.21) v2(9.71,42.66) v2(9.97,82.03) v2(9.97,62.6) v2(9.97,26.28) v2(10.02,23.74) v2(10.02,22.97) v2(9.99,22.21) v2(9.99,21.58) v2(9.99,20.94) v2(10.86,65.01) v2(11.36,118.99) v2(11.49,120.51) v2(12,118.99) v2(12.13,88.51) v2(12.15,10.04) v2(12.38,117.84) v2(12.38,103.87) v2(12.38,0.88) v2(12.63,118.99) v2(12.89,87.11) v2(12.89,86.35) v2(12.89,62.6) v2(12.89,26.4) v2(13.02,117.84) v2(13.02,46.85) v2(13.27,77.71) v2(13.73,12.2) v2(14.03,45.43) v2(14.03,44.44) v2(14.03,43.7) v2(14.03,19.39) v2(14.16,119.37) v2(14.29,9.36) v2(14.36,10.4) v2(14.54,26.28) v2(14.67,46.21) v2(14.67,42.79) v2(15.23,46.67) v2(15.17,26.28) v2(15.17,0.88) v2(15.38,36.31) v2(15.43,19.42) v2(15.45,56.22) v2(15.56,20.99) v2(15.68,34.91) v2(15.81,51.29) v2(15.81,50.41) v2(16.14,84.19) v2(16.19,82.92) v2(16.67,52.23) v2(16.67,21.93) v2(16.78,84.16) v2(16.83,82.92) v2(17,111.39) v2(17.08,118.1) v2(17.71,10.02) v2(18.1,0.88) v2(18.22,54.72) v2(18.86,35.27) v2(18.86,34.5) v2(18.98,16.5) v2(18.98,15.61) v2(18.98,14.64) v2(19.62,48.12) v2(19.87,16.5) v2(19.87,15.61) v2(19.87,14.64) v2(20.13,48.63) v2(20.64,48.12) v2(20.64,0.88) v2(20.66,49.14) v2(20.71,44) v2(20.76,15.61) v2(20.76,14.72) v2(21.19,31.13) v2(21.27,7.73) v2(21.37,53.71) v2(21.52,41.9) v2(21.52,41.26) v2(21.58,8.29) v2(21.78,118.1) v2(21.78,21.58) v2(21.91,7.73) v2(22.03,46.04) v2(21.96,31.13) v2(22.03,12.18) v2(22.21,8.29) v2(22.31,34.02) v2(22.29,28.94) v2(22.26,28.05) v2(22.29,27.04) v2(22.29,26.35) v2(22.41,21.58) v2(22.72,22.47) v2(22.92,55.99) v2(23.05,71.74) v2(23.05,71.11) v2(23.07,82.66) v2(23.2,80.76) v2(23.18,0.77) v2(23.3,41.64) v2(23.3,41.01) v2(23.43,78.73) v2(23.43,76.77) v2(23.4,74.87) v2(23.56,12.18) v2(23.66,61) v2(24.32,80.73) v2(24.32,54.22) v2(24.32,52.82) v2(24.55,41.92) v2(24.65,82.66) v2(24.57,71.74) v2(24.57,71.11) v2(24.98,76.82) v2(25.03,74.84) v2(25.21,90.41) v2(25.46,18.68) v2(25.54,18.05) v2(25.59,80.53) v2(25.59,41.92) v2(25.59,12.05) v2(25.72,39.31) v2(25.72,37.32) v2(25.72,0.77) v2(25.84,79.64) v2(25.84,71.74) v2(25.84,71.11) v2(25.87,78.24) v2(26.63,99.91) v2(26.6,90.66) v2(26.6,89.9) v2(26.6,88.12) v2(26.6,86.35) v2(26.6,85.71) v2(26.6,82.66) v2(26.6,81.27) v2(26.6,12.99) v2(26.73,118.1) v2(26.86,39.23) v2(26.99,36.38) v2(26.99,35.04) v2(26.99,33.9) v2(27.8,23.66) v2(28.15,99.88) v2(28.43,12.58) v2(28.38,0.77) v2(29.53,49.03) v2(29.6,101.08) v2(29.78,39.03) v2(30.59,7.35) v2(30.92,93.59) v2(30.92,0.77) v2(31.05,118.1) v2(31.3,101.05) v2(31.68,7.35) v2(31.94,93.59) v2(32.07,30.09) v2(32.07,29.45) v2(32.32,13.32) v2(32.5,99.55) v2(32.95,93.59) v2(32.95,13.32) v2(33.13,8.37) v2(33.34,0.77) v2(33.74,23.91) v2(33.66,15.58) v2(33.77,22.29) v2(33.97,122.41) v2(33.97,119.75) v2(34.33,15.58) v2(34.43,99.53) v2(34.38,23.91) v2(34.86,93.59) v2(35.24,13.32) v2(35.47,100.34) v2(35.88,0.77) v2(36.64,124.07) v2(36.64,12.69) v2(36.76,93.59) v2(37.35,14.67) v2(37.4,100.44) v2(38.42,0.77) v2(38.67,93.71) v2(38.75,60.06) v2(38.8,30.26) v2(38.8,28.76) v2(39.05,109.97) v2(39.13,109.33) v2(39.56,30.26) v2(39.56,28.76) v2(39.94,93.59) v2(40.14,26.15) v2(40.14,25.51) v2(40.17,38.54) v2(40.8,26.15) v2(40.8,25.51) v2(40.83,0.88) v2(40.91,36.79) v2(41.08,93.59) v2(41.14,48.36) v2(41.08,3.03) v2(41.3,99.3) v2(41.73,35.35) v2(42,100.75) v2(42.33,48.38) v2(43.32,45.92) v2(43.5,124.07) v2(43.57,104.38) v2(43.81,20.7) v2(43.98,21.32) v2(44.14,20.04) v2(44.38,104.61) v2(44.38,92.7) v2(44.45,20.6) v2(44.46,105.45) v2(44.64,83.04) v2(44.64,72) v2(44.63,21.23) v2(44.8,20.04) v2(45.11,20.6) v2(45.27,92.7) v2(45.29,21.23) v2(45.48,20.03) v2(45.6,101.94) v2(45.65,104.51) v2(45.65,49.52) v2(45.79,20.59) v2(45.93,100.52) v2(45.93,21.23) v2(45.96,27.82) v2(46.29,92.57) v2(46.42,10.27) v2(46.42,9.51) v2(46.42,6.84) v2(46.54,113.52) v2(46.8,83.04) v2(46.8,72) v2(46.95,102.22) v2(47.05,92.57) v2(47.18,113.52) v2(47.18,10.27) v2(47.18,9.51) v2(47.26,122.46) v2(47.46,99.81) v2(47.9,122.46) v2(47.94,10.27) v2(47.91,9.54) v2(48.27,113.98) v2(48.7,113.14) v2(48.7,6.84) v2(48.96,60.92) v2(49.34,113.14) v2(49.59,103.36) v2(49.59,9.13) v2(49.72,125.08) v2(49.85,11.04) v2(50.48,101.46) v2(51.47,125.59) v2(51.47,124.95) v2(52.13,11.8) v2(52.26,127.24) v2(52.26,101.97) v2(52.64,24.12) v2(52.83,32.31) v2(53.12,125.59) v2(53.12,124.95) v2(53.1,79.86) v2(53.36,82.45) v2(53.45,103.57) v2(53.57,93.07) v2(53.73,76.95) v2(53.82,46.41) v2(54.16,39.03) v2(54.25,35.89) v2(54.29,40.95) v2(54.45,82.41) v2(54.54,42.48) v2(54.72,125.59) v2(54.72,124.95) v2(54.67,11.8) v2(54.93,93.84) v2(55.18,111.75) v2(55.18,111.05) v2(55.18,110.41) v2(55.69,48.35) v2(55.69,40.95) v2(55.81,86.6) v2(55.81,42.47) v2(56.3,125.59) v2(56.3,124.95) v2(56.58,127.24) v2(57.34,25.51) v2(57.72,15.51) v2(57.97,25.51) v2(57.97,11.8) v2(58.48,98.46) v2(58.46,87.39) v2(58.61,25.51) v2(59.12,28.73) v2(59.24,25.51) v2(61.04,121.83) v2(61.28,109.1) v2(61.25,39.08) v2(61.53,127.24) v2(61.53,11.8) v2(61.68,121.83) v2(61.91,109.21) v2(61.86,37.71) v2(62.22,40.12) v2(62.52,114.06) v2(62.9,102.6) v2(63.08,25.08) v2(63.05,17) v2(63.44,122.12) v2(63.41,102.09) v2(63.36,35.32) v2(63.64,102.88) v2(63.76,37.71) v2(63.92,101.59) v2(63.92,22.11) v2(64.22,122.85) v2(64.2,66.53) v2(64.56,99.53) v2(64.7,54.72) v2(64.7,11.8) v2(64.78,58.09) v2(65.06,102.6) v2(65.06,101.97) v2(65.34,127.24) v2(65.54,67.25) v2(65.85,66.53) v2(65.85,47.99) v2(65.87,47.26) v2(65.97,54.72) v2(66.61,94.73) v2(66.74,47.99) v2(67.03,91.98) v2(66.99,37.68) v2(67.12,66.53) v2(67.24,54.72) v2(67.5,91.55) v2(67.63,120) v2(67.63,47.99) v2(67.72,123.62) v2(67.88,11.8) v2(68.27,123.14) v2(68.34,37.65) v2(68.39,123.79) v2(68.77,66.53) v2(69.15,127.24) v2(69.33,47.99) v2(69.66,53.2) v2(69.91,60.16) v2(70.04,66.53) v2(70.17,47.99) v2(70.8,11.8) v2(71.05,47.99) v2(71.69,53.2) v2(71.69,47.99) v2(71.89,60.16) v2(72.27,113) v2(72.31,111.69) v2(72.37,110.41) v2(73.34,127.11) v2(73.34,58.1) v2(73.55,111.68) v2(73.56,113.02) v2(73.59,110.3) v2(73.57,33.16) v2(73.72,41.13) v2(74.23,11.8) v2(74.8,113.02) v2(74.84,111.72) v2(74.84,110.37) v2(74.86,62.22) v2(74.92,39.66) v2(75.23,48.01) v2(75.15,43.67) v2(75.37,63.49) v2(75.73,60.13) v2(75.68,45.56) v2(75.83,46.85) v2(75.89,54.72) v2(75.91,41.16) v2(76.39,56.37) v2(76.42,43.67) v2(76.85,39.66) v2(76.9,11.8) v2(77.13,48.01) v2(77.2,58.05) v2(77.33,52.06) v2(77.4,127.11) v2(77.4,63.46) v2(77.4,53.4) v2(77.66,56.37) v2(78.09,50.78) v2(78.56,118.15) v2(78.57,117.49) v2(78.93,10.78) v2(79.82,125.08) v2(79.83,98.79) v2(80.14,103.29) v2(80.11,102.04) v2(80.1,100.79) v2(80.11,99.53) v2(80.33,101.42) v2(80.55,102.68) v2(80.48,100.13) v2(80.53,98.8) v2(80.47,97.36) v2(80.91,103.29) v2(80.89,102.05) v2(80.88,100.75) v2(80.9,99.52) v2(80.96,8.62) v2(81.12,97.34) v2(81.24,101.45) v2(81.32,102.68) v2(81.26,98.8) v2(81.64,100.74) v2(81.73,109.95) v2(81.71,108.7) v2(81.7,107.45) v2(81.7,106.18) v2(81.7,103.29) v2(81.66,102.05) v2(81.93,108.08) v2(82,102.69) v2(81.96,101.45) v2(82.14,109.34) v2(82.08,106.79) v2(82.5,109.95) v2(82.48,108.71) v2(82.47,107.41) v2(82.49,106.17) v2(82.83,108.1) v2(82.91,109.34) v2(83.09,114.92) v2(83.07,79.95) v2(83.24,107.4) v2(83.28,113.27) v2(83.3,109.95) v2(83.25,108.7) v2(83.4,37.53) v2(83.5,125.08) v2(83.5,7.23) v2(83.59,109.34) v2(83.55,108.1) v2(83.82,112.93) v2(84.03,112.33) v2(84.01,105.27) v2(84.44,104.81) v2(84.44,78.57) v2(84.85,82.46) v2(84.77,37.25) v2(84.91,105.25) v2(86.02,112.48) v2(86.1,116.21) v2(86.22,81.09) v2(86.55,126.35) v2(86.74,116.2) v2(86.68,112.48) v2(86.66,37.06) v2(86.68,6.84) v2(87.82,115.66) v2(88.15,90.59) v2(88.28,38.26) v2(88.28,36.97) v2(88.45,115.63) v2(88.45,112.64) v2(89.47,127.11) v2(89.72,7.61) v2(89.9,82.99) v2(90.49,117.08) v2(90.54,90.46) v2(91.2,117.05) v2(91.25,82.92) v2(92.01,9) v2(92.62,82.92) v2(92.77,127.11) v2(93.28,92.87) v2(93.58,81.52) v2(93.66,11.29) v2(94.04,92.87) v2(94.68,114.67) v2(94.68,114.03) v2(95.08,112.41) v2(95.24,19.01) v2(95.31,87.24) v2(95.31,84.44) v2(95.67,111.09) v2(95.67,109.13) v2(95.97,107.28) v2(96.45,11.8) v2(96.71,85.84) v2(98.11,87.24) v2(98.11,84.44) v2(99.55,112.03) v2(99.63,11.8) v2(100.01,22.47) v2(100.18,112.44) v2(100.17,111.78) v2(100.39,92.44) v2(102.42,82.26) v2(102.55,127.11) v2(103.29,103.19) v2(103.97,103.16) v2(104.07,11.8) v2(104.76,106.41) v2(104.89,94.19) v2(105.52,106.46) v2(105.5,102.07) v2(106.11,127.11) v2(106.44,56.34) v2(106.87,55.87) v2(107.5,11.8) v2(107.63,117.33) v2(107.63,116.57) v2(107.63,115.56) v2(108.14,112.67) v2(108.65,42.2) v2(108.65,41.57) v2(109.15,58.76) v2(109.51,107.07) v2(109.59,62.52) v2(109.66,69.84) v2(109.66,69.2) v2(109.66,67.37) v2(109.66,66.74) v2(109.66,64.88) v2(110.04,71.74) v2(110.04,11.8) v2(110.5,107.05) v2(110.55,127.11) v2(110.7,106.22) v2(110.7,103.22) v2(110.65,55.13) v2(110.81,41.35) v2(110.93,60.41) v2(110.86,56.6) v2(111.49,107.05) v2(111.49,106.29) v2(111.52,103.16) v2(111.51,41.35) v2(111.95,70.85) v2(111.95,70.22) v2(111.95,68.57) v2(111.95,67.93) v2(111.95,65.65) v2(111.95,63.99) v2(111.95,63.36) v2(111.95,59.17) v2(112.05,23.1) v2(112.08,11.8) v2(112.41,103.16) v2(112.53,107.07) v2(112.48,106.26) v2(112.71,62.09) v2(112.71,60.82) v2(113.09,85.46) v2(113.09,83.93) v2(113.35,102.25) v2(113.45,103.19) v2(113.5,107.07) v2(113.47,106.31) v2(114.06,21.12) v2(114.23,127.11) v2(114.21,60.82) v2(114.51,107.1) v2(114.51,106.39) v2(114.49,103.19) v2(114.62,15.25) v2(114.69,62.01) v2(114.68,61.36) v2(114.87,86.85) v2(114.87,85.46) v2(114.87,83.93) v2(115,11.8) v2(115.4,103.19) v2(115.48,107.12) v2(115.5,106.39) v2(115.64,76.04) v2(116.28,76.04) v2(117.79,11.8) v2(118.43,127.11) v2(118.48,83.04) v2(119.09,117.36) v2(119.16,123.58) v2(119.95,116.24) v2(120.33,11.8) v2(120.56,83.04) v2(121.32,72.73) v2(121.35,24.12) v2(121.73,117.46) v2(122.62,11.8) v2(123.12,127.11) v2(123.15,115.58) v2(123.38,11.8) v2(123.51,70.47) v2(123.75,44.94) v2(123.75,43.65) v2(123.79,115.61) v2(123.96,116.93) v2(124.14,70.47) v2(124.14,11.8) v2(124.18,69.84) v2(124.27,20.53) v2(124.38,44.94) v2(124.38,43.67) v2(124.47,109.76) v2(124.73,93.43) v2(124.78,113.93) v2(124.78,70.47) v2(124.81,69.78) v2(124.9,11.8) v2(125.31,106.39) v2(125.36,21.83) v2(125.41,20.53) v2(125.51,90.84) v2(125.56,90.21) v2(125.79,125.08) v2(125.97,110.59) v2(125.98,109.23) v2(126.22,100.28) v2(126.16,24.6) v2(126.34,113.86) v2(126.33,103.25) v2(126.25,101.4) v2(126.37,115.63) v2(126.43,20.53) v2(126.65,98.9) v2(126.79,112.58) v2(126.82,97.48) v2(126.93,11.8) v2(127.04,93.23) v2(127.24,96.08) v2(127.19,20.53) v2(127.44,106.32) v2(127.37,105.04) v2(127.45,110.59) v2(127.59,93.88) v2(127.67,109.67) v2(127.7,89.52) v2(128.07,24.6) v2(128.26,103.21) v2(128.28,100.26) v2(128.34,97.45) v2(128.36,89.78) v2(128.58,98.78) v2(128.59,11.8) v2(128.87,101.21) v2(129.02,92.52) v2(129.02,89.52) v2(129.14,96.01) v2(129.3,102.3) v2(129.26,20.89) v2(129.47,125.08) v2(129.9,20.89) v2(129.97,24.6) v2(129.98,11.8) v2(130.9,37.62) v2(131.51,11.8) v2(131.56,36.13) v2(132.37,87.13) v2(132.4,38.07) v2(132.88,106) v2(132.9,90.92) v2(132.9,11.8) v2(133.8,38.08) v2(134.35,85.51) v2(134.43,11.8) v2(134.96,25.36) v2(135.22,38.08) v2(135.28,47.15) v2(137.22,11.8) v2(138.03,35.8) v2(139.05,120.97) v2(139.42,42.87) v2(139.74,104.25) v2(139.76,11.8) v2(139.94,38.92) v2(140.76,83.8) v2(141.16,72.91) v2(142.43,11.8) v2(142.81,73.01) v2(143.17,72.43) v2(143.44,73.01) v2(143.4,31.66) v2(143.4,30.99) v2(143.83,72.43) v2(143.87,67.62) v2(144.08,73.01) v2(144.11,61.84) v2(144.06,31.65) v2(144.06,30.99) v2(144.08,10.02) v2(144.46,72.4) v2(144.71,72.99) v2(144.74,31.66) v2(144.74,30.98) v2(145.1,72.38) v2(145.14,54.89) v2(145.14,53.74) v2(145.12,52.41) v2(145.35,72.99) v2(145.39,31.66) v2(145.4,30.99) v2(145.58,32.42) v2(145.73,72.38) v2(145.98,72.99) v2(146.22,69.01) v2(146.36,54.88) v2(146.35,53.7) v2(146.37,52.42) v2(146.87,9.64) v2(147.13,14.46) v2(147.67,54.92) v2(147.66,53.69) v2(147.68,52.42) v2(148.04,42.65) v2(148.88,39) v2(149.03,18.4) v2(149.44,41.95) v2(149.6,38.3) v2(151.06,69.96) v2(151.19,116.06) v2(151.19,112.64) v2(151.19,108.95) v2(151.19,105.65) v2(151.19,102.35) v2(151.19,99.17) v2(151.19,96.25) v2(151.19,93.08) v2(151.19,90.54) v2(151.19,87.11) v2(151.19,83.43) v2(151.19,80) v2(151.19,76.95) v2(151.19,73.77) v2(151.19,66.92) v2(151.32,9.64) v2(151.45,63.99) v2(151.95,60.95) v2(152.33,43.04) v2(152.64,38.47) v2(152.84,45.83) v2(153.1,57.14) v2(153.35,39.99) v2(153.73,39.36) v2(153.99,18.4) v2(154.24,38.72) v2(154.49,53.71) v2(154.62,47.99) v2(154.75,38.09) v2(155.13,9.64) v2(155.26,18.43) v2(155.51,37.71) v2(156.02,50.53) v2(156.4,37.58) v2(156.53,18.4) v2(156.91,37.07) v2(157.8,36.94) v2(158.02,31.46) v2(158.2,18.43) v2(158.68,36.94) v2(159.68,35.42) v2(159.95,37.32) v2(159.95,9.64) v2(160.2,28.05) v2(160.31,19.14) v2(160.97,19.14) v2(163,38.98) v2(163.38,9.64) v2(164.68,34.94) v2(166.3,38.98) v2(166.74,21.7) v2(168.46,9.64) v2(168.97,37.2) v2(171.51,19.7) v2(171.77,9.64) v2(172.07,27.09) v2(172.27,35.42) v2(174.69,9.64) v2(176.97,34.15) v2(178.12,9.64) v2(179.26,34.15) v2(180.45,12.74) v2(180.91,9.64) v2(182.05,34.15) v2(183.55,31.15) v2(183.7,8.88) v2(185.3,25.69) v2(185.61,34.15) v2(185.91,18.3) v2(186.48,20.16) v2(186.52,14.24) v2(186.6,27.11) v2(186.81,25.1) v2(187.51,8.88) v2(187.62,22.29) v2(187.81,18.3) v2(188.4,34.28) v2(190.56,8.88) v2(191.96,34.53) v2(191.96,10.37) v2(192.72,10.37) v2(194.5,8.88) v2(195.13,35.04) v2(195.18,13.7) v2(195.26,11.04) v2(195.26,10.4) v2(195.64,14.72) v2(196.28,14.72) v2(196.91,14.72) v2(197.42,8.88) v2(197.8,35.8) v2(200.34,36.56) v2(200.85,8.88) v2(201.86,27.59) v2(201.86,26.32) v2(201.86,25.05) v2(202.37,37.32) v2(203.13,27.59) v2(203.13,26.32) v2(203.13,25.05) v2(203.21,19.82) v2(203.19,16.85) v2(204.4,27.59) v2(204.4,26.32) v2(204.4,25.05) v2(204.66,8.88) v2(205.04,38.72) v2(207.5,10.88) v2(207.58,40.12) v2(207.83,8.88) v2(208.34,14.46) v2(209.61,21.83) v2(209.87,41.77) v2(210.3,11.06) v2(210.37,21.83) v2(210.5,30.21) v2(210.5,29.45) v2(210.88,32.24) v2(211.39,8.88) v2(211.52,32.24) v2(211.64,21.96) v2(211.92,25.18) v2(212.02,11.82) v2(212.15,30.97) v2(212.43,43.8) v2(212.36,13.35) v2(212.46,10.91) v2(213.42,25.39) v2(213.42,24.62) v2(214.56,45.71) v2(214.95,27.04) v2(214.95,26.02) v2(214.95,8.88) v2(216.09,47.23) v2(216.34,17.51) v2(216.98,45.71) v2(217.1,29.96) v2(217.1,29.32) v2(217.1,28.69) v2(217.1,28.05) v2(217.51,32.37) v2(218.76,8.88) v2(219.01,43.55) v2(219.01,41.52) v2(219.01,38.85) v2(219.01,36.31) v2(219.01,33.51) v2(219.01,30.72) v2(219.01,27.8) v2(219.01,18.02) v2(219.01,15.48) v2(219.01,13.45) v2(219.01,10.91) v3(23.18,112.33) v3(23.71,112.89) v3(24.19,113.52) v3(24.52,7.1) v3(24.52,6.34) v3(25.26,7.1) v3(25.26,6.34) v3(65.09,104.53) v3(65.09,103.77) v3(67.63,122.9) v3(67.91,122.22) v3(68.97,123.15) v3(69.12,123.87) v3(69.78,97.17) v3(80.05,114.88) v3(80.35,115.58) v3(80.82,114.88) v3(81.1,115.6) v3(81.6,114.87) v3(81.92,115.57) v3(82.39,114.9) v3(83.33,112.44) v3(84.74,112.5) v3(87.36,112.51) v3(106.19,19.56) v3(106.39,20.27) v3(106.94,19.55) v3(107.18,20.27) v3(107.68,19.56) v3(107.93,20.27) v3(108.24,82.71) v3(108.43,19.55) v3(108.7,20.27) v3(109.19,19.58) v3(109.44,20.28) v3(109.54,82.79) v3(110.27,82.79) v3(111.67,82.79) v3(121.83,84.06) v3(121.91,85.33) v3(126.52,31.67) v3(126.52,30.93) v3(127.28,31.67) v3(127.28,30.93) v3(128.06,31.67) v3(128.06,30.93) v3(136.22,63.94) v3(136.22,63.2) v3(136.26,64.68) v3(136.73,62.51) v3(137.04,64.69) v3(136.96,63.96) v3(136.95,63.22) v3(137.47,62.46) v3(137.71,63.92) v3(137.69,63.16) v3(137.8,64.68) v3(138.21,62.5) v3(138.43,63.21) v3(138.46,63.95) v3(138.56,64.69) v3(139.37,42.08) v3(139.91,40.47) v3(140.1,42.87) v3(140.1,42.07) v3(140.11,41.23) v3(143.93,68.31) v3(144.28,68.97) v3(144.82,68.4) v3(145.32,68.97) v3(145.88,68.39)
