# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN1 (solid shape): 170.33,25.88 170.43,25.85 171.19,25.09 173.74,25.09 174.16,24.67 177.03,24.67 177.85,23.85 182.7,23.85 183.16,23.39 185.42,23.39 185.51,23.34 185.51,23.24 185.49,23.17 185.48,23.1 185.49,23.04 185.5,22.98 185.49,22.88 185.41,22.84 183.28,22.84 182.45,23.67 177.78,23.67 177.14,24.31 174.27,24.31 173.66,24.92 171.11,24.92 170.5,25.53 170.29,25.53 170.2,25.59 170.21,25.69 170.24,25.75 170.26,25.8
GND on IN1 (solid shape): 127.72,106.63 127.81,106.59 127.81,106.49 127.78,106.41 127.77,106.32 127.88,106.07 128.13,105.97 128.32,106.02 128.45,106.16 129.9,106.16 130.25,105.81 130.27,105.7 130.18,105.64 127.63,105.64 127.08,106.19 127.09,106.22 127.12,106.29 127.13,106.37 127.12,106.44 127.11,106.5 127.12,106.59 127.2,106.63
GND on IN1 (solid shape): 126.24,109.57 126.24,108.91 126.56,108.59 131.79,108.59 132.26,108.13 132.26,107.2 133.2,106.25 133.18,106.18 133.18,106.14 133.22,105.99 133.31,105.86 133.35,105.75 133.25,105.68 132.82,105.68 132.63,105.87 132.63,106.36 131.93,107.06 131.93,107.72 131.42,108.22 126.31,108.22 125.83,108.7 125.84,108.77 125.85,108.81 125.75,109.06 125.52,109.17 125.43,109.24 125.45,109.34 125.81,109.71 126.11,109.71
GND on IN1 (solid shape): 55.19,94.2 55.28,94.15 55.27,94.04 55.22,93.95 55.21,93.84 55.31,93.59 55.56,93.48 55.62,93.49 55.67,93.5 55.76,93.48 55.8,93.4 55.8,93.31 56.01,93.1 56.03,92.99 55.93,92.93 54.52,92.93 54.18,93.27 54.16,93.38 54.25,93.44 54.41,93.44 54.58,93.61 54.58,94.2 54.59,94.2
GND on IN1 (solid shape): 55.12,50.68 55.2,50.63 55.21,50.53 55.18,50.45 55.17,50.36 55.27,50.11 55.52,50.01 55.57,50.01 55.57,49.37 55.87,49.07 55.89,48.96 55.8,48.9 55.57,48.9 55.57,48.9 55.57,49.11 55.39,49.28 55.31,49.28 55.22,49.34 55.24,49.45 55.35,49.57 55.35,49.87 55.18,50.04 54.21,50.04 54.16,50.07 54.17,50.13 54.18,50.14 54.18,50.67 54.19,50.68
GND on IN1 (solid shape): 26.24,83.29 26.31,83.38 26.42,83.36 26.86,82.92 26.86,81.13 26.26,80.52 26.26,79.63 25.62,79 25.52,79 25.52,79.07 25.54,79.09 25.61,79.2 25.64,79.33 25.61,79.46 25.54,79.58 25.51,79.65 25.54,79.72 25.61,79.83 25.64,79.96 25.53,80.22 25.28,80.32 25.1,80.27 24.97,80.14 24.95,80.11 24.87,80.11 24.87,80.21 26.24,81.59
GND on IN1 (solid shape): 31.32,31.14 31.32,29.14 33.11,27.34 42.22,27.34 43.07,26.49 51.15,26.49 51.23,26.44 51.23,26.34 51.2,26.26 51.19,26.17 51.2,26.08 51.24,25.99 51.24,25.89 51.15,25.84 50.43,25.84 50,26.27 42.89,26.27 41.99,27.16 33.04,27.16 31.07,29.14 31.07,31.13 28.67,33.53 26.54,33.53 26.46,33.61 26.43,33.7 26.49,33.78 26.64,33.9 26.71,34.08 26.74,34.15 26.81,34.17 28.28,34.17
GND on IN1 (solid shape): 106.47,53.99 106.47,50.59 104.56,48.69 104.56,47.61 103.75,46.8 103.75,46.05 103.69,45.96 103.59,45.97 103.49,46.02 103.39,46.04 103.31,46.03 103.23,46 103.13,46 103.08,46.08 103.08,46.37 104.3,47.59 104.3,48.74 106.2,50.64 106.2,54 105.13,55.07 104.51,55.07 104.42,55.12 104.41,55.21 104.42,55.26 104.43,55.31 104.42,55.4 104.38,55.49 104.38,55.59 104.46,55.64 104.81,55.64
GND on IN1 (solid shape): 25.78,42.43 25.86,42.41 30.42,37.85 30.42,33.94 32.91,31.44 33.54,31.44 35.96,29.02 50.06,29.02 51.25,27.84 53.04,27.84 53.79,27.09 54.93,27.09 55.44,27.6 55.53,27.62 55.61,27.56 55.61,27.55 55.59,27.46 55.51,27.42 55.01,26.91 53.72,26.91 52.97,27.66 50.99,27.66 49.99,28.66 43.75,28.66 43.6,28.51 36.22,28.51 33.9,30.83 33.27,30.83 29.8,34.31 29.8,38.02 26.72,41.1 25.95,41.1 25.31,41.75 25.31,42.07 25.34,42.14 25.4,42.18 25.58,42.24 25.7,42.38
GND on IN1 (solid shape): 107.12,56.04 107.12,55.31 107.93,54.5 107.93,50.02 106.08,48.17 106.08,47.03 105.43,46.38 105.43,42.49 106.14,41.78 106.14,35.7 106.95,34.89 106.98,34.79 106.91,34.72 106.87,34.71 106.83,34.69 106.76,34.69 106.76,34.79 105.85,35.7 105.85,36.97 105.62,37.2 105.62,41.96 105.26,42.32 105.26,46.58 105.87,47.19 105.87,48.24 107.75,50.12 107.75,54.43 105.3,56.88 101.07,56.88 100.45,56.26 99.34,56.26 99.25,56.31 99.24,56.4 99.26,56.45 99.26,56.51 99.25,56.57 99.24,56.63 99.25,56.72 99.33,56.77 99.67,56.77 99.82,56.61 100.45,56.61 100.91,57.07 106.1,57.07
GND on IN1 (solid shape): 141.65,93.12 141.67,93.01 141.58,92.95 141.4,92.9 141.27,92.77 141.18,92.71 141.09,92.77 140.96,92.9 140.78,92.95 140.53,92.85 140.42,92.59 140.44,92.5 140.47,92.42 140.47,92.37 140.43,92.34 140.34,92.34 139.18,93.51 139.15,93.62 139.25,93.68 141.09,93.68
GND on IN1 (solid shape): 18.7,91.27 18.81,91.3 18.87,91.2 18.87,85.36 20.05,84.18 20.05,83.95 19.9,83.81 19.67,83.81 18.71,82.85 18.71,82.66 18.67,82.58 18.57,82.57 18.52,82.58 18.47,82.59 18.38,82.65 18.41,82.76 19.53,83.88 19.53,84.36 18.12,85.77 18.12,88.69 17.79,89.01 17.8,89.04 17.81,89.09 17.82,89.14 17.71,89.39 17.46,89.5 17.41,89.49 17.37,89.48 17.28,89.5 17.24,89.58 17.24,89.81
GND on IN1 (solid shape): 51.61,49.37 51.61,48.76 51.79,48.59 51.96,48.59 52.04,48.55 52.05,48.46 52.04,48.41 52.04,48.35 52.39,48 52.75,48.35 52.75,48.4 52.74,48.45 52.73,48.48 52.86,48.61 53.33,48.61 53.42,48.56 53.43,48.47 53.41,48.41 53.41,48.35 53.47,48.16 53.62,48.03 53.62,47.77 53.59,47.75 51.5,47.75 51.5,49.37 51.5,49.37 51.61,49.37
GND on IN1 (solid shape): 129.74,17.38 129.84,17.32 129.81,17.21 129.63,17.03 129.6,17.03 129.55,17.04 129.5,17.05 129.25,16.94 129.15,16.69 129.15,16.63 129.17,16.57 129.15,16.48 129.07,16.44 123.97,16.44 123.89,16.48 123.88,16.58 123.9,16.64 123.9,16.71 123.88,16.84 123.81,16.95 123.79,17.06 123.88,17.12 125.48,17.12 125.64,16.96 129.05,16.96 129.47,17.38
GND on IN1 (solid shape): 34.68,57.64 34.7,57.65 34.73,57.66 34.76,57.65 34.79,57.64 34.81,57.62 34.83,57.6 34.84,57.57 34.84,57.55 34.84,56.18 34.8,56.14 33.15,56.14 33.14,56.13 33.11,56.11 33.08,56.11 33.05,56.11 33.02,56.12 33,56.14 32.98,56.17 32.97,56.2 32.97,56.21 32.97,56.68 33.81,56.68 33.81,56.63 33.82,56.58 33.84,56.53 33.86,56.48 33.89,56.44 33.93,56.4 33.97,56.37 34.02,56.35 34.06,56.33 34.12,56.33 34.17,56.33 34.22,56.33 34.27,56.35 34.32,56.37 34.36,56.4 34.39,56.44 34.42,56.48 34.45,56.53 34.46,56.58 34.47,56.63 34.47,56.68 34.46,56.73 34.45,56.78 34.42,56.83 34.39,56.87 34.36,56.91 34.32,56.94 34.27,56.96 34.22,56.98 34.17,56.99 34.12,56.99 34.06,56.98 34.02,56.96 33.97,56.94 33.93,56.91 33.89,56.87 33.86,56.83 33.84,56.78 33.82,56.73 33.81,56.68 32.97,56.68 32.97,57.58 33.02,57.62 34.67,57.62
GND on IN1 (solid shape): 59.24,49.42 59.26,49.31 59.17,49.25 58.76,49.25 58.48,48.97 58.48,45.39 58.48,45.39 58.23,45.39 58.23,45.39 58.23,47 57.95,47.27 55.86,47.27 55.77,47.37 55.77,47.51 55.77,47.52 57.95,47.52 58.23,47.79 58.23,50.2 57.95,50.48 57.42,50.48 57.01,50.07 57.01,49.4 56.98,49.36 56.69,49.36 56.58,49.46 56.15,49.46 56.04,49.56 56.04,49.93 56.09,50.01 56.18,50.02 56.23,50.01 56.28,50.01 56.54,50.11 56.64,50.36 56.63,50.45 56.6,50.53 56.6,50.63 56.69,50.68 57.98,50.68
GND on IN1 (solid shape): 11.89,81.75 11.98,81.69 11.96,81.57 11.77,81.39 11.58,81.39 10.84,80.65 10.84,79.69 10.29,79.15 10.26,79.16 10.16,79.2 10.05,79.21 9.9,79.19 9.76,79.12 9.65,79.11 9.6,79.2 9.6,80.2 9.65,80.29 9.76,80.28 9.9,80.21 10.05,80.19 10.41,80.34 10.56,80.7 10.55,80.81 10.51,80.91 10.5,80.94 11.31,81.75
GND on IN1 (solid shape): 138.35,87.91 138.6,87.91 139.31,87.21 139.31,86.84 139.33,86.82 139.3,86.76 138.74,86.76 138.65,86.81 138.66,86.92 138.7,87.01 138.72,87.11 138.36,87.47 138.01,87.11 138.02,87.01 138.06,86.92 138.07,86.81 137.98,86.76 137.68,86.76 137.25,87.18 137.25,88.06 136.55,88.76 136.53,88.87 136.63,88.94 137.33,88.94
GND on IN1 (solid shape): 39.62,66.64 39.7,66.66 39.78,66.61 39.91,66.48 40.09,66.43 40.19,66.45 40.29,66.5 40.4,66.5 40.45,66.41 40.45,52.1 39.85,51.51 39.75,51.48 39.68,51.57 39.6,51.76 39.42,51.87 39.34,51.94 39.37,52.04 39.83,52.5 39.83,65.2 39.62,65.41 38.73,65.41 38.69,65.45 38.69,65.58 38.73,65.63 39.62,65.63 39.83,65.84 39.83,66.21 39.62,66.43 39.11,66.43 39.07,66.47 39.07,66.6 39.11,66.64
GND on IN1 (solid shape): 52.07,46.73 52.16,46.68 52.17,46.59 52.15,46.53 52.14,46.46 52.16,46.36 52.2,46.26 52.21,46.16 52.12,46.11 51.89,46.11 51.67,45.89 51.67,45.61 51.85,45.43 51.87,45.43 51.95,45.38 51.95,45.28 51.92,45.19 51.9,45.1 51.92,44.98 51.98,44.87 51.99,44.77 51.9,44.71 51.65,44.71 51.48,44.53 51.48,44.06 51.59,43.95 51.6,43.9 51.55,43.87 51.41,43.87 51.37,43.91 51.37,46.66 51.44,46.73
GND on IN1 (solid shape): 55.27,48.99 55.27,48.78 55.45,48.61 55.86,48.61 55.99,48.47 55.98,48.45 55.97,48.4 55.97,48.35 55.98,48.24 56.03,48.15 56.04,48.04 55.95,47.99 55.58,47.99 55.29,47.69 55.23,47.68 55.2,47.73 55.2,47.8 55.3,47.91 55.3,48.18 55.26,48.22 55.27,48.25 55.28,48.3 55.28,48.35 55.18,48.6 54.93,48.7 54.83,48.69 54.75,48.66 54.7,48.66 54.67,48.7 54.67,48.76 54.61,48.82 54.59,48.93 54.69,48.99 55.27,48.99
GND on IN1 (solid shape): 67.1,103.28 67.1,103.28 66.89,103.07 66.89,102.63 67.37,102.15 67.81,102.15 68.02,102.36 68.02,102.36 69.39,101 69.41,100.89 69.31,100.82 68.62,100.82 68.54,100.87 68.53,100.96 68.54,101.02 68.55,101.08 68.44,101.33 68.19,101.43 67.97,101.36 67.84,101.16 67.77,101.08 67.67,101.11 65.96,102.83 65.94,102.94 66.03,103 66.4,103 66.89,103.49 66.89,103.49
GND on IN1 (solid shape): 57.41,77.44 57.43,77.44 57.46,77.43 57.48,77.41 57.5,77.39 57.51,77.36 57.52,77.33 57.51,77.3 57.5,77.27 57.4,77.17 57.4,76.42 57.57,76.25 58.33,76.25 58.34,76.24 58.34,75.9 58.34,75.88 58.33,75.85 58.31,75.83 58.29,75.81 58.26,75.8 58.23,75.79 58.2,75.8 58.17,75.81 58.16,75.82 57.84,76.14 55.94,76.14 55.77,76.31 55.77,76.97 55.97,76.97 55.97,76.92 55.98,76.87 55.99,76.82 56.01,76.77 56.04,76.73 56.08,76.69 56.12,76.65 56.17,76.63 56.22,76.61 56.27,76.6 56.32,76.59 56.38,76.6 56.43,76.61 56.48,76.63 56.52,76.65 56.57,76.69 56.6,76.73 56.63,76.77 56.65,76.82 56.67,76.87 56.68,76.92 56.68,76.97 56.67,77.03 56.65,77.08 56.63,77.13 56.6,77.17 56.57,77.21 56.52,77.24 56.48,77.27 56.43,77.29 56.38,77.3 56.32,77.3 56.27,77.3 56.22,77.29 56.17,77.27 56.12,77.24 56.08,77.21 56.04,77.17 56.01,77.13 55.99,77.08 55.98,77.03 55.97,76.97 55.77,76.97 55.77,77.43 55.77,77.44
GND on IN1 (solid shape): 136.73,94.61 136.73,94.33 136.77,94.3 136.79,94.19 136.69,94.13 135.52,94.13 135.43,94.18 135.43,94.28 135.48,94.37 135.49,94.47 135.13,94.83 134.78,94.47 134.78,94.47 134.72,94.37 134.6,94.4 134.02,94.98 133.44,94.98 133.3,94.84 133.26,94.89 133.24,94.95 133.25,95.05 133.33,95.09 136.25,95.09
GND on IN1 (solid shape): 145.04,44.46 145.1,44.4 145.18,44.29 145.28,44.22 145.28,41.5 145.51,41.28 145.51,37.53 145.46,37.45 145.37,37.44 145.31,37.45 145.25,37.46 144.9,37.1 145.25,36.75 145.31,36.75 145.37,36.77 145.46,36.75 145.51,36.67 145.51,34.78 145.44,34.68 145.33,34.71 144.75,35.29 144.75,44.32 144.82,44.39 144.9,44.41 144.95,44.44
GND on IN1 (solid shape): 185.53,13.58 185.52,13.55 185.51,13.5 185.51,13.45 185.51,13.4 185.43,13.4 185.33,13.34 185.32,13.32 185.23,13.23 185.1,13.19 185.01,13.21 184.92,13.26 184.78,13.32 184.64,13.26 184.56,13.21 184.47,13.19 184.34,13.23 184.25,13.32 184.23,13.34 184.14,13.4 181.77,13.4 181.56,13.19 181.55,13.14 181.53,13.06 181.49,12.99 181.47,12.98 181.44,12.91 181.44,12.41 181.52,12.34 181.53,12.28 181.48,12.25 179.27,12.25 179.18,12.31 179.2,12.42 180.48,13.7 185.4,13.7
GND on IN1 (solid shape): 65.97,104.41 65.97,104.41 65.45,103.89 65.45,103.42 65.39,103.4 65.38,103.41 64.64,103.41 64.13,103.91 64.11,104 64.17,104.08 64.36,104.23 64.43,104.46 64.42,104.52 64.4,104.59 64.41,104.67 64.47,104.72 64.7,104.87 64.78,105.12 64.66,105.4 64.37,105.52 64.28,105.51 64.18,105.48 64.1,105.47 64.04,105.53 64.03,105.54 64.04,105.64 64.13,105.68 64.7,105.68
GND on IN1 (solid shape): 101.9,62.16 101.9,61.96 102.42,61.43 102.74,61.43 104.59,59.59 107.06,59.59 109.19,57.46 109.19,56.17 114.29,51.07 114.29,45.41 114.54,45.15 114.54,40.92 114.11,40.5 114.11,39.51 114.06,39.42 113.95,39.43 113.85,39.49 113.74,39.51 113.64,39.49 113.56,39.45 113.45,39.45 113.4,39.54 113.4,40.03 114.36,40.99 114.36,45.09 114.11,45.33 114.11,51 109.02,56.09 109.02,57.38 106.98,59.42 104.49,59.42 102.68,61.23 102.37,61.23 101.66,61.95 101.66,62.12 100.5,63.27 99.94,63.27 99.86,63.32 99.85,63.41 99.86,63.47 99.87,63.53 99.87,63.58 99.86,63.62 99.87,63.71 99.95,63.75 100.3,63.75
GND on IN1 (solid shape): 110.34,29.74 110.4,29.71 110.51,29.65 110.63,29.63 110.68,29.63 110.72,29.64 110.82,29.63 110.86,29.54 110.86,25.32 113.42,22.75 116.25,22.75 116.41,22.91 121.49,22.91 122.09,23.51 122.2,23.51 122.28,23.47 122.29,23.37 122.27,23.3 122.26,23.23 122.29,23.08 122.38,22.96 122.41,22.89 122.38,22.82 122.04,22.48 119.85,22.48 119.69,22.32 113.24,22.32 110.13,25.44 109.81,26.2 109.81,29.55 109.85,29.63 109.94,29.64 109.99,29.63 110.04,29.63 110.16,29.65 110.27,29.71
GND on IN1 (solid shape): 97.39,32.05 97.44,32.13 97.54,32.14 97.62,32.1 97.71,32.09 97.76,32.1 97.82,32.11 97.91,32.1 97.95,32.01 97.95,31.97 97.32,31.34 97.32,29.77 96.88,29.33 96.88,26.98 95.9,26 95.81,25.97 95.74,26.03 95.68,26.12 95.59,26.19 95.59,26.6 95.79,26.8 95.79,29.15 95.92,29.28 95.97,29.45 95.88,29.68 95.64,29.78 95.52,29.76 95.42,29.69 95.35,29.67 95.28,29.69 95.26,29.71 95.26,29.79 95.37,29.79 97.39,31.81
GND on IN1 (solid shape): 60.68,98.83 62.07,98.83 63.31,97.59 64.13,97.59 67.33,94.39 67.33,93.54 73.29,87.57 80.48,87.57 83.37,84.68 83.37,84.56 83.34,84.51 83.28,84.52 80.42,87.38 73.27,87.38 67.21,93.44 67.21,93.7 66.36,94.55 66.36,95.06 64,97.41 63.28,97.41 62.01,98.68 60.57,98.68 59.63,99.62 56.15,99.62 55.72,99.19 53.43,99.19 53,98.76 50.17,98.76 47.3,95.9 45.31,95.9 40.86,91.45 30.86,91.45 30.3,90.89 28.53,90.89 27.89,91.52 26.33,91.52 25.75,90.94 25.75,90.17 25.49,89.92 25.21,89.92 25.2,89.96 25.08,90.15 24.86,90.23 24.69,90.18 24.56,90.06 24.54,90.04 24.47,90.04 24.47,90.15 25.95,91.64 28.56,91.64 29.07,91.13 29.82,91.13 30.33,91.64 40.34,91.64 45.06,96.36 47.62,96.36 50.15,98.89 52.88,98.89 53.35,99.36 55.64,99.36 56.03,99.75 59.76,99.75
GND on IN1 (solid shape): 61.83,37.96 62.06,37.96 62.14,37.92 62.15,37.82 62.14,37.77 62.13,37.71 62.14,37.64 62.16,37.57 62.15,37.47 62.07,37.43 62.06,37.43 61.86,37.22 61.65,37.43 61.48,37.43 61.4,37.47 61.38,37.56 61.4,37.62 61.4,37.68 61.05,38.04 60.69,37.68 60.7,37.61 60.72,37.54 60.73,37.51 60.67,37.45 60.55,37.57 60.48,37.57 60.38,37.63 60.41,37.74 60.43,37.77 60.43,38.15 60.47,38.19 61.6,38.19
GND on IN1 (solid shape): 120.59,118.17 120.68,118.11 120.66,118 119.64,116.97 118.61,116.97 115.1,113.46 115.1,112.96 115.05,112.87 114.95,112.87 114.87,112.9 114.78,112.91 114.72,112.91 114.66,112.89 114.57,112.91 114.53,112.99 114.53,113.28 119.06,117.81 119.18,117.84 119.24,117.74 119.34,117.49 119.59,117.38 119.85,117.49 119.95,117.74 119.92,117.88 119.84,118 119.82,118.11 119.91,118.17
GND on IN1 (solid shape): 99.78,45.13 99.83,45.21 99.93,45.22 100,45.19 100.09,45.18 100.17,45.14 100.19,45.06 100.19,45.02 100.29,44.79 100.52,44.69 100.61,44.7 100.69,44.74 100.8,44.74 100.85,44.65 100.85,42.81 99.19,41.15 98.27,41.15 94.71,37.6 94.71,35.91 93.6,34.8 93.47,34.8 91.41,32.74 91.41,32.72 91.38,32.68 91.32,32.68 91.3,32.7 91.27,32.72 91.21,32.79 91.24,32.88 93.43,35.07 93.55,35.07 94.52,36.04 94.52,38.61 96.64,40.73 97.29,40.73 97.88,41.33 98.76,41.33 100.28,42.85 100.28,43.99 99.78,44.5
GND on IN1 (solid shape): 68.6,94.26 68.7,94.23 70.53,92.4 70.53,91.75 73.57,88.71 75.22,88.71 75.69,88.24 75.71,88.13 75.62,88.07 73.5,88.07 69.11,92.46 69.08,92.55 69.15,92.62 69.33,92.77 69.4,93 69.29,93.29 69,93.41 68.96,93.41 68.87,93.43 68.84,93.52 68.85,93.56 68.77,93.8 68.56,93.95 68.5,94.01 68.5,94.09 68.52,94.13 68.53,94.18
GND on IN1 (solid shape): 116.67,110.54 116.71,110.63 116.81,110.63 116.88,110.61 116.95,110.6 117.02,110.57 117.05,110.5 117.05,109.66 117.07,109.59 117.13,109.53 117.16,109.51 117.19,109.48 117.24,109.45 117.29,109.43 117.45,109.36 117.51,109.21 117.44,109.04 117.27,108.98 117.11,108.92 117.05,108.77 117.05,108.47 116.99,108.37 116.87,108.4 116.46,108.81 115.94,108.81 115.86,108.86 115.85,108.95 115.87,108.99 115.88,109.04 116.67,109.83
GND on IN1 (solid shape): 104.28,52.27 104.28,51.49 101.77,48.98 101.77,47.77 100.85,46.85 100.85,45.39 100.8,45.3 100.69,45.3 100.61,45.34 100.51,45.35 100.43,45.38 100.41,45.47 100.41,45.51 100.31,45.74 100.08,45.84 100,45.83 99.93,45.8 99.83,45.8 99.78,45.89 99.78,46.05 101.58,47.86 101.58,49.56 103.39,51.36 103.39,51.73 103.41,51.8 103.7,51.94 103.79,52.17 103.78,52.25 103.75,52.32 103.75,52.42 103.84,52.47 104.09,52.47
GND on IN1 (solid shape): 114.23,118.99 114.49,119.24 114.74,118.99 114.74,118.97 114.8,118.82 114.95,118.76 116.09,118.76 116.19,118.69 116.17,118.58 115.7,118.12 111.76,118.12 111.25,118.62 109.06,118.62 108.86,118.42 108.75,118.4 108.69,118.49 108.69,118.71 108.74,118.76 108.74,118.76 108.85,118.86 108.85,118.92 109.1,119.16 109.36,118.92 109.36,118.86 109.47,118.76 114.03,118.76 114.18,118.82 114.24,118.97
GND on IN1 (solid shape): 72.25,60.52 72.28,60.46 72.26,60.39 72.19,60.28 72.17,60.16 72.19,60.06 72.23,59.97 72.23,59.86 72.14,59.81 69.62,59.81 69.54,59.86 69.54,59.97 69.58,60.06 69.6,60.16 69.24,60.51 68.88,60.16 68.9,60.06 68.94,59.97 68.94,59.86 68.85,59.81 68.08,59.81 65.42,62.47 65.4,62.58 65.49,62.64 70.13,62.64
GND on IN1 (solid shape): 183.17,19.3 187.94,19.3 188.57,18.66 188.85,18.66 188.94,18.61 188.94,18.51 188.9,18.42 188.89,18.32 188.89,18.26 188.91,18.19 188.9,18.09 188.82,18.05 187.61,18.05 187.53,18.09 187.51,18.18 187.53,18.24 187.53,18.3 187.43,18.55 187.18,18.66 187.14,18.67 187.12,18.71 187.12,18.79 186.8,19.11 182.82,19.11 181.61,20.32 180.49,20.32 180.4,20.37 180.4,20.47 180.44,20.56 180.45,20.66 180.45,20.73 180.42,20.8 180.43,20.9 180.52,20.95 181.52,20.95
GND on IN1 (solid shape): 82.16,43.61 82.27,43.63 82.33,43.53 82.33,43.45 82.51,43.27 82.55,43.27 82.64,43.23 82.65,43.13 82.62,43.06 82.61,42.98 82.61,42.94 82.63,42.88 82.34,42.59 82.34,42.41 82.14,42.22 81.66,42.22 81.45,42.01 81.24,42.22 80.76,42.22 80.67,42.28 80.69,42.39 80.73,42.43 80.73,42.84 80.73,42.84 80.9,42.84 81.31,42.43 81.61,42.43 81.92,42.73 81.99,42.72 82.03,42.72 82.36,43.05 82.03,43.38 81.98,43.38 81.93,43.36 81.85,43.37 81.8,43.42 81.78,43.48 81.78,43.54 82.1,43.54
GND on IN1 (solid shape): 60.61,97.34 60.62,97.29 60.58,97.26 60.48,97.26 59.71,98.02 59.58,98.02 59.5,98.06 59.48,98.13 59.48,98.16 59.12,98.51 58.76,98.16 58.79,98.02 58.86,97.91 58.89,97.84 58.86,97.77 58.82,97.71 58.78,97.64 58.71,97.57 58.61,97.6 58.16,98.05 57.92,98.05 57.83,98.11 57.85,98.22 57.92,98.34 57.95,98.47 57.94,98.53 57.93,98.59 57.94,98.68 58.02,98.72 59.23,98.72
GND on IN1 (solid shape): 85.87,93.58 85.87,91.14 87.71,89.3 90.73,89.3 92.85,87.18 92.85,85.38 92.8,85.3 92.71,85.28 92.65,85.3 92.59,85.31 92.45,85.28 92.33,85.19 92.22,85.16 92.16,85.26 92.16,87.71 90.71,89.16 87.23,89.16 87.15,89.21 87.14,89.3 87.17,89.38 87.18,89.45 87.07,89.71 86.82,89.81 86.59,89.73 86.47,89.52 86.4,89.44 86.3,89.47 85.77,90 85.34,90 85.24,90.06 85.26,90.18 85.49,90.4 85.49,93.56 85.55,93.62 85.83,93.62
GND on IN1 (solid shape): 95.89,45.48 95.96,45.45 96.05,45.44 96.11,45.44 96.17,45.46 96.26,45.45 96.31,45.36 96.31,45 96.26,44.95 95.62,44.95 95.22,44.55 95.22,43.02 92.88,40.69 92.88,39.85 92.27,39.24 92.27,38.64 92.23,38.56 92.13,38.55 92.07,38.56 92.01,38.57 91.93,38.56 91.86,38.53 91.74,38.55 91.72,38.66 92.23,39.9 92.23,40.48 93.77,42.01 93.77,42.58 93.81,42.66 93.9,42.67 93.94,42.66 93.99,42.66 94.23,42.75 94.32,42.99 94.28,43.16 94.15,43.28 94.1,43.36 94.12,43.44 94.9,44.22 94.9,44.54 95.85,45.5
GND on IN1 (solid shape): 85.67,46.8 85.67,46.76 85.76,46.52 86,46.43 86.04,46.43 86.11,46.44 86.28,46.27 86.64,46.27 86.73,46.22 86.74,46.13 86.72,46.06 86.71,45.99 86.81,45.76 87.04,45.66 87.08,45.67 87.15,45.68 87.34,45.49 87.27,45.42 87.24,45.45 87.14,45.5 87.04,45.51 86.82,45.43 86.71,45.22 86.64,45.14 86.54,45.16 86.4,45.3 86.3,45.3 86.17,45.44 86,45.49 85.94,45.48 85.89,45.47 85.8,45.48 85.76,45.56 85.76,46.12 85.55,46.33 85.55,46.79 85.62,46.85
GND on IN1 (solid shape): 85.18,42.71 85.21,42.66 85.21,41.72 85.36,41.56 85.36,41.11 81.7,37.45 74.18,37.45 73.97,37.24 73.97,36.92 72.69,35.64 70.43,35.64 70.39,35.69 70.39,35.85 70.18,36.06 69.89,36.06 69.81,35.98 69.7,35.96 69.64,36.05 69.64,36.7 69.42,36.91 69.09,36.91 69.04,36.95 69.04,37.18 69,37.23 69.05,37.27 69.07,37.28 69.18,37.31 69.28,37.38 69.35,37.41 69.42,37.38 69.52,37.28 69.74,37.28 69.85,37.39 69.96,37.41 70.02,37.32 70.02,36.73 70.29,36.46 70.61,36.46 71.01,36.05 71.87,36.05 72.09,36.26 72.09,36.32 72.12,36.36 72.17,36.35 72.35,36.17 72.65,36.17 72.82,36.35 72.82,36.81 72.89,36.91 73,36.88 73.05,36.83 73.3,36.83 73.51,37.04 73.51,37.85 73.52,37.86 81.43,37.86 85.05,41.48 85.05,42.65 85.09,42.67 85.12,42.7
GND on IN1 (solid shape): 92.16,84.64 92.22,84.73 92.33,84.71 92.45,84.62 92.59,84.59 92.7,84.61 92.8,84.66 92.83,84.68 95.41,82.1 95.44,82.01 95.38,81.93 95.22,81.8 95.16,81.61 95.16,81.55 95.13,81.45 95.02,81.44 94.95,81.46 94.88,81.47 94.75,81.44 94.63,81.37 94.56,81.34 94.49,81.37 94.38,81.44 94.25,81.47 93.99,81.37 93.89,81.11 93.89,81.09 93.83,80.99 93.72,81.01 92.28,82.44 92.28,84.47 92.16,84.59
GND on IN1 (solid shape): 56.92,102.68 59.16,102.68 59.39,102.46 61.97,102.46 63.97,100.46 65.58,100.46 66.33,99.71 66.36,99.62 66.3,99.55 66.21,99.48 66.14,99.38 66.06,99.32 65.97,99.35 65.04,100.28 63.88,100.28 61.92,102.24 59.34,102.24 59.11,102.47 57.54,102.47 57.11,102.04 55.01,102.04 54.62,101.64 54.18,101.64 54.1,101.69 54.09,101.79 54.11,101.85 54.11,101.92 54.11,101.96 54.11,101.99 54.12,102.07 54.19,102.11 54.29,102.15 54.37,102.21 54.44,102.24 54.51,102.21 54.63,102.13 54.76,102.11 55.01,102.21 55.12,102.46 55.11,102.55 55.07,102.64 55.07,102.74 55.16,102.79 56.82,102.79
GND on IN1 (solid shape): 113.24,36.44 113.33,36.46 113.41,36.41 113.48,36.31 113.57,36.24 113.63,36.17 113.6,36.08 112.37,34.84 112.37,33.18 112.93,32.62 112.93,27.63 115.23,25.33 115.94,25.33 116.29,24.99 120.26,24.99 120.9,25.63 128.73,25.63 128.87,25.49 128.87,24.98 128.83,24.93 128.8,24.94 128.75,24.95 128.7,24.95 128.45,24.85 128.34,24.6 128.35,24.54 128.36,24.48 128.35,24.39 128.27,24.34 127.86,24.34 127.78,24.39 127.77,24.48 127.78,24.54 127.79,24.6 127.69,24.84 127.43,24.97 127.41,25 127.41,25.11 127.07,25.45 121.14,25.45 120.49,24.81 116.21,24.81 115.87,25.15 115.15,25.15 112.75,27.56 112.75,32.55 112.19,33.1 112.19,34.97 112.86,35.63 112.86,36.05
GND on IN1 (solid shape): 67.26,37.95 67.35,37.9 67.36,37.8 67.33,37.73 67.32,37.65 67.34,37.53 67.41,37.42 67.44,37.39 67.21,37.16 67.21,36.73 67.09,36.62 67.09,36.27 67.09,36.26 65.21,36.26 65.04,36.43 60.95,36.43 60.32,35.79 59.17,35.79 58.32,36.64 57.49,36.64 57.4,36.69 57.4,36.79 57.43,36.87 57.43,36.95 57.46,37.02 57.54,37.05 58.93,37.05 58.95,36.99 58.94,36.97 58.94,36.63 59.37,36.2 60.03,36.2 60.33,36.5 60.33,37.24 60.37,37.28 60.43,37.28 60.44,37.26 60.44,37.05 60.66,36.83 61.26,36.83 61.48,37.06 61.71,36.83 62.01,36.83 62.21,37.04 62.42,36.83 62.72,36.83 62.92,37.04 63.13,36.83 63.43,36.83 63.63,37.04 63.84,36.83 64.14,36.83 64.35,37.04 64.55,36.83 64.99,36.83 65.2,37.04 65.4,36.83 65.65,36.83 65.76,36.72 66.64,36.72 66.8,36.88 66.8,37.23 66.58,37.45 66.6,37.49 66.65,37.59 66.67,37.7 66.66,37.76 66.65,37.81 66.66,37.91 66.74,37.95
GND on IN1 (solid shape): 103.32,82.65 103.42,82.65 103.47,82.56 103.47,81.66 105.43,79.7 105.43,78.96 105.96,78.43 105.96,75.77 105.43,75.25 105.43,68.99 101.7,65.26 99.92,65.26 99.83,65.31 99.83,65.4 99.85,65.47 99.86,65.54 99.85,65.6 99.84,65.65 99.85,65.75 99.94,65.79 101.54,65.79 102.26,66.51 102.61,66.51 105.26,69.16 105.26,75.51 105.75,76 105.75,77.85 104.57,79.02 104.54,79.11 104.6,79.19 104.75,79.32 104.81,79.51 104.71,79.77 104.46,79.87 104.26,79.81 104.13,79.66 104.06,79.6 103.97,79.63 103.28,80.31 103.28,82.46 103.27,82.47 103.24,82.56 103.3,82.64
GND on IN1 (solid shape): 170.32,25.01 170.35,24.92 170.29,24.84 170.14,24.71 170.09,24.52 170.19,24.27 170.45,24.17 170.66,24.24 170.79,24.43 170.79,24.44 170.84,24.49 170.91,24.42 173.46,24.42 174.06,23.82 176.93,23.82 177.57,23.18 178.28,23.18 178.36,23.13 178.37,23.03 178.34,22.95 178.33,22.87 178.34,22.81 178.35,22.75 178.34,22.66 178.26,22.62 177.06,22.62 176.78,22.89 173.85,22.89 172.76,23.99 170.1,23.99 169.86,24.23 169.83,24.3 169.85,24.37 169.92,24.48 169.94,24.6 169.91,24.74 169.82,24.86 169.8,24.97 169.89,25.04 170.29,25.04
GND on IN1 (solid shape): 138.32,93.91 138.35,93.82 138.28,93.75 138.11,93.62 138.04,93.41 138.14,93.16 138.4,93.05 138.6,93.12 138.73,93.29 138.81,93.36 138.9,93.33 139.13,93.11 139.15,93.01 139.08,92.94 138.96,92.87 138.87,92.77 138.78,92.72 138.69,92.77 138.56,92.9 138.38,92.95 138.16,92.88 138.04,92.69 138.03,92.67 137.99,92.63 137.89,92.73 137.89,93.65 137.54,94 137.52,94 137.05,94.47 137.05,94.75 136.53,95.26 136.51,95.37 136.6,95.43 136.8,95.43
GND on IN1 (solid shape): 167.69,28.62 167.78,28.56 167.76,28.45 167.69,28.34 167.67,28.21 167.68,28.12 167.71,28.03 167.71,27.93 167.62,27.88 165.62,27.88 164.73,26.99 159.16,26.99 158.36,27.79 156.71,27.79 156.56,27.95 154.19,27.95 153.86,27.62 148.79,27.62 147.63,26.45 145.7,26.45 144.37,25.12 130.85,25.12 130.08,24.34 129.77,24.34 129.68,24.39 129.67,24.48 129.69,24.54 129.69,24.6 129.62,24.81 129.43,24.94 129.39,24.95 129.39,25.71 128.94,26.15 120.69,26.15 120.04,25.51 119.94,25.51 119.94,25.59 119.97,25.6 120.1,25.73 120.15,25.91 120.1,26.1 119.95,26.23 119.95,26.23 119.91,26.28 119.96,26.33 130.46,26.33 131.1,25.7 144.58,25.7 145.52,26.64 147.51,26.64 148.71,27.83 153.66,27.83 153.99,28.16 156.74,28.16 156.92,27.98 158.48,27.98 159.29,27.17 164.64,27.17 165.63,28.16 167,28.16 167.46,28.62
GND on IN1 (solid shape): 62.59,106.29 64.94,106.29 64.96,106.26 64.98,106.21 64.93,106.18 62.48,106.18 61.62,107.04 60.22,107.04 59.93,106.75 59.93,106.07 59.93,106.06 59.63,106.06 59.62,106.07 59.62,106.75 59.33,107.04 55.73,107.04 55.28,106.6 54.6,106.6 54.15,107.04 53.41,107.04 53.18,106.81 52.63,106.81 52.4,107.04 51.48,107.04 51.15,106.71 51.15,106.01 51.73,105.43 51.73,105.08 51.66,105 51.18,105 51.14,105.04 51.14,105.54 50.8,105.87 50.21,105.87 49.6,105.26 49.6,104.43 49.55,104.42 49.33,104.31 49.24,104.07 49.34,103.82 49.6,103.71 49.73,103.74 49.84,103.81 49.91,103.84 49.98,103.81 50.02,103.78 50.04,103.74 50.02,103.7 49.91,103.58 49.87,103.41 49.88,103.33 49.91,103.25 49.91,103.15 49.82,103.1 49.48,103.1 48.73,103.85 48.73,104.58 51.3,107.15 61.72,107.15
GND on IN1 (solid shape): 141.68,83.63 142.04,83.63 142.17,83.49 142.36,83.44 142.57,83.51 142.7,83.7 142.7,83.71 142.75,83.76 142.84,83.67 142.84,83.66 142.94,83.5 143.11,83.42 143.18,83.35 143.16,83.25 142.84,82.93 142.75,82.91 142.68,82.96 142.55,83.11 142.36,83.16 142.1,83.06 142,82.81 142,82.8 141.94,82.71 141.83,82.73 141.2,83.36 138.7,83.36 138.6,83.42 138.63,83.53 138.71,83.65 138.74,83.79 138.73,83.86 138.71,83.92 138.72,84.02 138.81,84.06 141.25,84.06
GND on IN1 (solid shape): 210.76,21.93 210.76,21.55 210.72,21.55 210.58,21.5 210.47,21.4 210.38,21.36 210.3,21.41 210.17,21.53 209.99,21.58 209.86,21.55 209.75,21.48 209.68,21.45 209.61,21.48 209.49,21.55 209.36,21.58 209.11,21.47 209,21.22 209.01,21.17 209.02,21.12 209.02,21.09 208.91,20.98 208.91,20.73 209.08,20.57 209.42,20.57 209.47,20.52 209.47,20.13 209.42,20.04 209.32,20.04 209.24,20.07 209.15,20.08 209.01,20.05 208.9,19.97 208.83,19.94 208.76,19.96 208.65,20.03 208.52,20.05 208.44,20.04 208.36,20.01 208.26,20.02 208.21,20.1 208.21,20.79 209.51,22.08 210.61,22.08
GND on IN1 (solid shape): 53.45,85.32 53.55,85.26 53.52,85.15 53.39,85.02 53.39,84.91 53.24,84.77 53.18,84.58 53.19,84.52 53.21,84.45 53.19,84.36 53.11,84.31 52.92,84.31 52.75,84.14 52.75,83.36 52.95,83.17 52.97,83.06 52.87,82.99 52.54,82.99 52.43,82.99 52.38,83.08 52.38,84.24 52.53,84.37 52.59,84.57 52.23,84.92 51.88,84.57 51.93,84.37 52.09,84.24 52.09,83.07 52.08,83.06 51.98,83.06 51.97,83.07 51.97,84.04 51.76,84.26 51.42,84.26 51.25,84.08 51.25,83.09 51.22,83.06 51.14,83.06 51.14,83.07 51.14,85.05 51.14,85.06 53.08,85.06 53.35,85.32
GND on IN1 (solid shape): 100.37,53.65 100.37,51.42 100.21,51.27 99.88,51.27 99.8,51.31 99.78,51.41 99.8,51.47 99.81,51.53 99.48,51.86 99.15,51.53 99.24,51.3 99.47,51.2 99.56,51.13 99.53,51.02 99.26,50.75 99.26,49.84 99.2,49.75 99.09,49.76 98.98,49.83 98.87,49.85 98.82,49.84 98.77,49.83 98.68,49.85 98.64,49.93 98.64,50.73 98.98,51.07 98.98,52.31 99.52,52.85 99.52,53.17 99.56,53.18 99.76,53.29 99.83,53.5 99.83,53.56 99.81,53.62 99.82,53.71 99.91,53.75 100.27,53.75
GND on IN1 (solid shape): 118.42,121.73 118.45,121.78 118.5,121.78 118.53,121.76 118.53,119.3 113.19,113.96 111.41,113.96 110.66,113.2 110.66,110.16 109.9,109.39 109.9,109.24 109.82,109.24 109.8,109.27 109.71,109.38 109.57,109.45 109.5,109.52 109.52,109.62 110.06,110.16 110.06,113.97 110.57,114.48 110.57,116.99 109.62,117.94 109.62,117.97 109.63,118.02 109.64,118.07 109.63,118.13 109.62,118.19 109.63,118.29 109.71,118.33 111.13,118.33 111.63,117.82 111.83,117.82 111.92,117.77 111.91,117.66 111.86,117.57 111.85,117.46 112.2,117.1 112.56,117.46 112.54,117.57 112.5,117.66 112.49,117.77 112.58,117.82 115.82,117.82 116.71,118.71 117.72,118.71 118.42,119.41
GND on IN1 (solid shape): 92.27,75.72 92.33,75.82 92.44,75.79 94.53,73.7 94.53,73.42 95.93,72.03 98.72,72.03 99,71.75 100.22,71.75 100.41,71.56 100.93,71.56 100.97,71.52 100.95,71.45 100.95,71.41 101.28,71.08 101.61,71.41 101.59,71.53 101.52,71.63 101.5,71.7 101.52,71.77 101.56,71.82 101.59,71.88 101.66,71.94 101.76,71.91 101.79,71.88 102.12,71.88 102.2,71.85 102.22,71.77 102.22,71.74 102.27,71.57 102.39,71.45 102.45,71.36 102.39,71.27 102.28,71.16 102.23,71.01 102.19,70.94 102.12,70.92 100.79,70.92 100.45,71.25 97.06,71.25 96.55,71.76 95.79,71.76 92.27,75.28
GND on IN1 (solid shape): outline of 110 points within 94.77,83.05 103.15,107.93
GND on IN1 (solid shape): 109.84,115.7 109.9,115.6 109.9,114.76 108.63,113.49 108.63,111.55 107.36,110.28 107.36,110.23 107.27,110.23 107.26,110.26 107.14,110.41 106.97,110.48 106.93,110.49 106.92,110.53 106.89,110.63 106.71,110.8 106.68,110.93 106.75,111.11 106.93,111.18 107.09,111.13 107.18,110.98 107.32,110.83 107.52,110.88 108.01,111.37 108.01,112.4 107.98,112.47 107.96,112.49 107.89,112.67 107.96,112.84 107.98,112.86 108.01,112.94 108.01,113.05 107.95,113.1 107.88,113.19 107.86,113.3 107.93,113.48 108.11,113.55 108.19,113.55 109.43,114.79 109.43,115.53 109.45,115.57 109.62,115.61 109.73,115.68
GND on IN1 (solid shape): 111.13,57.8 111.22,57.78 112.72,56.28 112.72,55.55 116.01,52.26 116.01,50.84 115.97,50.75 115.88,50.74 115.82,50.76 115.76,50.76 115.7,50.76 115.64,50.74 115.55,50.75 115.51,50.84 115.51,51.58 114.53,52.56 114.5,52.66 114.58,52.73 114.77,52.85 114.85,53.07 114.74,53.32 114.49,53.43 114.27,53.35 114.14,53.16 114.07,53.09 113.97,53.11 110.41,56.67 110.41,56.85 110.46,56.93 110.56,56.94 110.64,56.9 110.73,56.89 110.98,57 111.09,57.25 111.06,57.38 110.99,57.5 110.96,57.57 110.99,57.64 111.03,57.69 111.06,57.74
GND on IN1 (solid shape): 100.53,30.4 100.59,30.49 100.7,30.47 101.63,29.54 101.66,29.45 101.59,29.38 101.44,29.26 101.38,29.07 101.4,28.97 101.44,28.88 101.46,28.85 100.7,28.09 100.7,21.21 100.64,21.12 100.53,21.14 99.56,22.1 99.25,22.1 99.16,22.16 99.16,22.26 99.21,22.36 99.23,22.47 98.87,22.82 98.51,22.47 98.52,22.43 98.53,22.36 98.47,22.31 98.44,22.34 94.56,22.34 94.48,22.38 94.47,22.48 94.49,22.54 95.86,22.54 96.42,23.1 96.44,23.1 96.99,22.55 97.26,22.55 97.64,22.92 97.64,23.19 97.08,23.75 97.08,23.77 97.28,23.96 97.3,23.96 98.11,23.16 98.38,23.16 98.75,23.53 98.75,23.8 97.95,24.61 97.95,24.63 98.14,24.83 98.16,24.83 99.03,23.95 99.3,23.95 99.66,24.31 99.66,24.62 98.83,25.46 98.83,25.51 100.53,27.21
GND on IN1 (solid shape): 39.7,69.31 39.77,69.22 39.77,67.93 40.45,67.25 41.96,67.25 41.98,67.23 41.98,66.93 41.96,66.91 40.7,66.91 40.61,66.81 40.5,66.79 40.43,66.86 40.31,67.07 40.09,67.14 40.03,67.14 39.97,67.12 39.88,67.14 39.83,67.22 39.83,67.23 39.62,67.44 38.92,67.44 38.87,67.47 38.88,67.53 38.94,67.59 38.99,67.68 39.09,67.68 39.18,67.64 39.26,67.63 39.62,67.99 39.26,68.35 39.18,68.33 39.09,68.3 38.99,68.3 38.94,68.39 38.94,69.17 39,69.26 39.11,69.25 39.21,69.19 39.33,69.17 39.47,69.2 39.59,69.29
GND on IN1 (solid shape): 47.35,95.4 47.44,95.34 47.42,95.23 47.2,95.01 45.37,95.01 41.1,90.74 31.19,90.74 29.38,88.92 28.21,88.92 26.67,87.38 25.79,87.38 25.75,87.45 25.7,87.5 25.67,87.59 25.73,87.67 25.89,87.8 25.95,88 25.59,88.35 25.23,88 25.26,87.85 25.35,87.73 25.38,87.64 25.32,87.56 25.27,87.54 25.17,87.54 25.12,87.62 25.12,88.29 24.47,88.95 24.47,89.06 24.54,89.06 24.56,89.04 24.69,88.92 24.86,88.88 25.11,88.98 25.21,89.23 25.21,89.28 25.2,89.33 25.19,89.36 25.25,89.42 25.7,89.42 26.24,89.97 26.24,90.73 26.54,91.03 27.69,91.03 28.32,90.39 30.51,90.39 31.07,90.95 41.07,90.95 45.52,95.4
GND on IN1 (solid shape): 26.41,31.48 26.48,31.38 26.48,26.32 27.39,25.41 38.26,25.41 39.37,24.29 41.31,24.29 42.05,25.04 42.82,25.04 42.91,24.99 42.92,24.89 42.89,24.82 42.89,24.75 43.24,24.39 43.6,24.75 43.59,24.82 43.57,24.89 43.58,24.99 43.66,25.04 49.07,25.04 49.73,24.37 50.81,24.37 50.89,24.33 50.91,24.24 50.89,24.17 50.82,24.09 50.72,24.12 39.3,24.12 38.18,25.23 27.13,25.23 25.94,26.42 25.94,30.09 25.58,30.45 25.56,30.55 25.63,30.62 25.88,30.76 25.97,31.02 25.97,31.09 25.95,31.15 25.96,31.24 26.03,31.28 26.18,31.34 26.29,31.44
GND on IN1 (solid shape): 66.77,91.09 66.88,91.07 68.71,89.23 68.74,89.14 68.68,89.07 68.52,88.95 68.46,88.76 68.56,88.53 68.79,88.43 68.98,88.49 69.1,88.64 69.18,88.7 69.27,88.68 72,85.95 79.76,85.95 81.63,84.08 81.63,81.75 82.49,80.89 82.51,80.8 82.46,80.72 82.31,80.59 82.26,80.4 82.27,80.32 82.3,80.23 82.29,80.13 82.21,80.09 76.56,80.09 66.77,89.88 66.74,89.98 66.81,90.05 67,90.2 67.08,90.44 66.99,90.69 66.76,90.83 66.7,90.88 66.69,90.96 66.7,91.02
GND on IN1 (solid shape): 56.16,104.34 58.73,104.34 59.14,103.92 59.17,103.84 59.12,103.76 59.07,103.73 59.02,103.7 58.95,103.67 58.88,103.7 58.77,103.77 58.63,103.8 58.38,103.69 58.28,103.44 58.28,103.38 58.3,103.32 58.29,103.22 58.2,103.18 57.13,103.18 57.03,103.28 54.58,103.28 54.19,102.9 54.16,102.84 54.1,102.82 53.96,102.78 53.85,102.69 53.77,102.65 53.69,102.69 53.57,102.78 53.42,102.82 53.39,102.82 53.31,102.84 53.28,102.92 53.28,103.29 53.17,103.4 53.17,104.01 53.55,104.39 53.64,104.42 53.71,104.36 53.84,104.21 54.04,104.15 54.29,104.26 54.39,104.51 54.38,104.59 54.35,104.67 54.36,104.77 54.44,104.82 55.68,104.82
GND on IN1 (solid shape): 106.52,109.88 106.6,109.91 106.67,109.88 106.79,109.79 106.93,109.76 106.97,109.77 107.07,109.71 107.05,109.59 106.85,109.39 106.85,107.72 106.11,106.98 106.11,106.79 105.96,106.66 105.9,106.46 105.91,106.39 105.93,106.32 105.92,106.23 105.84,106.18 105.02,106.18 104.89,106.05 104.64,106.05 104.36,106.34 104.37,106.36 104.38,106.41 104.38,106.46 104.28,106.71 104.02,106.82 103.88,106.79 103.77,106.71 103.66,106.69 103.59,106.78 103.59,106.87 105.12,108.4 105.19,108.43 105.27,108.4 105.38,108.32 105.52,108.29 105.77,108.4 105.88,108.65 105.8,108.87 105.6,109 105.53,109.07 105.55,109.17 105.72,109.34 105.97,109.34
GND on IN1 (solid shape): 168.83,22.1 168.79,22.05 168.77,22.05 168.58,21.92 168.51,21.7 168.61,21.45 168.86,21.35 169.05,21.4 169.19,21.55 169.26,21.61 169.35,21.58 170.35,20.57 172.66,20.57 172.74,20.53 172.75,20.43 172.74,20.37 172.73,20.31 172.74,20.25 172.75,20.19 172.74,20.1 172.65,20.05 172.48,20.05 172.29,20.25 171.12,20.25 170.94,20.07 169.28,20.07 169.15,20.2 169.13,20.2 168.98,20.36 168.98,20.39 168.99,20.43 169,20.48 168.89,20.74 168.64,20.84 168.49,20.81 168.37,20.72 168.3,20.68 168.23,20.71 168.11,20.78 167.98,20.8 167.89,20.79 167.8,20.76 167.75,20.76 167.73,20.8 167.73,20.9 168.19,21.35 168.19,21.88 168.18,21.95 168.15,22.02 168.16,22.12 168.25,22.17 168.76,22.17
GND on IN1 (solid shape): 98.51,53.75 98.6,53.71 98.61,53.62 98.59,53.56 98.59,53.5 98.68,53.27 98.92,53.17 99.03,53.17 99.03,53.06 98.49,52.52 98.49,51.94 98.45,51.85 98.36,51.84 98.31,51.85 98.26,51.85 98.21,51.85 98.16,51.84 98.07,51.85 98.02,51.93 98.02,52.18 98.06,52.19 98.24,52.31 98.31,52.51 98.22,52.74 97.98,52.84 97.86,52.82 97.76,52.75 97.69,52.73 97.62,52.75 97.52,52.82 97.4,52.84 97.25,52.8 97.13,52.71 97.05,52.67 96.97,52.71 96.93,52.76 97.23,53.07 97.23,53.19 97.28,53.2 97.49,53.31 97.57,53.53 97.57,53.57 97.56,53.62 97.57,53.71 97.65,53.75
GND on IN1 (solid shape): 56.81,34.55 56.81,34.28 56.76,34.19 56.65,34.2 56.55,34.25 56.44,34.27 56.08,33.91 56.44,33.56 56.49,33.56 56.53,33.57 56.56,33.58 56.59,33.55 56.61,33.44 56.52,33.38 53.53,33.38 53.4,33.51 53.46,33.57 53.5,33.55 53.56,33.53 53.63,33.53 53.88,33.63 53.99,33.88 53.98,33.96 53.95,34.03 53.96,34.13 54.05,34.17 54.68,34.17 54.81,34.04 54.8,34.01 54.79,33.97 54.78,33.92 55.39,33.66 55.14,34.27 55.09,34.27 55.04,34.26 55.01,34.25 54.89,34.38 54.87,34.49 54.96,34.55 56.81,34.55
GND on IN1 (solid shape): 134.11,88.09 134.91,88.09 135.3,87.71 135.33,87.62 135.27,87.54 135.12,87.41 135.07,87.22 135.17,86.97 135.42,86.86 135.58,86.9 135.7,87 135.72,87.02 135.79,87.02 135.79,86.91 136.61,86.1 137.5,86.1 137.65,85.95 137.67,85.83 137.58,85.77 137.56,85.77 137.39,85.73 137.26,85.61 137.17,85.56 137.09,85.61 136.96,85.74 136.78,85.79 136.72,85.79 136.66,85.77 136.57,85.78 136.53,85.87 136.53,86 135.89,86.63 134.48,86.63 134.38,86.73 134.43,86.77 134.44,86.78 134.63,86.91 134.7,87.12 134.6,87.37 134.35,87.48 134.29,87.47 134.23,87.46 134.14,87.47 134.1,87.55 134.1,87.56 133.14,88.52 133.12,88.63 133.21,88.69 133.51,88.69
GND on IN1 (solid shape): 71.31,119.35 71.37,119.45 71.48,119.43 72.53,118.38 72.53,117.75 72.13,117.35 71.71,117.35 71.01,116.65 70.91,116.62 70.84,116.69 70.72,116.87 70.53,116.95 70.46,116.98 70.43,117.06 70.43,117.09 70.33,117.34 70.08,117.45 69.92,117.41 69.8,117.31 69.73,117.27 69.66,117.29 69.56,117.34 69.45,117.36 69.09,117 69.45,116.65 69.61,116.68 69.73,116.78 69.8,116.82 69.87,116.8 69.96,116.76 70.05,116.74 70.12,116.7 70.14,116.63 70.14,116.59 70.15,116.53 70.16,116.48 70.15,116.38 70.07,116.34 69.2,116.34 68.28,115.42 68.17,115.4 68.1,115.49 68.1,116.9 69.3,118.1 70.7,118.1 71.31,118.71
GND on IN1 (solid shape): 82.34,84.25 82.34,83.11 83.98,81.46 84.01,81.37 83.95,81.3 83.79,81.18 83.73,80.99 83.83,80.75 84.06,80.66 84.08,80.66 84.16,80.63 84.19,80.55 84.19,80.53 84.28,80.3 84.52,80.2 84.71,80.26 84.83,80.42 84.9,80.48 85,80.45 85.3,80.14 85.33,80.05 85.27,79.98 85.11,79.86 85.05,79.67 85.15,79.43 85.38,79.34 85.49,79.35 85.59,79.41 85.63,79.42 85.66,79.41 88.47,76.6 88.5,76.51 88.44,76.44 88.28,76.3 88.22,76.11 88.23,76.1 88.16,76 88.05,76.02 82.12,81.95 82.12,84.28 79.95,86.46 79.94,86.51 79.98,86.54 80.05,86.54
GND on IN1 (solid shape): 102.53,45.08 102.58,44.99 102.58,44.67 103.07,44.19 103.07,41.14 101.01,39.08 99.49,39.08 98.33,37.92 98.24,37.9 98.17,37.96 98.04,38.13 97.85,38.19 97.62,38.09 97.52,37.86 97.58,37.66 97.75,37.54 97.81,37.47 97.79,37.38 96.87,36.46 96.82,36.37 96.72,36.37 96.64,36.4 96.56,36.41 96.33,36.31 96.23,36.08 96.3,35.87 96.49,35.76 96.57,35.69 96.54,35.59 96.18,35.23 96.18,34.69 96.14,34.61 96.05,34.59 96,34.6 95.95,34.61 95.88,34.6 95.81,34.58 95.71,34.58 95.66,34.67 95.66,34.8 95.89,35.03 95.89,36.55 97.85,38.52 98.62,38.52 102.02,41.92 102.02,44.94 102.06,45.02 102.15,45.03 102.2,45.02 102.24,45.02 102.34,45.03 102.43,45.07
GND on IN1 (solid shape): outline of 139 points within 91.98,78.02 103.7,98.58
GND on IN1 (solid shape): 95.74,37.92 95.83,37.95 95.9,37.9 95.99,37.78 96.13,37.71 96.2,37.64 96.18,37.54 95.39,36.76 95.39,35.23 95.17,35.01 95.17,34.47 94.95,34.25 94.8,34.25 93.3,32.75 93.23,32.72 93.16,32.75 93.06,32.8 92.95,32.83 92.72,32.73 92.62,32.49 92.69,32.29 92.88,32.17 92.95,32.1 92.92,32 91.28,30.36 91.28,29.47 90.71,28.9 90.61,28.88 90.54,28.94 90.39,29.14 90.16,29.22 90.02,29.2 89.91,29.14 89.8,29.13 89.74,29.22 89.74,29.64 91.9,31.8 91.9,32.01 91.94,32.09 92.04,32.11 92.09,32.1 92.14,32.09 92.37,32.19 92.47,32.42 92.42,32.6 92.28,32.72 92.23,32.79 92.25,32.88 93.68,34.31 93.81,34.31 95.2,35.71 95.2,37.39
GND on IN1 (solid shape): 108.67,63.23 108.76,63.17 108.75,63.07 108.69,62.98 108.67,62.88 108.64,62.81 108.57,62.78 108.54,62.78 108.25,62.49 108.25,61.74 113.45,56.53 113.45,55.81 116.71,52.55 116.71,45.87 117.3,45.28 117.3,39.89 117.25,39.8 117.15,39.79 117.09,39.82 117.02,39.82 116.69,39.49 117.02,39.16 117.09,39.17 117.15,39.19 117.25,39.18 117.3,39.1 117.3,37.04 116.25,36 116.16,35.97 116.09,36.03 115.97,36.19 115.78,36.26 115.69,36.32 115.71,36.43 116.46,37.18 116.46,39.65 116.79,39.99 116.79,45.2 116.53,45.46 116.53,52.47 113.24,55.77 113.24,56.5 108.19,61.55 106.29,61.55 106.09,61.74 106.07,61.84 106.13,61.91 106.28,62.03 106.34,62.22 106.31,62.34 106.24,62.45 106.22,62.56 106.32,62.62 106.66,62.62 107.38,62.62 107.99,63.23
GND on IN1 (solid shape): 210.37,21.06 210.45,21.01 210.58,20.88 210.76,20.84 210.89,20.86 211,20.94 211.07,20.97 211.14,20.94 211.26,20.86 211.39,20.84 211.55,20.88 211.68,20.98 211.74,21.02 211.82,21.01 211.85,20.99 211.88,20.97 211.93,20.9 211.91,20.81 207.5,16.4 207.5,15.86 206.25,14.61 199.86,14.61 199.59,14.35 198.17,14.35 198.08,14.41 198.09,14.51 198.14,14.61 198.16,14.72 198.13,14.86 198.04,14.98 198.02,15.09 198.11,15.16 198.86,15.16 199.23,14.79 204.5,14.79 204.91,15.21 205.01,15.23 205.08,15.17 205.21,14.99 205.42,14.92 205.67,15.03 205.78,15.28 205.71,15.49 205.53,15.62 205.47,15.69 205.49,15.78 207.99,18.28 209.13,18.28 209.99,19.14 209.99,20.86 210.03,20.87 210.17,20.91 210.28,21.01
GND on IN1 (solid shape): 89.6,28.74 89.69,28.76 89.77,28.69 89.91,28.49 90.16,28.41 90.26,28.42 90.36,28.47 90.47,28.47 90.52,28.38 90.52,27.56 88.16,25.21 88.06,25.19 87.99,25.27 87.88,25.5 87.64,25.59 87.5,25.56 87.39,25.49 87.32,25.46 87.25,25.49 87.14,25.56 87,25.59 86.65,25.23 87,24.88 87.14,24.9 87.25,24.98 87.32,25.01 87.39,24.98 87.49,24.91 87.6,24.88 87.69,24.81 87.66,24.71 87.36,24.41 77.46,24.41 76.78,23.73 67.19,23.73 67.09,23.79 67.12,23.9 67.19,24.02 67.22,24.15 67.2,24.27 67.14,24.38 67.12,24.49 67.22,24.55 77.06,24.55 77.1,24.59 85.45,24.59
GND on IN1 (solid shape): 57.65,79.59 57.7,79.6 57.73,79.55 57.73,79.45 57.41,79.14 57.41,79.1 57.36,79.01 57.26,79.01 57.18,79.05 57.08,79.06 56.83,78.96 56.73,78.71 56.74,78.63 56.76,78.56 56.75,78.46 56.67,78.42 55.3,78.42 54.91,78.02 54.91,75.62 55.04,75.48 55.07,75.4 55.02,75.32 54.88,75.19 54.83,75.01 55.25,74.66 55.51,75.14 55.52,75.23 55.61,75.28 56.08,75.28 56.17,75.23 56.17,75.13 56.14,75.05 56.13,74.97 56.16,74.84 56.23,74.73 56.25,74.62 56.16,74.55 55.76,74.55 55.29,74.09 55.29,73.27 55.69,72.86 57.96,72.86 58.26,72.57 58.28,72.46 58.19,72.4 58.13,72.4 57.83,72.69 56.24,72.69 55.82,72.27 53.5,72.27 53.25,72.53 53.25,74.07 53.25,74.07 53.6,74.07 53.64,74.03 53.64,72.79 53.81,72.61 54.99,72.61 55.18,72.8 55.18,73.43 54.65,73.96 54.65,79.04 54.82,79.21 57.27,79.21
GND on IN1 (solid shape): 10.53,114.2 10.61,114.18 14.76,114.18 25.29,114.18 25.39,114.12 25.36,114.01 23.07,111.72 20.99,111.72 20.46,112.25 19.39,112.25 17.84,110.7 17.84,108.29 16.72,107.17 13.19,103.64 11.74,103.64 11.5,103.83 11.2,103.9 7.3,103.9 7.3,104.4 7.1,104.9 6.6,105.1 5.2,105.1 4.99,105.07 4.8,104.97 4.58,104.72 4.5,104.4 4.5,103.9 0.71,103.9 0.5,104.11 0.5,105.19 0.51,105.2 2.1,105.2 2.1,111.2 0.51,111.2 0.5,111.21 0.5,112.59 0.71,112.8 3.3,112.8 3.6,112.58 3.97,112.5 5.93,112.5 6.3,112.58 6.6,112.8 6.62,112.82 7.29,112.83 7.35,112.75 8.58,112.58 8.8,113.8 8.84,113.8 9.86,113.8 10.23,113.92 10.47,114.24
GND on IN1 (solid shape): 89.23,42.74 89.28,42.65 89.24,41.68 89.15,39.52 88.86,37.99 88.61,36.71 88.55,36.64 88.46,36.64 88.37,36.68 88.28,36.69 88.13,36.66 88.01,36.57 87.9,36.55 87.84,36.64 87.84,37.29 87.9,37.39 88.01,37.36 88.13,37.28 88.28,37.25 88.63,37.6 88.28,37.96 88.13,37.93 88.01,37.84 87.9,37.82 87.84,37.91 87.84,38.58 87.9,38.68 88.01,38.65 88.13,38.57 88.28,38.54 88.53,38.64 88.63,38.89 88.57,39.09 88.42,39.22 88.36,39.29 88.39,39.39 88.99,39.99 88.99,40.55 88.78,40.76 88.78,42.65 88.82,42.73 88.91,42.74 88.96,42.73 89.02,42.73 89.08,42.73 89.14,42.75
GND on IN1 (solid shape): 60.48,24.55 60.57,24.5 60.58,24.4 60.55,24.32 60.54,24.24 60.89,23.89 61.25,24.24 61.24,24.32 61.21,24.4 61.22,24.5 61.31,24.55 63.34,24.55 63.43,24.49 63.41,24.38 63.35,24.27 63.33,24.15 63.36,24.02 63.44,23.9 63.46,23.79 63.37,23.73 62.4,23.73 61.64,22.97 51.89,22.97 51.25,22.33 48.79,22.33 48.42,22.7 48.4,22.81 48.48,22.87 48.6,22.9 48.7,22.97 48.77,23 48.84,22.97 48.95,22.9 49.08,22.87 49.22,22.9 49.33,22.97 49.4,23 49.47,22.97 49.59,22.9 49.72,22.87 49.85,22.9 49.97,22.97 50.04,23 50.11,22.97 50.22,22.9 50.35,22.87 50.61,22.98 50.71,23.23 50.71,23.26 50.7,23.33 50.75,23.38 50.86,23.28 55.92,23.28 56.73,24.09 59.83,24.09 60.29,24.55
GND on IN1 (solid shape): outline of 160 points within 144.14,18 150.32,19.55
GND on IN1 (solid shape): 180.2,14.08 180.3,14.02 180.27,13.91 178.94,12.58 177.34,12.58 177.25,12.63 177.26,12.74 177.31,12.84 177.33,12.95 177.22,13.21 176.97,13.31 176.8,13.27 176.68,13.15 176.59,13.11 176.51,13.15 176.38,13.27 176.21,13.31 175.96,13.21 175.85,12.95 175.87,12.84 175.93,12.74 175.94,12.63 175.84,12.58 175.69,12.58 175.6,12.63 175.61,12.74 175.66,12.84 175.68,12.95 175.32,13.31 174.97,12.95 174.98,12.84 175.04,12.74 175.05,12.63 174.96,12.58 174.57,12.58 174.48,12.63 174.49,12.74 174.54,12.84 174.56,12.95 174.56,13.32 174.03,13.84 174.01,13.95 174.1,14.02 175.4,14.02 175.79,13.63 179.55,13.63 180.01,14.08
GND on IN1 (solid shape): outline of 163 points within 87.77,76.34 92.37,80.74
GND on IN1 (solid shape): 105.47,25.5 105.54,25.59 105.65,25.57 110.05,21.17 110.07,21.08 110.02,21.01 109.87,20.88 109.81,20.69 109.92,20.44 110.17,20.33 110.36,20.39 110.49,20.53 110.57,20.59 110.66,20.56 112.3,18.91 113.22,18.91 113.25,18.86 113.26,18.81 113.21,18.78 109.97,18.78 109.88,18.84 109.9,18.96 110.43,19.49 110.51,19.47 110.55,19.47 110.8,20.08 110.2,19.82 110.2,19.78 110.22,19.7 109.65,19.14 106.17,19.14 105.88,19.43 105.88,22.04 105.93,22.13 106.03,22.13 106.1,22.11 106.18,22.1 106.54,22.45 106.18,22.81 106.1,22.8 106.03,22.77 105.93,22.78 105.88,22.86 105.88,24.53 105.47,24.94
GND on IN1 (solid shape): 69.51,20.48 69.6,20.42 69.6,20.32 69.56,20.23 69.54,20.13 69.9,19.78 70.26,20.13 70.24,20.23 70.2,20.32 70.2,20.43 70.29,20.48 70.89,20.48 70.98,20.42 70.98,20.32 70.94,20.23 70.92,20.13 71.03,19.88 71.28,19.78 71.41,19.8 71.53,19.88 71.6,19.91 71.67,19.88 71.78,19.8 71.92,19.78 72.05,19.8 72.17,19.88 72.24,19.91 72.31,19.88 72.42,19.8 72.56,19.78 72.81,19.88 72.91,20.13 72.9,20.23 72.86,20.32 72.86,20.43 72.95,20.48 75.97,20.48 76.06,20.41 76.04,20.3 74.9,19.16 69.81,19.16 68.96,20.01 68.97,20.04 68.98,20.08 68.99,20.13 68.97,20.23 68.93,20.32 68.93,20.43 69.02,20.48
GND on IN1 (solid shape): 57.39,61.16 64.51,61.16 67.3,58.36 72.28,58.36 72.36,58.32 72.37,58.23 72.36,58.17 72.35,58.1 72.37,57.98 72.44,57.87 72.45,57.76 72.36,57.7 64.49,57.7 64.39,57.76 64.41,57.87 64.46,57.97 64.48,58.09 64.38,58.34 64.13,58.44 64.06,58.44 64,58.42 63.9,58.43 63.86,58.51 63.86,58.69 63.9,58.73 64.35,58.73 64.75,59.13 64.75,60.05 64.35,60.44 57.29,60.44 57.2,60.5 57.21,60.61 57.27,60.71 57.29,60.82 57.19,61.05 56.96,61.15 56.8,61.11 56.68,61 56.59,60.95 56.51,61 56.39,61.12 56.23,61.16 56.05,61.11 55.93,60.98 55.86,60.92 55.77,60.95 55.72,61 55.62,61 55.5,61.12 55.34,61.16 55.22,61.13 55.11,61.06 55.04,61.04 54.97,61.06 54.93,61.1 54.88,61.12 54.82,61.2 54.85,61.29 54.98,61.42 57.13,61.42
GND on IN1 (solid shape): 10.58,16.69 10.58,14.53 10.84,14.28 10.84,14.21 10.78,14.12 10.68,14.12 10.58,14.17 10.48,14.19 10.12,13.83 10.48,13.47 10.58,13.49 10.68,13.54 10.78,13.54 10.84,13.45 10.84,13.19 10.78,13.1 10.68,13.11 10.58,13.15 10.48,13.17 10.12,12.81 10.48,12.46 10.58,12.47 10.68,12.52 10.78,12.53 10.84,12.44 10.84,11.68 10.79,11.59 10.68,11.59 10.6,11.63 10.46,11.66 10.44,11.7 10.44,11.98 9.52,12.91 9.52,15.93 9.54,15.97 9.58,15.98 9.83,16.09 9.94,16.34 9.85,16.58 9.63,16.69 9.58,16.7 9.58,16.87 9.21,17.24 9.12,17.24 9.04,17.28 9.03,17.38 9.05,17.44 9.05,17.51 9.05,17.56 9.04,17.61 9.03,17.64 9.14,17.75 9.53,17.75
GND on IN1 (solid shape): 114.19,33.44 114.32,33.33 114.48,33.29 114.56,33.3 114.61,33.24 114.52,33.15 114.52,28.48 116.13,26.87 119.48,26.87 119.64,27.03 131.4,27.03 132,26.43 144.33,26.43 145.25,27.35 147.22,27.35 149.05,29.18 158.29,29.18 158.55,28.92 164.6,28.92 164.68,28.87 164.7,28.78 164.68,28.72 164.68,28.66 164.73,28.47 164.88,28.34 164.94,28.27 164.91,28.18 164.42,27.69 162.62,27.69 162.53,27.75 162.53,27.85 162.58,27.95 162.6,28.05 162.24,28.41 161.88,28.05 161.9,27.95 161.95,27.85 161.95,27.75 161.86,27.69 161.59,27.69 161.5,27.75 161.51,27.85 161.56,27.95 161.57,28.05 161.22,28.41 160.86,28.05 160.88,27.95 160.92,27.85 160.93,27.75 160.84,27.69 159.51,27.69 158.7,28.5 157.14,28.5 156.96,28.68 153.77,28.68 153.44,28.35 148.49,28.35 147.3,27.16 145.31,27.16 144.37,26.22 131.31,26.22 130.68,26.85 119.74,26.85 119.59,26.7 116.05,26.7 114.25,28.49 114.25,33.19 114.1,33.35 114.1,33.46 114.18,33.46
GND on IN1 (solid shape): outline of 154 points within 75.22,76.77 95.36,91.13
GND on IN1 (solid shape): 102.78,115.92 102.85,115.89 102.88,115.81 102.89,115.72 102.93,115.63 102.93,115.53 102.84,115.47 101.59,115.47 100.09,113.97 100.09,113.63 98.8,112.34 98.8,100.33 98.9,100.23 98.9,96.73 103.47,92.16 103.47,90.93 104.31,90.1 104.31,87.37 106.74,84.95 106.74,81.12 107.51,80.35 107.53,80.26 107.48,80.19 107.43,80.16 107.38,80.13 107.31,80.1 107.24,80.13 107.13,80.2 107,80.23 106.88,80.2 106.77,80.14 106.66,80.13 106.6,80.22 106.6,80.85 105.95,81.5 105.93,81.61 106.02,81.67 106.26,81.78 106.36,82.03 106.33,82.16 106.26,82.28 106.23,82.35 106.26,82.42 106.33,82.53 106.36,82.66 106,83.02 105.64,82.66 105.67,82.53 105.74,82.42 105.77,82.35 105.74,82.28 105.67,82.17 105.64,82.05 105.58,81.96 105.47,81.98 105.44,82.01 105.44,85.99 104.04,87.39 104.04,90.05 102.7,91.39 102.7,92.66 98.72,96.64 98.72,100.16 98.63,100.26 98.63,112.41 99.92,113.7 99.92,114.68 101.03,115.79 102.14,115.79 102.26,115.92
