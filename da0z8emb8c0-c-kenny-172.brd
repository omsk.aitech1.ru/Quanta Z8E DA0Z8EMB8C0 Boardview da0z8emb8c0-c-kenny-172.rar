# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MINICAR_PME#: length 2.8
  BOTTOM w0.102: Q46.1 181.16,17 181.52,17.36 R833.1 182.05,17.64 182.06,17.63 CN9.55
MVREFDA: length 0.8
  BOTTOM w0.381: v2(118.59,100.94) U2029.K17
MVREFDB: length 0.8
  BOTTOM w0.381: v2(114.84,97.29) 114.42,97.72 U2029.U10
MX0: length 48.9
  TOP w0.102: U13.58 177.22,15.17 175.42,16.97 172.77,16.97 172.65,16.85 171.13,16.85 170.78,16.5 v1(170.32,16.5)
  IN3 w0.089: v2(149.13,23.33) 149.7,23.33 151.28,21.76 154.93,21.76 156.1,22.93 158.02,22.93 158.43,22.52 160.46,22.52 161.66,21.32 162.58,21.32 163.33,20.57 164.78,20.57 165.9,19.44 165.9,17.74 166.19,17.45 169.57,17.45 170.32,16.7 v1(170.32,16.5)
  BOTTOM w0.102: v1(170.32,16.5) 170.32,16.55 170.24,16.62 166.28,16.62 166,16.9 CN10.10 166,18.22 166.05,18.27 C412.1 ; v2(145.22,27.67) 145.07,27.52 CN8.10 145.07,25.72 147.31,23.48 147.79,23.48 148.07,23.76 148.71,23.76 v2(149.13,23.33)
MX1: length 43.5
  TOP w0.102: v2(168.46,18.61) 168.7,18.38 168.7,18.33 169.95,17.08 172.56,17.08 172.67,17.19 175.51,17.19 177.62,15.09 U13.59
  IN3 w0.089: v2(168.46,18.61) 168.46,19.25 167.33,20.38 167.33,20.56 166.97,20.92 166.41,20.92 165.96,21.38 165.96,21.54 164.06,23.43 162.86,23.43 162.36,23.93 159.01,23.93 158.6,24.34 155.52,24.34 154.59,23.41 152.69,23.41 v1(151.74,22.47)
  BOTTOM w0.102: v1(151.74,22.47) 151.56,22.65 150.63,22.65 148.93,24.34 148.93,24.9 148.77,25.07 148.32,25.07 148.09,25.3 147.47,25.3 147.25,25.51 146.2,25.51 146.07,25.64 CN8.9 ; CN10.9 167,17.78 166.91,17.87 166.91,18.66 167.45,19.19 C424.1 168.15,19 168.33,19 168.46,18.87 v2(168.46,18.61)
MX2: length 43.7
  TOP w0.102: U13.60 178.02,15.01 175.61,17.42 172.58,17.42 172.46,17.31 170.34,17.31 169.1,18.54 v2(169.09,18.54)
  IN3 w0.089: v1(152.33,22.47) 153.08,23.22 154.67,23.22 155.6,24.15 158.52,24.15 158.93,23.74 162.28,23.74 162.8,23.23 163.1,23.23 164.17,22.16 164.91,22.16 166.33,20.73 166.89,20.73 167.14,20.48 167.14,20.24 168.01,19.37 168.01,18.41 168.21,18.21 168.76,18.21 v2(169.09,18.54)
  BOTTOM w0.102: CN10.8 168,17.99 168.19,18.18 168.72,18.18 v2(169.09,18.54) 169.09,18.82 C406.1 ; v2(146.87,27.67) 147.07,27.48 CN8.8 147.07,26.08 147.62,25.53 148.19,25.53 148.42,25.3 148.99,25.3 149.16,25.13 149.16,24.43 150.72,22.87 151.92,22.87 v1(152.33,22.47)
MX3: length 42.6
  TOP w0.102: v2(169.73,18.53) 169.73,18.24 170.43,17.54 172.37,17.54 172.48,17.65 175.7,17.65 178.42,14.94 U13.61
  IN3 w0.089: v2(169.73,18.53) 169.22,18.02 168.03,18.02 167.78,18.27 167.78,19.26 167.32,19.72 166.74,19.72 164.49,21.97 164.1,21.97 163.03,23.04 162.72,23.04 162.2,23.55 158.85,23.55 158.45,23.96 155.67,23.96 154.75,23.03 153.48,23.03 v1(152.91,22.47)
  BOTTOM w0.102: v1(152.91,22.47) 152.27,23.1 150.82,23.1 149.39,24.53 149.39,25.28 149.15,25.53 148.51,25.53 148.07,25.97 CN8.7 148.07,27.6 v2(148.14,27.67) ; C404.1 169.48,18.9 169.73,18.66 v2(169.73,18.53) 169.73,18.4 169,17.67 CN10.7
MX4: length 41.6
  TOP w0.102: U13.62 178.82,14.9 175.84,17.88 172.39,17.88 172.27,17.77 171.02,17.77 v2(170.36,18.43)
  IN3 w0.089: v2(170.36,18.43) 169.76,17.83 166.99,17.83 166.52,18.3 166.52,19.67 164.41,21.78 164.02,21.78 162.95,22.85 162.64,22.85 162.12,23.36 158.77,23.36 158.37,23.77 155.75,23.77 154.83,22.84 153.87,22.84 v1(153.5,22.47)
  BOTTOM w0.102: C405.1 170.24,18.54 v2(170.36,18.43) 170,18.07 CN10.6 ; v2(149.41,27.67) 149.07,27.33 CN8.6 149.07,25.98 149.62,25.43 149.62,24.62 150.91,23.33 152.42,23.33 152.57,23.18 152.78,23.18 v1(153.5,22.47)
MX5: length 39.8
  TOP w0.102: v2(171,18.43) 171.43,17.99 172.18,17.99 172.29,18.11 175.93,18.11 179.22,14.83 U13.63
  IN3 w0.089: v1(154.08,22.47) 154.72,22.47 155.83,23.58 158.29,23.58 158.69,23.17 160.73,23.17 161.79,22.1 163.42,22.1 163.94,21.59 164.33,21.59 166.33,19.59 166.33,18.22 166.92,17.64 170.21,17.64 v2(171,18.43)
  BOTTOM w0.102: CN8.5 150.07,25.59 149.85,25.36 149.85,24.72 151.01,23.56 152.51,23.56 152.67,23.4 153.14,23.4 v1(154.08,22.47) ; C401.1 171,18.43 v2(171,18.43) CN10.5
MX6: length 40.8
  TOP w0.102: U13.64 179.62,12.84 179.89,12.56 TP47.1 180.27,14.68 179.73,15.23 179.14,15.23 176.03,18.34 172.09,18.34 v2(172,18.43)
  IN3 w0.089: v2(172,18.43) 172,18.55 169.24,21.3 166.57,21.3 166.34,21.54 166.34,21.69 164.22,23.81 163.02,23.81 162.52,24.31 159.17,24.31 158.76,24.72 154.51,24.72 v2(153.86,24.07)
  BOTTOM w0.102: CN8.4 151.07,25.58 151.4,25.26 152.03,25.26 152.66,24.62 153.3,24.62 v2(153.86,24.07) ; C402.1 172.02,18.45 v2(172,18.43) CN10.4
MX7: length 41.2
  TOP w0.102: U13.65 182.18,15.76 182.31,15.63 182.31,15.23 TP44.1 180.56,14.72 179.82,15.45 179.24,15.45 176.12,18.57 175.23,18.57 174.43,19.37 174,19.37 v2(173.57,18.94)
  IN3 w0.089: v2(154.49,24.07) 154.96,24.53 158.68,24.53 159.09,24.12 162.44,24.12 162.94,23.62 164.14,23.62 166.15,21.61 166.15,21.46 166.49,21.11 169.16,21.11 171.51,18.76 171.51,18.35 171.84,18.02 172.16,18.02 173.08,18.94 v2(173.57,18.94)
  BOTTOM w0.102: CN8.3 152.07,25.55 152.74,24.88 153.68,24.88 v2(154.49,24.07) ; v2(173.57,18.94) 172.91,18.94 C403.1 172.91,18.27 173,18.18 CN10.3
MY0: length 50.6
  TOP w0.102: C407.1 150.3,16.56 v2(150.36,16.5) ; v2(165.16,14.72) 165.54,14.34 v2(165.54,13.45) 166.04,12.95 168.09,12.95 168.42,13.27 U13.36
  BOTTOM w0.102: v2(165.54,13.45) 163.51,11.42 155.44,11.42 v2(150.36,16.5) 150,16.86 CN10.26 150,18.14 149.5,18.64 149.5,18.67 148.53,19.65 143.1,19.65 139.82,22.92 134.51,22.92 132.59,24.84 130.99,24.84 130.3,25.53 129.21,25.53 129.07,25.66 CN8.26
MY1: length 48.3
  TOP w0.102: U13.37 168.82,13.34 168.2,12.72 165.63,12.72 v2(164.91,13.45) ; v2(151,16.5) 151,16.52 151.06,16.59 C408.1
  BOTTOM w0.102: CN8.25 130.07,26.08 131.08,25.07 132.68,25.07 134.6,23.15 139.92,23.15 143.2,19.87 148.62,19.87 149.73,18.77 149.73,18.73 150.28,18.18 150.53,18.18 151,17.7 CN10.25 v2(151,16.5) 155.85,11.64 163.1,11.64 v2(164.91,13.45)
MY2: length 48
  TOP w0.102: U13.38 169.22,13.11 v2(168.85,12.74) 168.6,12.49 165.23,12.49 v2(164.27,13.45) ; v2(152,16.5) 151.95,16.54 C409.1
  BOTTOM w0.102: CN8.24 131.07,25.7 131.47,25.3 132.78,25.3 134.7,23.38 140.01,23.38 143.29,20.1 148.72,20.1 149.96,18.86 149.96,18.82 150.38,18.4 150.62,18.4 150.85,18.18 151.54,18.18 152,17.72 CN10.24 v2(152,16.5) 156.62,11.87 162.7,11.87 v2(164.27,13.45)
MY3: length 47.8
  TOP w0.102: U13.39 169.62,12.89 168.99,12.27 164.82,12.27 v2(163.64,13.45) ; v2(153,16.5) 152.97,16.53 C410.1
  BOTTOM w0.102: CN8.23 132.07,25.65 132.2,25.53 132.87,25.53 134.79,23.61 140.11,23.61 143.39,20.33 148.81,20.33 150.19,18.96 150.19,18.92 150.47,18.63 150.72,18.63 150.95,18.4 151.64,18.4 151.87,18.18 152.48,18.18 153,17.66 CN10.23 v2(153,16.5) 153,15.96 156.86,12.1 162.29,12.1 v2(163.64,13.45)
MY4: length 48.1
  TOP w0.102: U13.40 170.02,12.97 169.08,12.04 164.36,12.04 v2(164.15,12.25) 163,13.4 v2(163,13.45) ; C411.1 153.99,16.51 v2(154,16.5)
  BOTTOM w0.102: v2(163,13.45) 161.89,12.33 158.28,12.33 154.11,16.5 v2(154,16.5) CN10.22 154,17.78 154.43,18.21 154.43,18.64 154.2,18.87 152.88,18.87 152.21,19.55 149.92,19.55 148.91,20.56 143.48,20.56 140.2,23.84 134.89,23.84 133.07,25.65 CN8.22
MY5: length 47
  TOP w0.102: v2(162.37,13.45) 162.37,13.32 163.88,11.81 169.18,11.81 170.42,13.05 U13.41 ; C414.1 155,16.5 v2(155,16.5)
  BOTTOM w0.102: v2(162.37,13.45) 161.48,12.56 158.43,12.56 155,15.99 v2(155,16.5) CN10.21 155,17.86 154.67,18.2 154.67,18.72 154.29,19.1 152.98,19.1 152.31,19.77 150.02,19.77 149,20.79 143.57,20.79 140.3,24.07 135.66,24.07 134.07,25.65 CN8.21
MY6: length 46.8
  TOP w0.102: v2(161.73,13.45) 161.73,13.32 v2(162.88,12.18) 163.47,11.58 169.27,11.58 170.82,13.12 U13.42 ; C415.1 156.02,16.51 v2(156,16.5)
  BOTTOM w0.102: CN8.20 135.07,25.65 136.42,24.29 140.39,24.29 143.67,21.02 149.1,21.02 150.11,20 152.4,20 153.08,19.33 154.39,19.33 154.86,18.86 155.64,18.86 156,18.5 CN10.20 v2(156,16.5) 156,15.37 158.58,12.79 161.07,12.79 v2(161.73,13.45)
MY7: length 45.7
  TOP w0.102: v2(157,16.5) 157.03,16.53 C416.1 ; U13.43 171.22,13.2 169.37,11.35 163.07,11.35 161.1,13.32 v2(161.1,13.45)
  BOTTOM w0.102: CN8.19 136.07,25.65 137.2,24.52 140.49,24.52 143.76,21.25 149.19,21.25 150.21,20.23 152.49,20.23 153.17,19.56 154.48,19.56 154.95,19.09 156.45,19.09 157,18.54 CN10.19 v2(157,16.5) 157,16.15 160.13,13.02 160.67,13.02 v2(161.1,13.45)
MY8: length 44.8
  TOP w0.102: U13.44 171.62,13.25 169.49,11.12 162.66,11.12 v2(161.54,12.24) 160.46,13.32 v2(160.46,13.45) ; C417.1 157.8,16.7 v2(158,16.5)
  BOTTOM w0.102: v2(160.46,13.45) 158,15.91 v2(158,16.5) CN10.18 158,17.98 156.66,19.32 155.05,19.32 154.58,19.78 153.27,19.78 152.59,20.46 150.3,20.46 149.29,21.47 143.86,21.47 140.58,24.75 137.98,24.75 137.07,25.66 CN8.18
MY9: length 43.7
  TOP w0.102: C419.1 158.56,16.57 v2(158.63,16.5) ; v2(171.51,12.43) 171.94,12.86 v2(171.94,12.95) 172.02,13.03 U13.45
  BOTTOM w0.102: v2(171.94,12.95) 166.65,12.95 164.99,14.62 160.51,14.62 v2(158.63,16.5) 159,16.86 CN10.17 159,18.24 157.7,19.54 156.02,19.54 154.73,20.84 151.16,20.84 150.72,21.27 149.92,21.27 149.49,21.7 143.95,21.7 140.68,24.98 138.77,24.98 138.07,25.68 CN8.17
MY10: length 41.8
  TOP w0.102: v2(172.58,12.95) 172.42,13.11 U13.46 ; v2(160,16.5) 159.95,16.54 C418.1
  BOTTOM w0.102: CN8.16 139.07,25.65 139.52,25.21 140.77,25.21 143.34,22.64 145.9,22.64 146.61,21.93 149.58,21.93 150.01,21.5 150.82,21.5 151.25,21.07 154.82,21.07 156.12,19.77 157.79,19.77 160,17.56 CN10.16 v2(160,16.5) 161.65,14.85 165.08,14.85 166.48,13.45 172.08,13.45 v2(172.58,12.95)
MY11: length 45.5
  TOP w0.102: v2(161.1,15.86) 160.72,16.24 v2(160.72,16.5) 161,16.78 C420.1 ; U13.51 174.42,13.35 174.82,12.95 v2(175.32,12.95)
  BOTTOM w0.102: CN8.15 140.07,25.71 140.35,25.44 140.87,25.44 143.44,22.87 146,22.87 146.7,22.16 149.68,22.16 150.11,21.73 150.91,21.73 151.35,21.3 154.92,21.3 156.21,20 157.89,20 159.71,18.18 160.56,18.18 161,17.74 CN10.15 161,16.78 v2(160.72,16.5) 162.14,15.07 165.18,15.07 166.5,13.75 174.52,13.75 v2(175.32,12.95)
MY12: length 44.3
  TOP w0.102: v2(173.54,16) 174.32,15.23 174.56,15.23 174.82,14.97 U13.52 ; v2(162,16.5) 161.75,16.75 C421.1
  BOTTOM w0.102: v2(173.54,16) 172.71,16 170.89,14.18 166.39,14.18 165.27,15.3 163.19,15.3 v2(162,16.5) CN10.14 162,18.01 161.83,18.18 160.88,18.18 160.66,18.4 159.81,18.4 157.98,20.23 156.31,20.23 155.01,21.53 151.44,21.53 151.01,21.96 150.2,21.96 149.77,22.39 146.8,22.39 146.09,23.09 143.53,23.09 141.07,25.56 CN8.14 141.07,26.62 140.65,27.04 v2(140.65,27.67)
MY13: length 43.9
  TOP w0.102: C422.1 162.49,16.75 162.75,16.5 v2(163,16.5) ; v2(174.18,16) 175.22,14.96 U13.53
  BOTTOM w0.102: v2(141.92,27.57) 142.07,27.42 CN8.13 142.07,25.62 144.37,23.32 146.19,23.32 146.89,22.62 149.87,22.62 150.3,22.19 151.1,22.19 151.54,21.75 155.11,21.75 156.4,20.46 158.07,20.46 159.9,18.63 160.75,18.63 160.98,18.41 162.01,18.41 162.22,18.2 162.83,18.2 163,18.02 CN10.13 v2(163,16.5) 163.97,15.53 165.37,15.53 166.46,14.44 170.82,14.44 172.82,16.43 173.75,16.43 v2(174.18,16)
MY14: length 42.9
  TOP w0.102: v2(174.81,16) 175.62,15.2 U13.54 ; v2(163.64,16.5) 163.26,16.88 C423.1
  BOTTOM w0.102: CN8.12 143.07,25.63 145.15,23.55 146.28,23.55 146.99,22.85 149.96,22.85 150.39,22.42 151.2,22.42 151.6,22.01 155.26,22.01 155.42,22.17 155.93,22.17 156.18,21.92 156.18,21.36 156.86,20.69 158.17,20.69 159.26,19.59 162.14,19.59 v2(162.88,18.86) 163.33,18.4 163.75,18.4 164,18.15 CN10.12 164,16.86 v2(163.64,16.5) 164.38,15.76 165.46,15.76 166.55,14.67 170.73,14.67 172.72,16.66 174.15,16.66 v2(174.81,16)
MY15: length 44.5
  TOP w0.102: v1(168.01,16.04) 168.01,16.06 168.57,16.62 169.73,16.62 169.89,16.47 169.89,16.09 169.99,15.99 170.78,15.99 171.41,16.62 172.78,16.62 172.9,16.74 175.32,16.74 176.02,16.04 U13.55
  IN3 w0.089: v2(164.4,18.86) 164.91,19.37 164.91,20.05 164.58,20.38 163.26,20.38 162.5,21.13 161.58,21.13 160.38,22.33 158.35,22.33 157.94,22.74 156.18,22.74 155.01,21.57 151.2,21.57 149.83,22.93 148.75,22.93 v2(148.36,23.32)
  BOTTOM w0.102: v1(168.01,16.04) 167.88,15.91 167.88,15.86 167.04,15.02 166.89,15.02 165,16.91 CN10.11 165,18.49 165.03,18.53 C427.1 164.48,18.94 v2(164.4,18.86) ; CN8.11 144.07,25.52 145.1,24.5 145.97,24.5 147.24,23.23 148.26,23.23 v2(148.36,23.32)
MY16: length 60.1
  TOP w0.102: v2(176.21,12.95) 176.42,13.16 U13.56 ; C400.1 148.33,17.9 v2(147.82,18.4)
  BOTTOM w0.102: v2(176.21,12.95) 176.21,12.66 174.51,10.96 153.94,10.96 148,16.89 CN10.28 148,18.22 v2(147.82,18.4) 147.82,18.69 147.32,19.19 142.91,19.19 139.63,22.47 134.32,22.47 132.4,24.38 130.8,24.38 130.11,25.07 129.02,25.07 128.79,25.3 128.1,25.3 127.87,25.53 127.2,25.53 127.07,25.65 CN8.28
MY17: length 60.1
  TOP w0.102: C394.1 149.54,16.68 v2(149.73,16.5) ; v2(176.97,12.31) v2(176.97,12.95) 176.96,12.95 176.82,13.1 U13.57
  BOTTOM w0.102: v2(176.97,12.95) 176.53,13.4 176.01,13.4 175.78,13.17 175.78,12.74 174.23,11.19 154.7,11.19 149.73,16.16 v2(149.73,16.5) 149.29,16.5 149,16.78 CN10.27 149,17.8 148.37,18.43 148.37,18.46 147.42,19.42 143.01,19.42 139.73,22.69 134.41,22.69 132.5,24.61 130.89,24.61 130.2,25.3 129.11,25.3 128.88,25.53 128.2,25.53 128.07,25.65 CN8.27
NBSWON#: length 46.9
  TOP w0.102: v2(175.14,32.98) 175.22,32.9 C676.2 175.22,32.27 175.67,31.82 R362.1 175.67,30.72 175.62,30.66 U13.107 175.62,28.84 v2(175.85,28.6)
  BOTTOM w0.102: R430.2 175.17,19.39 175.55,19.77 D17.2 175.79,20.22 175.07,20.94 175.07,21.86 174.81,22.11 174.81,23.33 175.25,23.76 176.29,23.76 176.69,24.17 176.69,25.46 176.46,25.69 175.96,25.69 175.55,26.1 175.55,26.91 175.4,27.06 175.4,28.15 v2(175.85,28.6) ; CN8.1 154.07,25.58 154.27,25.39 154.75,25.39 155.26,25.89 156.3,25.89 158.24,27.84 158.24,28.29 158.61,28.66 158.61,32.93 160.4,34.72 v2(161.86,34.72) 162.8,34.72 SW1.1 163.88,33.64 165.94,33.64 SW1.2 172.21,34.09 172.91,33.39 174.05,33.39 174.46,32.98 v2(175.14,32.98)
NOVRP1: length 2.5
  BOTTOM w0.102: R566.1 v2(100.56,85.75) 100.48,85.84 U2033.25
NOVRP2: length 2.2
  BOTTOM w0.102: R563.1 101.12,86.34 U2033.24
NOVRP3: length 3.1
  BOTTOM w0.102: R552.1 96.2,90.41 97.71,88.9 U2033.20
NOVRP4: length 3.3
  BOTTOM w0.102: R551.1 97.21,88.89 U2033.19
OCP_DET: length 27.2
  TOP w0.102: v2(26.6,15.36) 26.44,15.2 R244.1 25.12,15.2 R2719.1 24.33,15.99 23.68,15.99 23.56,15.86 23.18,15.86 23.05,15.99 22.7,15.99 22.57,15.86 U2034.16
  IN3 w0.089: v2(13.9,25.26) 13,24.35 13,20.56 13.73,19.82 14.39,19.82 17.28,16.93 24.34,16.93 25.91,15.36 v2(26.6,15.36)
  BOTTOM w0.102: U2035.3 14.1,25.07 v2(13.9,25.26)
ODD_PRSNT#: length 67.6
  TOP w0.102: v2(92.26,21.53) 92.26,21.2 93.79,19.67 96.71,19.67 97.55,18.83 102.3,18.83 105.85,15.28 v2(105.85,14.46) ; v1(89.09,46.06) 88.73,45.71 87.95,45.71 87.45,45.21 87.45,42.27 87.62,42.1 87.62,34.72 87.84,34.5 87.84,33.7 87.54,33.4 87.54,32.91 87.08,32.45 87.08,31.96 86.32,31.2 86.32,30.36 87.33,29.35 87.99,29.35 v2(88.48,28.87)
  BOTTOM w0.102: v2(92.26,21.53) 91.71,22.08 89.8,22.08 88.48,23.4 v2(88.48,28.87) ; U2030.AR18 89.44,46.41 v1(89.09,46.06) ; R812.2 123.89,16.24 123.63,15.99 123.63,15.74 C703.1 121.97,14.08 106.23,14.08 v2(105.85,14.46)
ODD_PWR: length 1.4
  TOP w0.102: v1(89.04,44.55) 88.61,44.12 TP2032.1
  BOTTOM w0.102: U2030.AV18 89.51,44.09 v1(89.04,44.55)
PBA_FP_PWREN#: length 136.4
  TOP w0.102: U13.76 180.38,20.16 180.15,19.93 178.34,19.93 v2(177.95,19.54)
  IN1 w0.089: v2(101.79,18.27) 98.99,21.07 91.39,21.07 90.94,20.62 68.43,20.62 66.83,19.02 58.12,19.02 v2(57.72,19.42)
  IN3 w0.089: v2(177.95,19.54) 177.55,19.14 176.36,19.14 176.09,19.41 175.41,19.41 174.96,18.96 174.96,18.63 174.53,18.21 173.72,18.21 172.39,16.88 171.76,16.88 171.13,16.25 171.13,15.99 170.93,15.79 169.25,15.79 168.43,16.61 165.4,16.61 164.69,17.32 159.82,17.32 159.31,16.81 159.31,16.36 159.05,16.1 147.84,16.1 145.86,18.08 101.98,18.08 v2(101.79,18.27)
  BOTTOM w0.102: R418.1 53.73,17.69 54.24,17.18 56.25,17.18 56.58,17.51 56.58,18.27 v2(57.72,19.42)
PBA_PWR:
  vias: v2(51.24,21.84)
PBA_PWR_R:
  vias: v2(53.02,21.84)
PCBEEP_EC: length 43.9
  TOP w0.102: v2(171.64,16.19) 170.5,15.05 167.74,15.05 167.62,14.92 U13.34
  IN2 w0.089: v2(188.97,20.12) 192.71,20.12 193.69,21.1 193.69,23.33 196.18,25.82 196.18,28.03 196.4,28.26 196.4,29.2 197.42,30.21 197.42,32.27 v2(197.14,32.55)
  IN3 w0.089: v2(171.64,16.19) 171.97,16.19 173.8,18.02 183.57,18.02 184.85,19.29 188.14,19.29 v2(188.97,20.12)
  BOTTOM w0.102: D35.2 196.56,33.13 v2(197.14,32.55)
PCBEEP_EC_C: length 7.6
  BOTTOM w0.102: C660.2 198.94,31.74 198.82,31.86 198.82,33.39 199.2,33.77 200.34,33.77 200.57,33.99 R707.1 200.85,34.4 200.95,34.3 R718.2 201.46,34.3 201.49,34.27 C648.2 C638.2
PCH_AZ_CODEC_SDIN0_R: length 4.9
  BOTTOM w0.102: U30.8 199.42,27.26 199.17,27.01 198.34,27.01 198.1,27.25 196.58,27.25 196.12,27.71 R751.1
PCH_BLON_C: length 4.6
  TOP w0.102: R19.1 R12.2 57.49,105.93 57.26,105.7 56.73,105.7 56.61,105.57 R20.1 R28.1 56.61,104.15 56.58,104.13 Q4.5
PCH_BLON_EC: length 185.9
  TOP w0.102: v2(58.18,105.14) 57.59,104.56 R28.2 ; v2(180.11,24.62) 180.44,24.96 U13.88
  IN3 w0.089: v2(58.18,105.14) 59.72,106.69 61.04,106.69 61.91,105.82 64.57,105.82 71.51,98.88 74.37,98.88 75.49,97.76 83,97.76 84.66,96.11 88.33,96.11 89.61,94.84 92.19,94.84 93.04,93.99 94.58,93.99 95.86,92.71 97.9,92.71 99.41,91.2 99.41,85.84 101.05,84.21 101.05,82.5 102.08,81.48 102.67,81.48 103.08,81.06 104.15,81.06 105.55,79.66 105.55,77.55 106.95,76.16 106.95,75.72 107.97,74.7 107.97,74.2 108.87,73.3 110.4,73.3 111.5,72.2 112.45,72.2 113.25,71.39 113.25,70.44 114.21,69.48 114.21,69.06 115.87,67.4 115.87,63 115.99,62.88 115.99,60.25 114.39,58.65 114.08,57.91 114.08,54.34 115.55,52.87 115.55,51.18 117.92,48.81 117.92,44.06 120.33,41.64 120.33,39.66 123.56,36.44 124.28,36.44 124.79,35.93 124.79,35.45 125.13,35.11 129.16,35.11 130.9,36.84 135.72,36.84 136.24,37.36 143.93,37.36 144.26,37.03 144.26,33.35 148.36,29.25 158.36,29.25 158.72,28.89 162.74,28.89 164.06,27.57 167.48,27.57 168.15,26.89 171.96,26.89 174.17,24.69 177.21,24.69 177.86,24.03 179.52,24.03 v2(180.11,24.62)
PCH_PWROK: length 1.6
  TOP w0.102: U13.78 182.2,20.96 TP9103.1
PCH_SUSPWRDNACK: length 2.1
  TOP w0.102: U13.15 v2(164.34,22.56)
  BOTTOM w0.102: TP9082.1 164.5,22.72 v2(164.34,22.56)
PCIE_CLKREQ_LAN#: length 102.5
  TOP w0.102: v2(89.47,80.12) 88.2,80.12 81.6,86.73 75.37,86.73 v2(70.42,91.68) 70.17,91.93 70.17,93.71 66.86,97.01 63.31,97.01 62.67,96.38 62.67,96.02 61.38,94.73 60.01,94.73 59.5,95.24 59.5,96.76 59.91,97.17 R52.1 59.91,98.26 59.24,98.92 58.86,98.92 58.49,99.3 Q6.3 57.97,99.55 57.88,99.46 R44.1 ; v1(86.35,32.26) 86.35,33.18 86.68,33.51 86.68,34.4 85.86,35.22 85.86,36.61 86.22,36.98 86.22,42.65 86.42,42.84 86.42,45.96 86.86,46.4 87.53,46.4 87.67,46.55 88.15,46.55 88.38,46.77 88.38,47.31 v1(88.09,47.59)
  IN3 w0.089: v1(88.09,47.59) 88.09,48.2 87.69,48.6 87.69,50.74 87.74,50.79 87.74,57.85 87.3,58.29 86.96,58.29 86.23,59.02 86.23,59.03 84.85,60.41 84.85,62.17 84.89,62.21 84.89,67.62 84.52,68 84.52,72 86.04,73.52 86.04,74.54 88.5,77 88.5,79.44 89.18,80.12 v2(89.47,80.12)
  BOTTOM w0.102: v1(86.35,32.26) 85.6,33.01 R2465.1 ; v1(88.09,47.59) U2030.AN19
PCIE_CLKREQ_WLAN#: length 131.5
  TOP w0.102: v1(88,46.98) 87.39,47.59 87.39,47.6 87.1,47.89 85.81,47.89 85.36,47.44 v2(85.36,42.32) 85.82,41.86 85.82,37.14 85.25,36.58 85.25,33.6 85.91,32.94 85.91,32.41 v1(85.76,32.26)
  IN2 w0.089: v1(110.63,29.96) 110.63,30.04 109.48,31.18 107.93,31.18 107.5,31.61 107.5,32.49 102.12,37.87 98.89,37.87 98.42,37.4 96.59,37.4 95.37,36.18 93.53,36.18 90.61,33.26 90.61,32.24 90.23,31.86 89.22,31.86 88.94,31.59 87.64,31.59 87.34,31.88 86.14,31.88 v1(85.76,32.26)
  IN3 w0.089: v2(179.51,19.42) 179.51,19.61 178.28,20.85 177.16,20.85 176.74,21.26 171.27,21.26 170.07,22.47 166.59,22.47 164.52,24.54 163.32,24.54 162.41,25.44 154.56,25.44 154.03,25.97 146.83,25.97 145.57,24.71 132.85,24.71 132.22,24.08 122.91,24.08 122.22,23.4 113.27,23.4 111.46,25.21 111.46,29.13 v1(110.63,29.96)
  BOTTOM w0.102: U2030.AP19 88.22,47.21 v1(88,46.98) ; v1(85.76,32.26) 85.75,32.24 R2447.1 ; Q18.3 179.72,19.93 179.72,19.62 v2(179.51,19.42)
PCIE_REQ_LAN#_R: length 24.1
  TOP w0.102: v2(44.89,99.53) 44.64,99.78 44.64,101.21 44.44,101.4 U1.12 ; v2(53.76,101.92) 54.08,101.92 v2(54.93,101.08) 56.1,99.91 R44.2 57.69,99.91 57.85,100.06 58.99,100.06 59.43,100.5 Q6.1 60.96,100.5 61.15,100.32 61.15,99.55 61.53,99.17 R55.1
  BOTTOM w0.102: v2(53.76,101.92) 52.28,100.44 48.83,100.44 47.76,99.38 45.05,99.38 v2(44.89,99.53)
PCIE_RST1#: length 66.8
  IN2 w0.089: v1(105.94,31.14) 103.26,28.46 99.3,28.46 97.88,27.04 97.42,27.04 95.71,25.33 92.44,25.33 91.45,26.31 89.03,26.31 88.46,26.88 86.16,26.88 84.6,25.32 64.86,25.32 v2(63.69,24.15)
  BOTTOM w0.102: U2030.BB6 99.51,40.78 99.89,40.4 100.37,40.4 101.13,39.63 101.75,39.63 102.41,38.97 103.38,38.97 107.81,34.54 107.81,33.71 107,32.89 107,31.6 106.7,31.3 106.11,31.3 v1(105.94,31.14) 105.48,31.6 R6642.2 ; R6024.2 65.59,26.06 v2(63.69,24.15)
PCIE_RST#: length 318.8
  TOP w0.102: v2(48.45,13.4) 48.45,13.75 49.65,14.95 v2(52.39,14.95) 54.04,14.95 56.15,17.05 57.52,17.05 v2(58.1,17.64) ; v2(26.86,96) 28.51,96 28.99,95.52 42,95.52 v2(42.73,96.25) 45.15,98.67 52.26,98.67 53.02,97.9 53.02,96.63 54.16,95.49 57.97,95.49 59.5,93.97 61.68,93.97 v2(62.29,94.58) ; v2(114.79,24.24) 114.79,24.42 115.25,24.88 115.89,24.88 116.46,24.3 120.27,24.3 120.58,24.62 D8515.1 ; U1.19 47.41,104.8 47.57,104.63 47.94,104.63 48.96,103.62 48.96,103.28 49.26,102.98 49.26,101.16 49.59,100.82 54.29,100.82 v2(56.65,98.46)
  IN1 w0.089: v2(56.65,98.46) 57.21,97.9 58.1,97.9 58.99,97.01 59.5,97.01 60.01,96.51 61.02,96.51 62.29,95.24 v2(62.29,94.58)
  IN2 w0.089: v2(64.32,24.15) 65.3,25.13 84.68,25.13 86.24,26.69 88.38,26.69 88.95,26.12 91.38,26.12 92.36,25.14 95.79,25.14 97.5,26.85 109.22,26.85 111.35,28.98 111.35,30.79 v1(110.45,31.69)
  IN3 w0.089: v1(110.45,31.69) 112.37,29.77 112.37,25.85 113.58,24.64 114.39,24.64 v2(114.79,24.24) ; v2(86.68,86.39) 83.99,89.08 82.8,89.08 81.3,90.58 71.22,90.58 70.56,91.24 68.62,91.24 66.49,93.38 66.05,93.38 64.19,95.24 62.95,95.24 v2(62.29,94.58) ; v2(64.32,24.15) 62.01,26.47 52.21,26.47 51.05,27.63 47.86,27.63 44.51,30.97 31.32,30.97 28.91,33.39 26.48,33.39 25.46,34.4 25.46,35.78 24.64,36.61 24.64,37.15 24.76,37.28 24.76,40.42 23.87,41.31 23.87,41.82 22.84,42.85 22.84,44.35 24.83,46.34 24.83,54.85 24.57,55.1 24.57,57.52 26.81,59.76 26.81,79.91 25.72,81.01 25.72,86.35 24.95,87.11 24.95,88.38 25.72,89.14 25.72,94.86 v2(26.86,96)
  BOTTOM w0.102: D2038.1 111.77,33.21 111.51,32.95 D2039.1 v1(110.45,31.69) 109.54,31.69 109.37,31.52 D8510.1 107.89,32.46 107.39,32.46 D6543.1 107.39,32.96 108.23,33.8 C2578.2 108.23,34.75 108.27,34.78 R2462.2 ; U8001.1 84.91,86.26 85.01,86.16 85.29,86.16 85.52,86.39 C8155.2 v2(86.68,86.39) ; v2(58.1,17.64) 59.12,17.64 62.01,20.53 62.01,21.84 v2(64.32,24.15) 66.55,26.38 69,26.38 69.99,27.37 69.99,28.49 69.65,28.83 D6542.1 69.29,29.47 69.57,29.74 D2040.1 ; v2(48.45,13.4) 47.61,12.56 47.18,12.56 46.45,11.83 CN17.2 ; v2(114.79,24.24) 115.3,23.74 D8516.1
PCIE_RST#_R: length 10.5
  BOTTOM w0.102: U2030.BD5 100.39,40.71 101.23,39.86 101.86,39.86 102.52,39.2 103.48,39.2 107.16,35.52 v2(107.5,35.52) 107.63,35.52 107.76,35.64 R2462.1
PCIE_RST#_SSD: length 71
  TOP w0.102: v2(29.14,4.94) R497.1 29.37,4.4 29.4,4.43 R77878.1
  IN2 w0.089: v2(37.91,30.26) 38.16,30.26 38.74,29.68 55.23,29.68 56.58,28.33 62.19,28.33 62.31,28.45 66.39,28.45 v2(66.79,28.05)
  IN3 w0.089: v2(37.91,30.26) 37.72,30.07 37.72,28.84 32.4,23.52 32.4,15.68 30.17,13.45 28.26,13.45 27.37,14.34 25.13,14.34 24.54,13.74 24.54,13.16 24.91,12.78 24.91,8.54 28.51,4.94 v2(29.14,4.94)
  BOTTOM w0.102: D6542.3 67.16,27.13 v2(66.93,27.35) 66.79,27.49 v2(66.79,28.05)
PCIE_RXN0_SSD: length 124
  IN3 w0.089: v1(97.14,65.49) 96.94,65.49 96.81,65.62 96.81,65.82 96.94,65.95 100.34,65.95 100.82,65.47 100.82,48.9 101.18,48.54 101.18,46.95 101.66,46.47 101.66,44.61 100.95,43.9 100.95,42.87 100.65,42.56 100.65,41.29 100.04,40.69 100.04,31.09 98.74,29.79 98.74,29.07 98.59,28.92 98.59,28.48 94.05,23.94 89.41,23.94 88.64,23.17 83.96,23.17 81.52,20.74 70.5,20.74 69.91,21.32 50.31,21.32 48.35,19.37 44.72,19.37 42.28,16.93 42.28,16.33 39.98,14.03 38.59,14.03 38.46,13.91 37.45,13.91 36.56,14.79 32.49,14.79 30.16,12.46 29.37,12.46 28.99,12.84 v2(28.99,12.9)
  BOTTOM w0.102: v1(97.14,65.49) 96.94,65.49 96.79,65.34 96.79,65.13 U2030.N9 ; R850.2 29.7,12.05 29.7,12.38 29.42,12.66 29.17,12.66 28.99,12.84 v2(28.99,12.9)
PCIE_RXN1_SSD: length 127.4
  IN3 w0.089: v2(33.07,12.61) 33.07,12.43 32.94,12.31 32.59,12.31 32.51,12.22 32.51,11.77 32.84,11.44 38.56,11.44 39.77,12.65 40.54,12.65 44.42,16.53 44.42,16.9 44.77,17.25 45.9,17.25 46.67,18.02 51.88,18.02 52.77,18.92 81.61,18.92 84.04,21.35 91.24,21.35 92.05,22.16 94.52,22.16 100.26,27.9 100.26,29.41 101.78,30.93 101.78,33.54 102.17,33.93 102.17,36.02 101.97,36.22 101.97,40.56 102.2,40.78 102.2,41.93 102.8,42.53 102.8,43.04 103.49,43.72 103.49,44.55 103.82,44.88 103.82,49.55 105.54,51.27 105.54,55.47 104.51,56.5 104.51,64.58 101.13,67.95 97.19,67.95 97.06,67.82 97.06,67.63 97.19,67.51 v1(97.3,67.51)
  BOTTOM w0.102: v2(33.07,12.61) 32.85,12.61 32.73,12.48 32.73,12.41 32.62,12.3 32.62,12 32.75,11.87 R844.2 ; v1(97.3,67.51) 97.34,67.47 97.34,67.03 97.22,66.9 97.02,66.9 U2030.L9
PCIE_RXN2_SSD: length 120.9
  IN3 w0.089: v2(36,12.69) 35.77,12.69 35.65,12.56 35.65,12.24 35.77,12.11 38.1,12.11 39.3,13.32 40.26,13.32 43.74,16.81 43.74,17.18 45.26,18.69 51.37,18.69 52.7,20.02 59.2,20.02 59.63,19.59 81.33,19.59 83.93,22.19 90.72,22.19 91.76,23.23 94.29,23.23 99.27,28.21 99.27,28.59 99.43,28.74 99.43,29.52 100.71,30.81 100.71,33.96 101.15,34.4 101.15,35.88 101.3,36.04 101.3,39.53 100.82,40 100.82,40.48 101.35,41.01 101.35,42.25 101.66,42.56 101.66,42.91 102.68,43.93 102.68,46.72 101.92,47.48 101.92,48.85 101.59,49.18 101.59,65.94 100.6,66.93 95.63,66.93 95.54,66.84 95.54,66.66 v1(95.67,66.53)
  BOTTOM w0.102: R846.2 35.71,11.87 35.58,12 35.58,12.41 35.86,12.69 v2(36,12.69) ; v1(95.67,66.53) 95.27,66.53 95.14,66.41 95.14,66.18 U2030.M11
PCIE_RXN3_SSD: length 115.8
  IN3 w0.089: v2(37.93,14.97) 37.93,14.9 38.12,14.71 39.7,14.71 41.59,16.59 41.59,17.29 42.86,18.56 42.86,21.2 43.75,22.08 70.29,22.08 70.97,21.41 81.24,21.41 83.68,23.84 88.36,23.84 89.14,24.62 93.25,24.62 97.98,29.36 97.98,30.47 98.99,31.48 98.99,32.66 99.3,32.96 99.3,34.49 99.37,34.55 99.37,41.51 99.93,42.07 99.93,43.84 100.95,44.86 100.95,46.16 100.5,46.61 100.5,48.13 99.43,49.21 99.43,50.62 98.79,51.25 98.79,52.73 98.31,53.21 98.31,55.82 98.35,55.86 98.35,57.01 98.31,57.05 98.31,64.68 98.08,64.91 94.65,64.91 94.52,64.78 94.52,64.63 94.65,64.5 v1(94.93,64.5)
  BOTTOM w0.102: v1(94.93,64.5) 94.84,64.41 94.84,64.21 95.04,64.01 U2030.P11 ; R852.2 38.75,12.02 38.75,14.49 38.5,14.74 38.13,14.74 37.93,14.95 v2(37.93,14.97)
PCIE_RXN4_LAN: length 76.9
  TOP w0.102: C88.2 48.58,101.7 48.32,101.45 48.32,100.57 48.7,100.19 54.29,100.19 56.45,98.03 58.99,98.03 v2(59.12,98.16)
  IN1 w0.089: v2(59.12,98.16) 59.4,97.88 59.65,97.88 60.42,97.11 61.34,97.11 63.07,95.38 64.3,95.38 65.18,94.51 65.18,94.12 65.72,93.59 65.72,92.72 72.15,86.3 79.9,86.3 81.98,84.22 81.98,81.89 89.55,74.32 89.55,73.95 91.58,71.92 91.58,67.89 91.84,67.63 92.35,67.63 93.58,66.39 93.58,64.53 94.3,63.82 94.3,62.47 94.68,62.09 95.44,62.09 96.43,61.1 97.73,61.1 97.81,61.02 99.05,61.02 99.17,61.15 99.17,61.24 v1(98.9,61.51)
  BOTTOM w0.102: U2030.V7 98.36,61.17 98.36,61.38 98.48,61.51 v1(98.9,61.51)
PCIE_RXN5_WLAN: length 137.4
  IN1 w0.089: v1(96.69,61.51) 96.9,61.71 96.9,61.92 97.11,62.13 100.39,62.13 100.77,61.74 100.77,61.45 102.3,59.93 102.71,59.93 104.07,58.57 106.63,58.57 108.17,57.03 108.17,55.74 113.26,50.65 113.26,44.98 113.47,44.77 113.47,41.3 112.55,40.38 112.55,37.96 111.31,36.72 111.31,36.27 110.32,35.28 110.32,33.24 110.65,32.91 110.65,32.46 111.21,31.91 111.21,25.46 113.57,23.1 116.11,23.1 116.26,23.26 121.34,23.26 121.95,23.86 124.9,23.86 125.27,23.5 130.43,23.5 131.2,24.28 144.72,24.28 146.03,25.59 148.27,25.59 149.41,26.73 152.62,26.73 153.51,25.84 155.65,25.84 156.52,26.71 158.18,26.71 158.74,26.15 165.09,26.15 165.46,26.52 167.66,26.52 168.79,25.39 170.44,25.39 171.05,24.77 173.6,24.77 174.21,24.17 177.08,24.17 177.72,23.53 182.39,23.53 183.22,22.69 186.84,22.69 187.11,22.42 187.11,21.9 v2(187.3,21.7)
  BOTTOM w0.102: v2(187.3,21.7) 187.3,21.05 186.96,20.71 184.26,20.71 184.19,20.63 CN9.43 ; v1(96.69,61.51) 96.91,61.72 U2030.T9
PCIE_RXN13_SSD_C: length 1.9
  BOTTOM w0.102: CN18.5 38.85,10.58 38.71,10.72 38.71,11.03 R852.1
PCIE_RXN14_SSD_C: length 2
  BOTTOM w0.102: R846.1 35.71,11.15 35.71,10.72 35.85,10.58 CN18.17
PCIE_RXN15_SSD_C: length 2
  BOTTOM w0.102: R844.1 32.71,11.15 32.71,10.72 32.85,10.58 CN18.29
PCIE_RXN16_SSD_C: length 1.9
  BOTTOM w0.102: R850.1 29.71,11.04 29.71,10.72 29.85,10.58 CN18.41
PCIE_RXN_LAN_L: length 3.3
  TOP w0.102: U1.18 47.35,104.4 47.44,104.3 47.76,104.3 48.19,103.87 48.19,103.49 48.45,103.24 48.45,102.86 C88.1
PCIE_RXP0_SSD: length 124
  IN3 w0.089: v2(28.99,12.26) 30.24,12.26 32.57,14.59 36.48,14.59 37.37,13.7 38.54,13.7 38.67,13.83 40.07,13.83 42.48,16.24 42.48,16.84 44.8,19.16 48.44,19.16 50.39,21.12 69.83,21.12 70.41,20.53 81.61,20.53 84.04,22.97 88.73,22.97 89.5,23.74 94.13,23.74 98.79,28.39 98.79,28.83 98.94,28.98 98.94,29.71 100.24,31.01 100.24,40.6 100.85,41.21 100.85,42.48 101.15,42.79 101.15,43.82 101.87,44.53 101.87,46.55 101.38,47.04 101.38,48.63 101.03,48.98 101.03,65.55 100.43,66.15 96.85,66.15 96.61,65.91 96.61,65.68 v1(96.44,65.51)
  BOTTOM w0.102: v1(96.44,65.51) 96.11,65.19 U2030.N10 ; v2(28.99,12.26) 29.18,12.44 29.33,12.44 29.49,12.29 29.49,12.03 R849.2
PCIE_RXP1_SSD: length 127.4
  IN3 w0.089: v1(96.69,67.51) 96.86,67.91 97.1,68.15 101.22,68.15 104.71,64.66 104.71,56.59 105.75,55.55 105.75,51.19 104.02,49.47 104.02,44.8 103.69,44.47 103.69,43.64 103.01,42.95 103.01,42.45 102.4,41.84 102.4,40.7 102.18,40.47 102.18,36.3 102.37,36.1 102.37,33.84 101.98,33.46 101.98,30.84 100.47,29.33 100.47,27.82 94.61,21.96 92.13,21.96 91.32,21.15 84.13,21.15 81.69,18.71 52.86,18.71 51.96,17.82 46.76,17.82 45.98,17.05 44.85,17.05 44.62,16.81 44.62,16.44 40.62,12.44 39.85,12.44 38.65,11.24 32.75,11.24 32.31,11.68 v2(32.31,12.61)
  BOTTOM w0.102: U2030.L10 v1(96.69,67.51) ; v2(32.31,12.61) 32.37,12.54 32.37,12.02 R843.2
PCIE_RXP2_SSD: length 120.9
  IN3 w0.089: v1(95.16,66.92) 95.55,67.13 100.69,67.13 101.79,66.03 101.79,49.26 102.12,48.93 102.12,47.57 102.88,46.81 102.88,43.84 101.87,42.83 101.87,42.48 101.55,42.17 101.55,40.92 101.03,40.4 101.03,40.09 101.5,39.61 101.5,35.95 101.35,35.8 101.35,34.31 100.92,33.88 100.92,30.73 99.63,29.44 99.63,28.65 99.48,28.5 99.48,28.13 94.38,23.02 91.84,23.02 90.81,21.99 84.02,21.99 81.41,19.39 59.55,19.39 59.12,19.82 52.79,19.82 51.46,18.49 45.35,18.49 43.95,17.09 43.95,16.72 40.34,13.12 39.39,13.12 38.18,11.91 35.69,11.91 35.44,12.16 35.44,12.48 v2(35.24,12.69)
  BOTTOM w0.102: v2(35.24,12.69) 35.37,12.56 35.37,12.02 R845.2 ; U2030.L12 v1(95.16,66.92)
PCIE_RXP3_SSD: length 115.8
  IN3 w0.089: v2(37.93,14.34) 38.09,14.5 39.79,14.5 41.79,16.51 41.79,17.21 43.06,18.48 43.06,21.11 43.83,21.88 70.21,21.88 70.88,21.21 81.33,21.21 83.76,23.64 88.44,23.64 89.22,24.42 93.33,24.42 98.18,29.27 98.18,30.38 99.2,31.4 99.2,32.57 99.5,32.88 99.5,34.4 99.57,34.47 99.57,41.42 100.14,41.99 100.14,43.76 101.15,44.77 101.15,46.25 100.71,46.69 100.71,48.22 99.63,49.3 99.63,50.7 98.99,51.34 98.99,52.82 98.52,53.3 98.52,55.74 98.56,55.78 98.56,57.1 98.52,57.14 98.52,64.76 98.17,65.11 94.57,65.11 94.32,64.86 94.32,64.65 v1(94.17,64.5)
  BOTTOM w0.102: U2030.P12 v1(94.17,64.5) ; v2(37.93,14.34) 38.12,14.53 38.41,14.53 38.53,14.4 38.53,12.06 R851.2
PCIE_RXP4_LAN: length 76.9
  TOP w0.102: v2(59.12,97.52) 58.83,97.81 56.36,97.81 54.2,99.97 48.61,99.97 48.11,100.48 48.11,101.41 C94.2
  IN1 w0.089: v2(59.12,97.52) 59.2,97.6 59.2,97.6 59.28,97.67 59.57,97.67 60.33,96.91 61.26,96.91 62.98,95.18 64.22,95.18 64.98,94.42 64.98,94.04 65.52,93.5 65.52,92.64 72.06,86.09 79.82,86.09 81.77,84.14 81.77,81.81 89.34,74.24 89.34,73.87 91.37,71.83 91.37,67.8 91.76,67.42 92.26,67.42 93.38,66.31 93.38,64.44 94.09,63.73 94.09,62.39 94.59,61.89 95.35,61.89 96.34,60.9 97.65,60.9 97.72,60.82 99.13,60.82 99.38,61.06 99.38,61.37 v1(99.51,61.51)
  BOTTOM w0.102: U2030.V6 99.21,61.2 v1(99.51,61.51)
PCIE_RXP5_WLAN: length 137.4
  IN1 w0.089: v1(97.3,61.51) 97.1,61.71 97.1,61.84 97.19,61.93 100.3,61.93 100.57,61.66 100.57,61.37 102.21,59.73 102.63,59.73 103.99,58.37 106.55,58.37 107.97,56.95 107.97,55.66 113.06,50.57 113.06,44.9 113.27,44.69 113.27,41.39 112.35,40.47 112.35,38.05 111.11,36.81 111.11,36.36 110.11,35.36 110.11,33.16 110.44,32.83 110.44,32.38 111,31.82 111,25.38 113.48,22.9 116.19,22.9 116.35,23.05 121.43,23.05 122.03,23.66 124.82,23.66 125.18,23.3 130.51,23.3 131.29,24.07 144.81,24.07 146.12,25.39 148.36,25.39 149.5,26.53 152.54,26.53 153.43,25.64 155.74,25.64 156.6,26.5 158.09,26.5 158.65,25.94 165.17,25.94 165.54,26.31 167.58,26.31 168.71,25.18 170.35,25.18 170.97,24.57 173.52,24.57 174.12,23.96 176.99,23.96 177.63,23.32 182.31,23.32 183.14,22.49 186.75,22.49 186.86,22.38 186.86,22.22 186.75,22.11 186.56,22.11 186.47,22.03 186.47,21.89 v2(186.67,21.7)
  BOTTOM w0.102: U2030.T8 97.59,62.13 97.41,62.13 97.3,62.03 v1(97.3,61.51) ; CN9.41 184.02,21.13 184.23,20.92 186.87,20.92 187.09,21.14 187.09,21.28 187.03,21.34 186.8,21.34 186.67,21.47 v2(186.67,21.7)
PCIE_RXP13_SSD_C: length 1.9
  BOTTOM w0.102: CN18.7 38.35,10.58 38.49,10.72 38.49,11.06 R851.1
PCIE_RXP14_SSD_C: length 2
  BOTTOM w0.102: CN18.19 35.35,10.58 35.49,10.72 35.49,11.14 R845.1
PCIE_RXP15_SSD_C: length 2
  BOTTOM w0.102: R843.1 32.49,11.15 32.49,10.72 32.35,10.58 CN18.31
PCIE_RXP16_SSD_C: length 1.9
  BOTTOM w0.102: CN18.43 29.35,10.58 29.49,10.72 29.49,11.05 R849.1
PCIE_RXP_LAN_L: length 3
  TOP w0.102: U1.17 47.3,104 47.39,104.09 47.67,104.09 47.98,103.78 47.98,103.4 48.23,103.15 48.23,102.9 C94.1
PCIE_TXN0_SSD: length 127.3
  IN3 w0.089: v2(28.41,8.37) 28.19,8.58 28.19,9.03 29.36,10.2 38.56,10.2 40.13,11.77 41.49,11.77 45.93,16.2 46.16,16.2 47.08,17.12 52.53,17.12 53.45,18.04 78.66,18.04 79.06,17.64 81.57,17.64 84.26,20.33 92.28,20.33 92.83,20.87 94.47,20.87 101.15,27.55 101.15,29.06 102.94,30.84 102.94,31.87 103.15,32.09 103.15,37.19 103.82,37.86 103.82,42.81 104.46,43.46 104.46,44.28 104.71,44.53 104.71,49.05 106.42,50.76 106.42,54.56 107.47,55.62 107.47,65.99 108.57,67.09 108.8,67.09 109.03,66.86 v2(109.03,66.79)
  BOTTOM w0.102: v2(109.03,66.79) 108.76,67.05 108.53,67.05 108.36,66.89 C2633.1 ; v2(28.41,8.37) 28.35,8.43 CN18.47
PCIE_TXN0_SSD_C: length 8.3
  BOTTOM w0.102: C2633.2 107.57,67 107.34,67 107.19,66.85 106.07,66.85 104.36,65.14 103.49,65.14 102.83,64.48 101.84,64.48 101.56,64.19 101.2,64.19 U2030.P3
PCIE_TXN1_SSD: length 130.3
  IN3 w0.089: v2(111.31,65.65) 111.1,65.86 110.89,65.86 110.55,65.52 110.55,64.21 110.24,63.9 110.24,62.32 108.82,60.9 108.82,55.06 107.76,54 107.76,50.2 106.06,48.49 106.06,43.5 105.81,43.25 105.81,40.93 105.47,40.59 105.47,36.18 104.93,35.64 104.93,32.26 104.87,32.19 104.87,30.87 102.99,28.99 102.99,27.21 98.44,22.66 98.44,22.16 94.96,18.68 93.56,18.68 90.99,16.12 90.99,14.46 87.95,11.42 83.12,11.42 79.71,14.83 72.47,14.83 72.07,15.23 70.27,15.23 69.88,14.83 46.46,14.83 42.05,10.43 40.69,10.43 38.94,8.67 36.31,8.67 35.24,7.61 32.95,7.61 31.94,8.62 31.35,8.62 31.21,8.48 31.21,8.35 v2(31.43,8.14)
  BOTTOM w0.102: CN18.35 31.35,8.22 v2(31.43,8.14) ; v2(111.31,65.65) 111.31,65.67 111.05,65.94 110.78,65.94 110.65,65.81 C2635.1
PCIE_TXN1_SSD_C: length 10.8
  BOTTOM w0.089: U2030.P2 101.42,63.52 102.82,63.52 103.13,63.83 103.15,63.83 103.16,63.84
  BOTTOM w0.102: 103.16,63.84 103.73,64.41 104.62,64.41 105.95,65.75 108.88,65.75 109.19,66.06 109.77,66.06 109.9,65.94 109.9,65.75 109.7,65.56 109.7,65.41 109.8,65.31 109.99,65.31 C2635.2
PCIE_TXN2_SSD: length 120.3
  IN3 w0.089: v2(34.43,8.37) 34.2,8.6 34.2,8.72 34.2,8.98 34.61,9.38 38.7,9.38 40.41,11.1 41.77,11.1 46.21,15.53 62.72,15.53 64.5,17.31 67.03,17.31 67.67,16.67 81.56,16.67 84.54,19.65 94.95,19.65 97.72,22.43 97.72,22.92 102.3,27.49 102.3,29.25 103.9,30.85 103.9,34.07 103.83,34.14 103.83,36.92 104.49,37.58 104.49,41.93 105.14,42.58 105.14,44 105.38,44.25 105.38,48.77 107.09,50.48 107.09,54.28 108.15,55.34 108.15,64.47 108.48,64.81 108.8,64.81 109.03,64.58 v2(109.03,64.5)
  BOTTOM w0.102: v2(109.03,64.5) 108.74,64.79 108.52,64.79 108.36,64.64 C2637.1 ; v2(34.43,8.37) 34.35,8.45 CN18.23
PCIE_TXN2_SSD_C: length 7.8
  BOTTOM w0.102: U2030.R1 101.91,63.11 103.31,63.11 103.82,63.61 104.84,63.61 106.27,65.05 107.57,65.05 107.64,64.97 107.64,64.77 107.5,64.62 107.5,64.43 107.63,64.3 107.84,64.3 C2637.2
PCIE_TXN3_SSD: length 124.3
  IN3 w0.089: v2(36.56,7.1) 36.35,7.31 36.35,7.57 36.76,7.99 39.21,7.99 40.97,9.75 42.33,9.75 46.74,14.16 79.38,14.16 83.05,10.49 88.07,10.49 91.71,14.13 91.71,15.81 93.9,18.01 95.28,18.01 99.58,22.3 99.58,22.84 103.66,26.92 103.66,28.71 105.55,30.6 105.55,31.94 105.61,31.99 105.61,35.27 106.51,36.17 106.51,42.27 106.78,42.54 106.78,44.6 107.12,44.94 107.12,48.61 108.44,49.92 108.44,53.72 109.49,54.78 109.49,60.62 110.91,62.04 110.91,63.29 111.06,63.43 111.24,63.43 v2(111.31,63.36)
  BOTTOM w0.102: C2639.1 110.65,63.52 110.8,63.68 111,63.68 v2(111.31,63.36) ; CN18.11 37.35,8.83 36.36,7.83 36.36,7.3 v2(36.56,7.1)
PCIE_TXN3_SSD_C: length 10.2
  BOTTOM w0.089: U2030.T2 101.25,62.51 101.18,62.43 101.18,62.28 101.32,62.14 101.46,62.14 101.83,62.51 102.08,62.51 102.2,62.63 102.49,62.63 102.5,62.61 102.52,62.61
  BOTTOM w0.102: C2639.2 109.87,63.56 106.47,63.56 105.79,62.88 104.03,62.88 103.76,62.61 102.52,62.61
PCIE_TXN4_LAN: length 100.8
  TOP w0.102: v2(45.88,101.36) 45.55,101.36 45.15,101.76 45.15,102.52 45.24,102.61 U1.14
  IN3 w0.089: v2(112.08,61.71) 112.29,61.49 112.68,61.49 113.12,61.93 113.12,62.44 112.98,62.58 112.98,66.01 111.69,67.3 111.09,67.3 109.92,68.46 108.46,68.46 107.6,69.33 105.34,69.33 103.74,70.93 103.74,75.2 101.84,77.1 100.33,77.1 98.96,78.47 98.96,79.07 98.65,79.39 98.24,79.39 96,81.63 96,81.94 94.6,83.34 94.6,88.8 93.55,89.85 88.02,89.85 85.35,92.53 82.36,92.53 81.33,93.56 74.48,93.56 73.7,94.33 69.95,94.33 67.4,96.87 66.09,96.87 63.79,99.17 61.12,99.17 60.71,99.58 51.81,99.58 51.4,99.17 45.82,99.17 44.77,100.22 44.77,101.24 45.04,101.51 45.38,101.51 45.53,101.36 v2(45.88,101.36)
  BOTTOM w0.102: v2(112.08,61.71) 111.89,61.52 110.97,61.52 C2641.2
PCIE_TXN4_LAN_C: length 10.6
  BOTTOM w0.102: C2641.1 109.97,61.61 107.6,61.61 105.7,59.7 101.66,59.7 101.53,59.83 101.28,59.83 101.22,59.76 U2030.W4
PCIE_TXN5_WLAN: length 121.9
  IN1 w0.089: v2(109.03,62.22) 108.81,62.43 108.69,62.43 108.6,62.34 108.6,61.88 113.8,56.68 113.8,55.95 117.06,52.69 117.06,46.01 117.64,45.43 117.64,36.89 116.22,35.46 116.22,34.35 114.87,33.01 114.87,28.62 116.27,27.22 119.34,27.22 119.5,27.38 131.55,27.38 132.14,26.78 144.19,26.78 145.1,27.7 147.08,27.7 148.91,29.53 158.44,29.53 158.7,29.27 166.09,29.27 166.6,29.78 170.64,29.78 171.63,28.79 171.63,28.45 172.96,27.11 176.55,27.11 176.83,26.83 182.51,26.83 182.94,26.4 186.1,26.4 186.35,26.16 186.35,25.91 v2(186.57,25.69)
  BOTTOM w0.102: v2(109.03,62.22) 108.82,62.43 108.7,62.43 C2632.2 ; CN9.37 184.18,22.13 184.32,22.27 184.76,22.27 185.23,22.74 185.23,23.23 186.36,24.36 186.36,25.48 v2(186.57,25.69)
PCIE_TXN5_WLAN_C: length 9.3
  BOTTOM w0.102: U2030.V2 101.29,60.39 101.29,60.27 101.38,60.18 101.54,60.18 101.81,60.45 102.09,60.45 102.33,60.69 102.94,60.69 103.36,60.26 105.55,60.26 107.21,61.92 107.21,62.64 107.34,62.76 107.55,62.76 107.72,62.59 107.83,62.59 107.91,62.51 C2632.1
PCIE_TXP0_SSD: length 127.3
  IN3 w0.089: v2(109.03,67.42) 108.9,67.3 108.49,67.3 107.27,66.08 107.27,55.7 106.21,54.65 106.21,50.84 104.51,49.14 104.51,44.61 104.26,44.37 104.26,43.54 103.61,42.89 103.61,37.94 102.95,37.28 102.95,32.17 102.73,31.95 102.73,30.93 100.95,29.14 100.95,27.64 94.39,21.07 92.74,21.07 92.2,20.53 84.17,20.53 81.49,17.84 79.14,17.84 78.74,18.24 53.37,18.24 52.45,17.32 46.99,17.32 46.08,16.41 45.84,16.41 41.41,11.97 40.05,11.97 38.47,10.4 29.27,10.4 27.99,9.12 27.99,8.58 v2(27.77,8.37)
  BOTTOM w0.102: v2(109.03,67.42) 108.88,67.27 108.65,67.27 C2654.1 ; v2(27.77,8.37) 27.85,8.44 CN18.49
PCIE_TXP0_SSD_C: length 8.3
  BOTTOM w0.102: U2030.N2 101.27,64.65 101.27,64.79 101.36,64.88 101.51,64.88 101.69,64.69 102.74,64.69 103.4,65.35 104.27,65.35 105.98,67.07 107.1,67.07 107.25,67.22 107.58,67.22 C2654.2
PCIE_TXP1_SSD: length 130.3
  IN3 w0.089: v2(111.31,66.28) 111.1,66.06 110.81,66.06 110.35,65.6 110.35,64.3 110.04,63.99 110.04,62.41 108.62,60.98 108.62,55.14 107.56,54.09 107.56,50.29 105.85,48.58 105.85,43.58 105.61,43.33 105.61,41.01 105.27,40.68 105.27,36.27 104.73,35.73 104.73,32.34 104.67,32.28 104.67,30.96 102.79,29.07 102.79,27.3 98.23,22.74 98.23,22.24 94.87,18.88 93.47,18.88 90.79,16.2 90.79,14.55 87.86,11.62 83.2,11.62 79.79,15.03 72.55,15.03 72.16,15.43 70.19,15.43 69.79,15.03 46.37,15.03 41.97,10.63 40.61,10.63 38.85,8.88 36.22,8.88 35.16,7.81 33.04,7.81 32.02,8.83 31.27,8.83 31,8.56 31.01,8.42 31.01,8.35 v2(30.79,8.14)
  BOTTOM w0.102: v2(30.79,8.14) 30.85,8.2 CN18.37 ; v2(111.31,66.28) 111.19,66.15 110.91,66.15 C2634.1
PCIE_TXP1_SSD_C: length 10.9
  BOTTOM w0.089: U2030.P4 100.94,63.51 101.27,63.83 101.54,63.83 101.66,63.71 102.74,63.71 103,63.96 103,63.98 103.01,64
  BOTTOM w0.102: 103.01,64 103.64,64.63 104.53,64.63 105.86,65.96 108.79,65.96 109.1,66.28 110.07,66.28 C2634.2
PCIE_TXP2_SSD: length 120.3
  IN3 w0.089: v2(33.77,8.37) 34,8.6 34,8.72 34,9.07 34.52,9.59 38.61,9.59 40.33,11.3 41.69,11.3 46.12,15.73 62.64,15.73 64.42,17.51 67.12,17.51 67.75,16.88 81.47,16.88 84.45,19.86 94.86,19.86 97.52,22.52 97.52,23.01 102.09,27.58 102.09,29.33 103.7,30.94 103.7,33.99 103.62,34.06 103.62,37 104.29,37.66 104.29,42.01 104.93,42.66 104.93,44.09 105.18,44.33 105.18,48.86 106.89,50.57 106.89,54.37 107.94,55.42 107.94,64.56 108.39,65.01 108.9,65.01 v2(109.03,65.14)
  BOTTOM w0.102: CN18.25 33.85,8.45 v2(33.77,8.37) ; C2636.1 108.36,65.14 108.49,65.01 108.9,65.01 v2(109.03,65.14)
PCIE_TXP2_SSD_C: length 7.8
  BOTTOM w0.102: U2030.R3 101.36,63.01 101.67,63.32 103.22,63.32 103.73,63.83 104.75,63.83 106.18,65.26 C2636.2
PCIE_TXP3_SSD: length 124.3
  IN3 w0.089: v2(35.93,7.1) 36.14,7.31 36.14,7.65 36.68,8.19 39.12,8.19 40.89,9.96 42.25,9.96 46.65,14.36 79.47,14.36 83.13,10.69 87.98,10.69 91.5,14.21 91.5,15.89 93.82,18.21 95.2,18.21 99.38,22.39 99.38,22.92 103.46,27.01 103.46,28.79 105.35,30.68 105.35,32.02 105.4,32.07 105.4,35.35 106.31,36.26 106.31,42.35 106.58,42.62 106.58,44.69 106.92,45.03 106.92,48.69 108.23,50.01 108.23,53.81 109.29,54.86 109.29,60.7 110.71,62.13 110.71,63.37 110.98,63.64 110.98,63.66 v2(111.31,63.99)
  BOTTOM w0.102: v2(35.93,7.1) 36.14,7.31 36.14,7.92 36.85,8.63 CN18.13 ; C2638.1 110.88,63.89 111.21,63.89 v2(111.31,63.99)
PCIE_TXP3_SSD_C: length 10.3
  BOTTOM w0.089: 102.52,62.83 102.5,62.83 102.49,62.82 102.12,62.82 102,62.7 101.64,62.7 101.53,62.81 101.26,62.81 101.22,62.76 U2030.T4
  BOTTOM w0.102: 102.52,62.83 103.67,62.83 103.94,63.1 105.7,63.1 106.38,63.78 109.86,63.78 C2638.2
PCIE_TXP4_LAN: length 100.8
  TOP w0.102: v2(45.43,100.91) 45.43,101.18 44.93,101.67 44.93,102.52 44.84,102.61 U1.13
  IN3 w0.089: v2(45.43,100.91) 45.43,101.18 45.3,101.3 45.12,101.3 44.97,101.15 44.97,100.31 45.9,99.38 51.32,99.38 51.73,99.78 60.79,99.78 61.2,99.38 63.87,99.38 66.17,97.08 67.49,97.08 70.03,94.53 73.79,94.53 74.56,93.76 81.42,93.76 82.44,92.73 85.43,92.73 88.11,90.05 93.64,90.05 94.8,88.89 94.8,83.43 96.2,82.03 96.2,81.72 98.33,79.59 98.73,79.59 99.17,79.15 99.17,78.55 100.42,77.3 101.92,77.3 103.95,75.28 103.95,71.01 105.43,69.53 107.68,69.53 108.55,68.67 110,68.67 111.17,67.5 111.78,67.5 113.19,66.09 113.19,62.66 113.32,62.53 113.32,61.85 112.76,61.29 112.29,61.29 v2(112.08,61.07)
  BOTTOM w0.102: C2640.2 110.96,61.31 111.84,61.31 v2(112.08,61.07)
PCIE_TXP4_LAN_C: length 10.6
  BOTTOM w0.102: C2640.1 109.81,61.39 107.69,61.39 105.79,59.49 101.83,59.49 101.5,59.16 101.29,59.16 101.18,59.28 101.18,59.39 101.3,59.51 U2030.W2
PCIE_TXP5_WLAN: length 121.9
  IN1 w0.089: v2(109.03,62.85) 108.81,62.64 108.6,62.64 108.39,62.43 108.39,61.8 113.6,56.59 113.6,55.87 116.86,52.61 116.86,45.93 117.44,45.34 117.44,36.97 116.01,35.55 116.01,34.44 114.67,33.09 114.67,28.54 116.19,27.02 119.42,27.02 119.58,27.18 131.46,27.18 132.06,26.58 144.27,26.58 145.19,27.49 147.16,27.49 148.99,29.32 158.35,29.32 158.61,29.06 166.17,29.06 166.69,29.58 170.55,29.58 171.42,28.71 171.42,28.36 172.88,26.91 176.46,26.91 176.74,26.63 182.43,26.63 182.86,26.2 186.02,26.2 186.15,26.07 186.15,25.91 v2(185.93,25.69)
  BOTTOM w0.102: v2(109.03,62.85) 108.82,62.64 108.71,62.64 C2631.2 ; CN9.35 184.18,22.63 184.32,22.49 184.67,22.49 185.01,22.83 185.01,23.32 186.14,24.45 186.14,25.48 v2(185.93,25.69)
PCIE_TXP5_WLAN_C: length 9.4
  BOTTOM w0.102: U2030.W3 101.01,60.44 101.06,60.52 101.15,60.69 101.31,60.84 101.53,60.84 101.72,60.65 102,60.65 102.25,60.89 102.51,60.89 102.52,60.9 103.03,60.9 103.45,60.48 105.46,60.48 107,62.01 107,62.72 107.25,62.98 C2631.1
PCIE_WAKE#: length 238.3
  TOP w0.102: R2438.1 95.64,29.22 v1(95.64,29.45) 95.64,30.07 C2579.2 ; R6643.1 49.85,105.9 49.97,105.78 50.99,105.78 51.37,105.4 51.37,104 50.79,103.41 v2(50.23,103.41)
  IN1 w0.089: v1(95.44,25.89) 95.44,26.66 95.64,26.86 v1(95.64,29.45)
  IN2 w0.089: v2(50.23,103.41) 50.23,102.86 50.02,102.65 49.5,102.65 49.33,102.48 49.33,101.85 50.61,100.57 v2(50.61,97.14) ; v2(177.92,17.39) 177.15,17.39 176.85,17.69 168.74,17.69 167.65,18.78 166.23,18.78 165.85,18.4 165.85,18.12 165.23,17.51 161.06,17.51 158.68,19.88 150.09,19.88 149.16,20.81 146.05,20.81 143.85,23.02 124.72,23.02 123.67,24.07 121.98,24.07 119.9,21.98 112.1,21.98 110.04,19.93 110.04,19.54 109.41,18.91 105.47,18.91 103.69,20.69 103.69,22.55 103.33,22.91 102.17,22.91 101.68,22.41 101.68,22.35 99.94,20.61 94.78,20.61 v1(94.4,20.23)
  IN3 w0.089: v2(50.61,97.14) 51.14,96.61 52.66,96.61 53.87,95.4 58.38,95.4 60.1,97.12 63.11,97.12 66.29,93.95 66.72,93.95 68.86,91.82 77.9,91.82 78.74,90.98 81.45,90.98 82.97,89.46 85.34,89.46 86.69,88.1 91.52,88.1 92.09,87.54 92.09,81.48 91.17,80.56 91.17,79.91 90.85,79.6 90.85,78.11 91.28,77.68 91.28,72.92 88.47,70.11 88.47,65.75 88.65,65.58 88.65,63.6 89.34,62.91 89.34,59.52 90.51,58.35 90.51,53.3 91.18,52.63 91.44,52.63 91.71,52.36 91.71,51.3 92.48,50.53 95.57,50.53 96.2,49.9 96.2,47.23 96.6,46.83 96.6,44.82 v1(96.01,44.23) 96.51,43.73 96.51,43.49 96.78,43.22 96.78,41.83 97.29,41.31 97.29,35.66 98.3,34.66 98.3,31.8 95.95,29.45 v1(95.64,29.45)
  BOTTOM w0.102: v2(177.92,17.39) 178.22,17.08 178.63,17.08 179,16.7 179,15.2 180,14.21 EC9.1 180.52,14.58 180.66,14.72 Q46.3 ; v1(95.44,25.89) 94.61,25.07 94.61,20.44 v1(94.4,20.23) ; v1(96.01,44.23) 95.96,44.23 95.74,44.01 U2030.AV11
PCIE_ZVSS: length 7.1
  BOTTOM w0.102: R2645.1 106.61,118.6 106.54,118.53 106.54,117.61 105.78,116.85 103.02,116.85 102.82,116.64 102.82,115.65 103.2,115.26 U2029.AU41
PD#: length 16.8
  TOP w0.102: D36.2 201.48,18.84 201.48,20.04 C377.1 201.82,20.71 200.47,20.71 200.11,21.07 R364.1 R355.1 200.06,22.08 200.19,22.21 200.54,22.21 v2(200.75,22.41)
  BOTTOM w0.102: U30.47 201.33,23.08 200.75,22.49 v2(200.75,22.41) 200.59,22.26 199.43,22.26 198.87,21.7 198.87,20.53 198.51,20.18 195.39,20.18 D37.2
PEG_RXN0: length 58.6
  TOP w0.102: C8133.1 96.23,109.89 96.1,110.02 95.87,110.02 v2(95.67,109.82)
  IN1 w0.089: v1(96.58,64.53) 96.81,64.53 96.91,64.63 96.91,64.86 97.16,65.11 101.76,65.11 105.58,68.93 105.58,75.18 106.11,75.71 106.11,78.5 105.58,79.02 105.58,79.76 103.62,81.72 103.62,83.19 103.01,83.8 103.01,84.2 101.92,85.29 101.92,86.04 100.65,87.31 100.65,88.36 98.03,90.97 98.03,93.25 97.27,94.01 97.27,95.31 96.4,96.18 96.4,109.89 96.27,110.02 95.87,110.02 v2(95.67,109.82)
  BOTTOM w0.102: U2030.P9 96.58,64.34 v1(96.58,64.53)
PEG_RXN0_C: length 8.4
  TOP w0.102: C8133.2 96.68,109.99 96.81,110.12 97.47,110.12 97.75,110.4 101.2,110.4 102.08,111.28 102.58,111.28 102.83,111.53 102.83,111.68 v2(103.13,111.97)
  BOTTOM w0.102: v2(103.13,111.97) 103.13,111.9 U2029.AU35
PEG_RXN1: length 59
  TOP w0.102: C8132.1 95.94,111.53 95.31,111.53 95.18,111.4 95.18,108.34 95.4,108.13 95.56,108.13 v2(95.99,108.55)
  IN1 w0.089: v2(95.99,108.55) 95.73,108.29 95.46,108.29 95.18,108.02 95.18,107.01 95.65,106.54 95.65,98.88 94.6,97.83 94.6,97.19 94.42,97.01 94.42,95.2 97.14,92.48 97.14,90.91 99.85,88.2 99.85,87.15 101.22,85.79 101.22,85.03 102.28,83.97 102.28,82.96 102.93,82.31 102.93,80.17 105.4,77.7 105.4,76.14 104.91,75.65 104.91,69.3 102.47,66.86 102.12,66.86 101.39,66.14 99.33,66.14 99.1,65.91 99.1,65.63 99.01,65.54 v1(98.87,65.54)
  BOTTOM w0.102: v1(98.87,65.54) 98.87,65.37 U2030.N7
PEG_RXN1_C: length 8.9
  TOP w0.102: C8132.2 96.88,111.44 97.12,111.44 97.45,111.11 100.65,111.11 102.04,112.51 102.91,112.51 v2(103.72,113.32)
  BOTTOM w0.102: U2029.AU39 103.54,113.62 103.72,113.44 v2(103.72,113.32)
PEG_RXN2: length 60.2
  TOP w0.102: C8126.1 95.98,113.27 95.77,113.27 v2(95.59,113.45)
  IN1 w0.089: v1(97.45,66.53) 97.51,66.53 97.61,66.63 97.61,66.9 97.83,67.12 101.4,67.12 104.23,69.95 104.23,72.94 103.82,73.35 103.82,75.71 104.61,76.5 104.61,77.48 101.82,80.27 101.82,82.37 101.61,82.58 101.61,83.69 100.54,84.75 100.54,85.51 99.18,86.87 99.18,87.92 96.38,90.72 96.38,92.1 93.71,94.77 93.71,95.99 93.41,96.29 93.41,97.68 94.17,98.44 94.17,99.76 94.98,100.57 94.98,106.2 94.47,106.71 94.47,112.94 94.8,113.27 95.41,113.27 v2(95.59,113.45)
  BOTTOM w0.102: v1(97.45,66.53) 97.44,66.53 U2030.M9
PEG_RXN2_C: length 10.3
  TOP w0.102: C8126.2 96.81,113.4 101.61,113.4 102.33,114.12 104.04,114.12 104.4,113.76 104.4,113.02 v2(104.81,112.61)
  BOTTOM w0.102: U2029.AR38 104.3,112.71 104.41,112.61 v2(104.81,112.61)
PEG_RXN3: length 62.8
  TOP w0.102: v2(95.31,114.24) 95.54,114.46 96.05,114.46 C8116.1
  IN1 w0.089: v2(95.31,114.24) 95.52,114.44 95.85,114.44 96.15,114.74 96.15,115.23 95.62,115.76 94.34,115.76 93.79,115.21 93.79,106.57 92.95,105.73 92.95,100.75 91.63,99.43 91.63,95.86 95.36,92.13 95.36,90.78 98.51,87.64 98.51,86.59 99.87,85.23 99.87,84.48 100.94,83.41 100.94,82.3 101.15,82.09 101.15,79.96 103.11,78 103.11,73.11 103.56,72.66 103.56,70.77 103.06,70.27 103.06,69.74 102.64,69.33 101.76,69.33 100.59,68.16 99.28,68.16 99.03,67.91 99.03,67.67 v1(98.89,67.52)
  BOTTOM w0.102: U2030.L7 98.89,67.39 v1(98.89,67.52)
