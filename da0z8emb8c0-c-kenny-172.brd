# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Library data of the parts (continued)
PU15 = RT6258CGQUF_12P_BGM: tolerance: AL006258006
PU2000 PU9005 = G5335QT2U_BGM
PU3003 = JW5222RSOTB#TRPBF_6P_V1_BGM: tolerance: AL005222000
PU3004 = JW5213DFND_8P_BGM: tolerance: AL005213003
PU6000 PU9000 = RT3662ACGQW_BGM
PU9006 = TMP708_BGM
PU9007 = JW5213DFND_8P_BGM
Q4 Q21 Q2031 Q2032 Q6565 = MOS-N_Dual_6P_ESD_BGM
Q14 = NPN_0
Q16 = NPN_BGM
Q33 = AP2331SA-7-01_BGM
Q2030 = 2N7002
Q2038 = 2N7002DW
Q6544 = NPN_V2_BGM
R232 R238 = RES_BGM: tolerance: CS06202FB13
R312 R323 R335 R363 R382 R6533 R6534 R6536 R6538 = RES_BGM: tolerance: CS02202FB12
R313 R373 R384 R694 R6532 = RES_BGM: tolerance: CS00002JB38
R325 R348 R459 R462 R791 R77864 R77865 = RES_S_BGM
R358 = RES_BGM: tolerance: CS00003J951
R551 = R_2
R552 = R_4
R556 = R_3
R559 = RESISTOR
R563 R566 R77880 = R_5
R571 = R_8
R2211-R2216 R2218-R2221 R2223 R2226 R2229-R2232 R2599-R2601 R2603-R2616 R2618 R2622-R2627 R2631-R2639 R2648 R2650-R2653 R2656 R2657 R2660-R2662 R2664 R2667-R2669 R2673 R8041 R8042 R8046 R8047 R8053 R8069 R8103 R8104 R8107 R8118 R8122 R8123 R8128 R8133 R8527 R12293 R12295 R12296 R77829 R77830 R77832 R77833 R77851 R77853-R77856 R77861 = RES_BGM_1
R2236-R2239 R2254 R2257 R2640-R2642 R2654 R2655 R2674 R2675 R2677-R2681 = R_31
R2240 R2253 R2663 R2671 = R_40
R2619 R2620 = R_30
R2645 = R_23
R2665 R2666 R77827 R77828 = R_22
R2717 R2718 = R_Current_SEN_BGM: tolerance: CS+0018FL00
R6507 = R-0603
R6508 = R_9
RV1 RV2 = TPD4E02B04DQAR_BGM
SW1 = SW_4P_BGM
SW2 = SW_6P_BGM
SW3 = SW_6P_R_BGM
TP2-TP4 TP35 TP36 TP39 TP41 TP43-TP49 TP68 TP83 TP98 TP2023 TP2024 TP8001 TP8002 TP8007 TP8010 TP8067 TP8073-TP8076 TP9075 TP9082-TP9084 TP9087-TP9089 TP9091-TP9093 TP9095 TP9101-TP9103 TP9111 = TP_BGM
TP2025-TP2028 TP2039 TP2044 TP2045 TP2050-TP2056 TP8547 TP8548 TP9097 TP9098 TP9100 TP9104 TP9106-TP9110 = PAD_3
TP2032 TP2038 TP8000 TP8006 TP8008 TP8009 TP8011-TP8013 TP8068 TP8071 TP8527-TP8531 TP9079 TP9081 TP9099 = PAD_0
TP2089-TP2091 TP9078 TP9085 TP9086 = PAD_53
U1 = RTL8111HSH-CG_BGM
U5 U11 = LXESEABAA6-046_0
U7 = SLGC55544VTR_BGM
U13 = IT5571E-I-128/CX_128P_BGM
U15 = NPCT750AAAYX_32P_BGM
U16 = LIS3DHTR_BGM
U17 = SN75LVCP601RTJR_BGM
U21 = NS680016_0
U23 = G524B1T11U_BGM
U26 = PTN3366_0
U28 U35 = MAX8863_2
U30 = ALC255-CG_BGM_0
U33 = SPI_WND_8P_BGM: tolerance: AKE3DF-KN01
U2013 U2014 U2017 U2018 = DDR4_96P_BGM_0
U2021 = AP2138N-1.5TRG1_BGM
U2028 = SST25LF080A_0
U2029 = BAFFIN
U2030 = FP5_0
U2031 = EMMC_153P_BGM_1
U2032 = 53398-0410_2
U2033 = CY7C65632-QFN28_2
U2034 = RTS5441E-GR_24P_BGM
U2035 = G518A1TO1U_5P_BGM
U2038 = SPI_WND_8P_BGM: tolerance: AKE5EZN0N00
U2039 = 74LVC1G17GW_5P_BGM
U5400 = G781_BGM
U8001 U8023 = Logic_AND_BGM
U8021 = SI51214
U8022 = 74LVC2G07GW_BGM
VRAM2001 VRAM2002 = 170BALL_GDDR5_1
Y1 Y2002 Y2004 = CRYSTAL_4P_BGM
Y2003 = CRYSTAL_2P_BGM
Y2005 = XTAL TSX-3225 EPSONTOYO _0

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2D-BARCODE-6X6-S
  round 0.991 smd: 1(6,-3)
2D-BARCODE-8X8-S
  round 0.991 smd: 1(7,-4)
132F18-100000-A2-R-18P-L
  rect 0.305x0.838 smd: 1(-4.25,3.175) 2(-3.75,3.175) 3(-3.25,3.175) 4(-2.75,3.175) 5(-2.25,3.175) 6(-1.75,3.175) 7(-1.25,3.175) 8(-0.75,3.175) 9(-0.25,3.175) 10(0.25,3.175) 11(0.75,3.175) 12(1.25,3.175) 13(1.75,3.175) 14(2.25,3.175) 15(2.75,3.175) 16(3.25,3.175) 17(3.75,3.175) 18(4.25,3.175)
  rect 0.787x2.007 smd: 19(-5.95,0) 20(5.95,0)
50208-00401-V02-4P-L
  rect 0.508x0.991 smd: 1(-1.2,1.95) 2(-0.4,1.95) 3(0.4,1.95) 4(1.2,1.95)
  rect 1.194x1.702 smd: 5(-2.5,0) 6(2.5,0)
50281-00201-001-2P-L
  rect 0.787x2.007 smd: 1(-0.625,4.05) 2(0.625,4.05)
  rect 2.007x2.489 smd: 3(-2.825,0) 4(2.825,0)
50505-00401-V01-4P-L
  rect 0.61x1.295 smd: 1(-1.5,3.25) 2(-0.5,3.25) 3(0.5,3.25) 4(1.5,3.25)
  rect 0.991x2.007 smd: 5(-4.1,0) 6(4.1,0)
50584-0280N-V02-28P-L
  rect 0.61x1.092 smd: 1(-13.5,2.05) 2(-12.5,2.05) 3(-11.5,2.05) 4(-10.5,2.05) 5(-9.5,2.05) 6(-8.5,2.05) 7(-7.5,2.05) 8(-6.5,2.05) 9(-5.5,2.05) 10(-4.5,2.05) 11(-3.5,2.05) 12(-2.5,2.05) 13(-1.5,2.05) 14(-0.5,2.05) 15(0.5,2.05) 16(1.5,2.05) 17(2.5,2.05) 18(3.5,2.05) 19(4.5,2.05) 20(5.5,2.05) 21(6.5,2.05) 22(7.5,2.05) 23(8.5,2.05) 24(9.5,2.05) 25(10.5,2.05) 26(11.5,2.05) 27(12.5,2.05) 28(13.5,2.05)
  rect 2.159x2.997 smd: 29(-15.975,0) 30(15.975,0)
51325-00401-001-4P-L
  rect 0.61x1.549 smd: 1(-1.5,3.875) 2(-0.5,3.875) 3(0.5,3.875) 4(1.5,3.875)
  rect 1.194x1.803 smd: 5(-2.8,0) 6(2.8,0)
51614-00601-V01-6P-L
  rect 0.305x0.787 smd: 1(-1.25,2.5) 2(-0.75,2.5) 3(-0.25,2.5) 4(0.25,2.5) 5(0.75,2.5) 6(1.25,2.5)
  rect 0.406x0.787 smd: 7(-2.25,0) 8(2.25,0)
51625-01201-001-12P-L
  rect 0.305x0.838 smd: 1(-2.75,3.555) 2(-2.25,3.555) 3(-1.75,3.555) 4(-1.25,3.555) 5(-0.75,3.555) 6(-0.25,3.555) 7(0.25,3.555) 8(0.75,3.555) 9(1.25,3.555) 10(1.75,3.555) 11(2.25,3.555) 12(2.75,3.555)
  rect 0.991x1.448 smd: 13(-4.54,0) 14(4.54,0)
196047-08021-3-8P-L
  rect 0.305x1.295 smd: 1(-3.5,2.65) 2(-2.5,2.65) 3(-1.5,2.65) 4(-0.5,2.65) 5(0.5,2.65) 6(1.5,2.65) 7(2.5,2.65) 8(3.5,2.65)
  rect 1.803x1.397 smd: 9(-5.65,0) 10(5.65,0)
196241-08021-3-8P-L
  rect 0.305x1.295 smd: 1(-1.75,2.7) 2(-1.25,2.7) 3(-0.75,2.7) 4(-0.25,2.7) 5(0.25,2.7) 6(0.75,2.7) 7(1.25,2.7) 8(1.75,2.7)
  rect 1.854x1.397 smd: 9(-3.425,0) 10(3.425,0)
196538-40041-3-40P-L
  rect 0.305x0.838 smd: 1(-9.75,3.175) 2(-9.25,3.175) 3(-8.75,3.175) 4(-8.25,3.175) 5(-7.75,3.175) 6(-7.25,3.175) 7(-6.75,3.175) 8(-6.25,3.175) 9(-5.75,3.175) 10(-5.25,3.175) 11(-4.75,3.175) 12(-4.25,3.175) 13(-3.75,3.175) 14(-3.25,3.175) 15(-2.75,3.175) 16(-2.25,3.175) 17(-1.75,3.175) 18(-1.25,3.175) 19(-0.75,3.175) 20(-0.25,3.175) 21(0.25,3.175) 22(0.75,3.175) 23(1.25,3.175) 24(1.75,3.175) 25(2.25,3.175) 26(2.75,3.175) 27(3.25,3.175) 28(3.75,3.175) 29(4.25,3.175) 30(4.75,3.175) 31(5.25,3.175) 32(5.75,3.175) 33(6.25,3.175) 34(6.75,3.175) 35(7.25,3.175) 36(7.75,3.175) 37(8.25,3.175) 38(8.75,3.175) 39(9.25,3.175) 40(9.75,3.175)
  rect 0.787x2.007 smd: 41(-11.45,0) 42(11.45,0)
ASP-137098-05-20P-LDV
  rect 0.737x2.794 smd: 1(-5.715,-2.035) 2(-5.715,2.035) 3(-4.445,-2.035) 4(-4.445,2.035) 5(-3.175,-2.035) 6(-3.175,2.035) 7(-1.905,-2.035) 8(-1.905,2.035) 9(-0.635,-2.035) 10(-0.635,2.035) 11(0.635,-2.035) 12(0.635,2.035) 13(1.905,-2.035) 14(1.905,2.035) 15(3.175,-2.035) 16(3.175,2.035) 17(4.445,-2.035) 18(4.445,2.035) 19(5.715,-2.035) 20(5.715,2.035)
BGA96-MICRON-MT41J64M16JT-187EG
  round 0.356 smd: A1(-3.2,6) A2(-2.4,6) A3(-1.6,6) A7(1.6,6) A8(2.4,6) A9(3.2,6) B1(-3.2,5.2) B2(-2.4,5.2) B3(-1.6,5.2) B7(1.6,5.2) B8(2.4,5.2) B9(3.2,5.2) C1(-3.2,4.4) C2(-2.4,4.4) C3(-1.6,4.4) C7(1.6,4.4) C8(2.4,4.4) C9(3.2,4.4) D1(-3.2,3.6) D2(-2.4,3.6) D3(-1.6,3.6) D7(1.6,3.6) D8(2.4,3.6) D9(3.2,3.6) E1(-3.2,2.8) E2(-2.4,2.8) E3(-1.6,2.8) E7(1.6,2.8) E8(2.4,2.8) E9(3.2,2.8) F1(-3.2,2) F2(-2.4,2) F3(-1.6,2) F7(1.6,2) F8(2.4,2) F9(3.2,2) G1(-3.2,1.2) G2(-2.4,1.2) G3(-1.6,1.2) G7(1.6,1.2) G8(2.4,1.2) G9(3.2,1.2) H1(-3.2,0.4) H2(-2.4,0.4) H3(-1.6,0.4) H7(1.6,0.4) H8(2.4,0.4) H9(3.2,0.4) J1(-3.2,-0.4) J2(-2.4,-0.4) J3(-1.6,-0.4) J7(1.6,-0.4) J8(2.4,-0.4) J9(3.2,-0.4) K1(-3.2,-1.2) K2(-2.4,-1.2) K3(-1.6,-1.2) K7(1.6,-1.2) K8(2.4,-1.2) K9(3.2,-1.2) L1(-3.2,-2) L2(-2.4,-2) L3(-1.6,-2) L7(1.6,-2) L8(2.4,-2) L9(3.2,-2) M1(-3.2,-2.8) M2(-2.4,-2.8) M3(-1.6,-2.8) M7(1.6,-2.8) M8(2.4,-2.8) M9(3.2,-2.8) N1(-3.2,-3.6) N2(-2.4,-3.6) N3(-1.6,-3.6) N7(1.6,-3.6) N8(2.4,-3.6) N9(3.2,-3.6) P1(-3.2,-4.4) P2(-2.4,-4.4) P3(-1.6,-4.4) P7(1.6,-4.4) P8(2.4,-4.4) P9(3.2,-4.4) R1(-3.2,-5.2) R2(-2.4,-5.2) R3(-1.6,-5.2) R7(1.6,-5.2) R8(2.4,-5.2) R9(3.2,-5.2) T1(-3.2,-6) T2(-2.4,-6) T3(-1.6,-6) T7(1.6,-6) T8(2.4,-6) T9(3.2,-6)
BGA153-SANDISK-SDIN7DP4-16G
  round 0.254 smd: A1(-3.25,-3.25) A2(-3.25,-2.75) A3(-3.25,-2.25) A4(-3.25,-1.75) A5(-3.25,-1.25) A6(-3.25,-0.75) A7(-3.25,-0.25) A8(-3.25,0.25) A9(-3.25,0.75) A10(-3.25,1.25) A11(-3.25,1.75) A12(-3.25,2.25) A13(-3.25,2.75) A14(-3.25,3.25) B1(-2.75,-3.25) B2(-2.75,-2.75) B3(-2.75,-2.25) B4(-2.75,-1.75) B5(-2.75,-1.25) B6(-2.75,-0.75) B7(-2.75,-0.25) B8(-2.75,0.25) B9(-2.75,0.75) B10(-2.75,1.25) B11(-2.75,1.75) B12(-2.75,2.25) B13(-2.75,2.75) B14(-2.75,3.25) C1(-2.25,-3.25) C2(-2.25,-2.75) C3(-2.25,-2.25) C4(-2.25,-1.75) C5(-2.25,-1.25) C6(-2.25,-0.75) C7(-2.25,-0.25) C8(-2.25,0.25) C9(-2.25,0.75) C10(-2.25,1.25) C11(-2.25,1.75) C12(-2.25,2.25) C13(-2.25,2.75) C14(-2.25,3.25) D1(-1.75,-3.25) D2(-1.75,-2.75) D3(-1.75,-2.25) D4(-1.75,-1.75) D12(-1.75,2.25) D13(-1.75,2.75) D14(-1.75,3.25) E1(-1.25,-3.25) E2(-1.25,-2.75) E3(-1.25,-2.25) E5(-1.25,-1.25) E6(-1.25,-0.75) E7(-1.25,-0.25) E8(-1.25,0.25) E9(-1.25,0.75) E10(-1.25,1.25) E12(-1.25,2.25) E13(-1.25,2.75) E14(-1.25,3.25) F1(-0.75,-3.25) F2(-0.75,-2.75) F3(-0.75,-2.25) F5(-0.75,-1.25) F10(-0.75,1.25) F12(-0.75,2.25) F13(-0.75,2.75) F14(-0.75,3.25) G1(-0.25,-3.25) G2(-0.25,-2.75) G3(-0.25,-2.25) G5(-0.25,-1.25) G10(-0.25,1.25) G12(-0.25,2.25) G13(-0.25,2.75) G14(-0.25,3.25) H1(0.25,-3.25) H2(0.25,-2.75) H3(0.25,-2.25) H5(0.25,-1.25) H10(0.25,1.25) H12(0.25,2.25) H13(0.25,2.75) H14(0.25,3.25) J1(0.75,-3.25) J2(0.75,-2.75) J3(0.75,-2.25) J5(0.75,-1.25) J10(0.75,1.25) J12(0.75,2.25) J13(0.75,2.75) J14(0.75,3.25) K1(1.25,-3.25) K2(1.25,-2.75) K3(1.25,-2.25) K5(1.25,-1.25) K6(1.25,-0.75) K7(1.25,-0.25) K8(1.25,0.25) K9(1.25,0.75) K10(1.25,1.25) K12(1.25,2.25) K13(1.25,2.75) K14(1.25,3.25) L1(1.75,-3.25) L2(1.75,-2.75) L3(1.75,-2.25) L12(1.75,2.25) L13(1.75,2.75) L14(1.75,3.25) M1(2.25,-3.25) M2(2.25,-2.75) M3(2.25,-2.25) M4(2.25,-1.75) M5(2.25,-1.25) M6(2.25,-0.75) M7(2.25,-0.25) M8(2.25,0.25) M9(2.25,0.75) M10(2.25,1.25) M11(2.25,1.75) M12(2.25,2.25) M13(2.25,2.75) M14(2.25,3.25) N1(2.75,-3.25) N2(2.75,-2.75) N3(2.75,-2.25) N4(2.75,-1.75) N5(2.75,-1.25) N6(2.75,-0.75) N7(2.75,-0.25) N8(2.75,0.25) N9(2.75,0.75) N10(2.75,1.25) N11(2.75,1.75) N12(2.75,2.25) N13(2.75,2.75) N14(2.75,3.25) P1(3.25,-3.25) P2(3.25,-2.75) P3(3.25,-2.25) P4(3.25,-1.75) P5(3.25,-1.25) P6(3.25,-0.75) P7(3.25,-0.25) P8(3.25,0.25) P9(3.25,0.75) P10(3.25,1.25) P11(3.25,1.75) P12(3.25,2.25) P13(3.25,2.75) P14(3.25,3.25)
BGA170-MICRON-MT51J256M32HF
  round 0.356 smd: A1(-6.4,-5.2) A2(-6.4,-4.4) A3(-6.4,-3.6) A4(-6.4,-2.8) A5(-6.4,-2) A10(-6.4,2) A11(-6.4,2.8) A12(-6.4,3.6) A13(-6.4,4.4) A14(-6.4,5.2) B1(-5.6,-5.2) B2(-5.6,-4.4) B3(-5.6,-3.6) B4(-5.6,-2.8) B5(-5.6,-2) B10(-5.6,2) B11(-5.6,2.8) B12(-5.6,3.6) B13(-5.6,4.4) B14(-5.6,5.2) C1(-4.8,-5.2) C2(-4.8,-4.4) C3(-4.8,-3.6) C4(-4.8,-2.8) C5(-4.8,-2) C10(-4.8,2) C11(-4.8,2.8) C12(-4.8,3.6) C13(-4.8,4.4) C14(-4.8,5.2) D1(-4,-5.2) D2(-4,-4.4) D3(-4,-3.6) D4(-4,-2.8) D5(-4,-2) D10(-4,2) D11(-4,2.8) D12(-4,3.6) D13(-4,4.4) D14(-4,5.2) E1(-3.2,-5.2) E2(-3.2,-4.4) E3(-3.2,-3.6) E4(-3.2,-2.8) E5(-3.2,-2) E10(-3.2,2) E11(-3.2,2.8) E12(-3.2,3.6) E13(-3.2,4.4) E14(-3.2,5.2) F1(-2.4,-5.2) F2(-2.4,-4.4) F3(-2.4,-3.6) F4(-2.4,-2.8) F5(-2.4,-2) F10(-2.4,2) F11(-2.4,2.8) F12(-2.4,3.6) F13(-2.4,4.4) F14(-2.4,5.2) G1(-1.6,-5.2) G2(-1.6,-4.4) G3(-1.6,-3.6) G4(-1.6,-2.8) G5(-1.6,-2) G10(-1.6,2) G11(-1.6,2.8) G12(-1.6,3.6) G13(-1.6,4.4) G14(-1.6,5.2) H1(-0.8,-5.2) H2(-0.8,-4.4) H3(-0.8,-3.6) H4(-0.8,-2.8) H5(-0.8,-2) H10(-0.8,2) H11(-0.8,2.8) H12(-0.8,3.6) H13(-0.8,4.4) H14(-0.8,5.2) J1(0,-5.2) J2(0,-4.4) J3(0,-3.6) J4(0,-2.8) J5(0,-2) J10(0,2) J11(0,2.8) J12(0,3.6) J13(0,4.4) J14(0,5.2) K1(0.8,-5.2) K2(0.8,-4.4) K3(0.8,-3.6) K4(0.8,-2.8) K5(0.8,-2) K10(0.8,2) K11(0.8,2.8) K12(0.8,3.6) K13(0.8,4.4) K14(0.8,5.2) L1(1.6,-5.2) L2(1.6,-4.4) L3(1.6,-3.6) L4(1.6,-2.8) L5(1.6,-2) L10(1.6,2) L11(1.6,2.8) L12(1.6,3.6) L13(1.6,4.4) L14(1.6,5.2) M1(2.4,-5.2) M2(2.4,-4.4) M3(2.4,-3.6) M4(2.4,-2.8) M5(2.4,-2) M10(2.4,2) M11(2.4,2.8) M12(2.4,3.6) M13(2.4,4.4) M14(2.4,5.2) N1(3.2,-5.2) N2(3.2,-4.4) N3(3.2,-3.6) N4(3.2,-2.8) N5(3.2,-2) N10(3.2,2) N11(3.2,2.8) N12(3.2,3.6) N13(3.2,4.4) N14(3.2,5.2) P1(4,-5.2) P2(4,-4.4) P3(4,-3.6) P4(4,-2.8) P5(4,-2) P10(4,2) P11(4,2.8) P12(4,3.6) P13(4,4.4) P14(4,5.2) R1(4.8,-5.2) R2(4.8,-4.4) R3(4.8,-3.6) R4(4.8,-2.8) R5(4.8,-2) R10(4.8,2) R11(4.8,2.8) R12(4.8,3.6) R13(4.8,4.4) R14(4.8,5.2) T1(5.6,-5.2) T2(5.6,-4.4) T3(5.6,-3.6) T4(5.6,-2.8) T5(5.6,-2) T10(5.6,2) T11(5.6,2.8) T12(5.6,3.6) T13(5.6,4.4) T14(5.6,5.2) U1(6.4,-5.2) U2(6.4,-4.4) U3(6.4,-3.6) U4(6.4,-2.8) U5(6.4,-2) U10(6.4,2) U11(6.4,2.8) U12(6.4,3.6) U13(6.4,4.4) U14(6.4,5.2)
BGA769-AMD-FT3
  round 0.4 smd: A2(-11.3,-10.7) A3(-11.3,-9.95) A39(-11.3,9.95) A40(-11.3,10.7) AA4(0,-9.2) AA5(0,-8.4) AA7(0,-7.6) AA8(0,-6.8) AA10(0,-6) AA11(0,-5) AA13(0,-4) AA15(0,-3) AA17(0,-2) AA19(0,-1) AA21(0,0) AA23(0,1) AA25(0,2) AA27(0,3) AA29(0,4) AA31(0,5) AA32(0,6) AA34(0,6.8) AA35(0,7.6) AA37(0,8.4) AA38(0,9.2) AC4(1.1,-9.2) AC5(1.1,-8.4) AC7(1.1,-7.6) AC8(1.1,-6.8) AC10(1.1,-6) AC11(1,-5) AC13(1,-4) AC15(1,-3) AC17(1,-2) AC19(1,-1) AC21(1,0) AC23(1,1) AC25(1,2) AC27(1,3) AC29(1,4) AC31(1,5) AC32(1.1,6) AC34(1.1,6.8) AC35(1.1,7.6) AC37(1.1,8.4) AC38(1.1,9.2) AE4(2.2,-9.2) AE5(2.2,-8.4) AE7(2.2,-7.6) AE8(2.2,-6.8) AE10(2.2,-6) AE11(2,-5) AE13(2,-4) AE15(2,-3) AE17(2,-2) AE19(2,-1) AE21(2,0) AE23(2,1) AE25(2,2) AE27(2,3) AE29(2,4) AE31(2,5) AE32(2.2,6) AE34(2.2,6.8) AE35(2.2,7.6) AE37(2.2,8.4) AE38(2.2,9.2) AG4(3.3,-9.2) AG5(3.3,-8.4) AG7(3.3,-7.6) AG8(3.3,-6.8) AG10(3.3,-6) AG11(3,-5) AG13(3,-4) AG15(3,-3) AG17(3,-2) AG19(3,-1) AG21(3,0) AG23(3,1) AG25(3,2) AG27(3,3) AG29(3,4) AG31(3,5) AG32(3.3,6) AG34(3.3,6.8) AG35(3.3,7.6) AG37(3.3,8.4) AG38(3.3,9.2) AJ4(4.4,-9.2) AJ5(4.4,-8.4) AJ7(4.4,-7.6) AJ8(4.4,-6.8) AJ10(4.4,-6) AJ11(4,-5) AJ13(4,-4) AJ15(4,-3) AJ17(4,-2) AJ19(4,-1) AJ21(4,0) AJ23(4,1) AJ25(4,2) AJ27(4,3) AJ29(4,4) AJ31(4,5) AJ32(4.4,6) AJ34(4.4,6.8) AJ35(4.4,7.6) AJ37(4.4,8.4) AJ38(4.4,9.2) AL4(5.5,-9.2) AL5(5.5,-8.4) AL7(5.5,-7.6) AL8(5.5,-6.8) AL10(5.5,-6) AL11(5,-5) AL13(5,-4) AL15(5,-3) AL17(5,-2) AL19(5,-1) AL21(5,0) AL23(5,1) AL25(5,2) AL27(5,3) AL29(5,4) AL31(5,5) AL32(5.5,6) AL34(5.5,6.8) AL35(5.5,7.6) AL37(5.5,8.4) AL38(5.5,9.2) AM11(6,-5.5) AM13(6,-4.4) AM15(6,-3.3) AM17(6,-2.2) AM19(6,-1.1) AM21(6,0) AM23(6,1.1) AM25(6,2.2) AM27(6,3.3) AM29(6,4.4) AM31(6,5.5) AN4(6.6,-9.2) AN5(6.6,-8.4) AN7(6.6,-7.6) AN8(6.6,-6.8) AN34(6.6,6.8) AN35(6.6,7.6) AN37(6.6,8.4) AN38(6.6,9.2) AP11(6.8,-5.5) AP13(6.8,-4.4) AP15(6.8,-3.3) AP17(6.8,-2.2) AP19(6.8,-1.1) AP21(6.8,0) AP23(6.8,1.1) AP25(6.8,2.2) AP27(6.8,3.3) AP29(6.8,4.4) AP31(6.8,5.5) AR4(7.7,-9.2) AR5(7.7,-8.4) AR7(7.7,-7.6) AR11(7.6,-5.5) AR13(7.6,-4.4) AR15(7.6,-3.3) AR17(7.6,-2.2) AR19(7.6,-1.1) AR21(7.6,0) AR23(7.6,1.1) AR25(7.6,2.2) AR27(7.6,3.3) AR29(7.6,4.4) AR31(7.6,5.5) AR35(7.7,7.6) AR37(7.7,8.4) AR38(7.7,9.2) AU4(8.8,-9.2) AU7(8.4,-7.7) AU9(8.4,-6.6) AU11(8.4,-5.5) AU13(8.4,-4.4) AU15(8.4,-3.3) AU17(8.4,-2.2) AU19(8.4,-1.1) AU21(8.4,0) AU23(8.4,1.1) AU25(8.4,2.2) AU27(8.4,3.3) AU29(8.4,4.4) AU31(8.4,5.5) AU33(8.4,6.6) AU35(8.4,7.7) AU38(8.8,9.2) AV7(9.2,-7.7) AV9(9.2,-6.6) AV11(9.2,-5.5) AV13(9.2,-4.4) AV15(9.2,-3.3) AV17(9.2,-2.2) AV19(9.2,-1.1) AV21(9.2,0) AV23(9.2,1.1) AV25(9.2,2.2) AV27(9.2,3.3) AV29(9.2,4.4) AV31(9.2,5.5) AV33(9.2,6.6) AV35(9.2,7.7) AW1(9.95,-11.3) AW41(9.95,11.3) AY1(10.7,-11.3) AY2(10.6,-10.6) AY40(10.6,10.6) AY41(10.7,11.3) B1(-10.7,-11.3) B2(-10.6,-10.6) B40(-10.6,10.6) B41(-10.7,11.3) BA2(11.3,-10.7) BA3(11.3,-9.95) BA39(11.3,9.95) BA40(11.3,10.7) C1(-9.95,-11.3) C41(-9.95,11.3) D7(-9.2,-7.7) D9(-9.2,-6.6) D11(-9.2,-5.5) D13(-9.2,-4.4) D15(-9.2,-3.3) D17(-9.2,-2.2) D19(-9.2,-1.1) D21(-9.2,0) D23(-9.2,1.1) D25(-9.2,2.2) D27(-9.2,3.3) D29(-9.2,4.4) D31(-9.2,5.5) D33(-9.2,6.6) D35(-9.2,7.7) E4(-8.8,-9.2) E7(-8.4,-7.7) E9(-8.4,-6.6) E11(-8.4,-5.5) E13(-8.4,-4.4) E15(-8.4,-3.3) E17(-8.4,-2.2) E19(-8.4,-1.1) E21(-8.4,0) E23(-8.4,1.1) E25(-8.4,2.2) E27(-8.4,3.3) E29(-8.4,4.4) E31(-8.4,5.5) E33(-8.4,6.6) E35(-8.4,7.7) E38(-8.8,9.2) G4(-7.7,-9.2) G5(-7.7,-8.4) G7(-7.7,-7.6) G11(-7.6,-5.5) G13(-7.6,-4.4) G15(-7.6,-3.3) G17(-7.6,-2.2) G19(-7.6,-1.1) G21(-7.6,0) G23(-7.6,1.1) G25(-7.6,2.2) G27(-7.6,3.3) G29(-7.6,4.4) G31(-7.6,5.5) G35(-7.7,7.6) G37(-7.7,8.4) G38(-7.7,9.2) H11(-6.8,-5.5) H13(-6.8,-4.4) H15(-6.8,-3.3) H17(-6.8,-2.2) H19(-6.8,-1.1) H21(-6.8,0) H23(-6.8,1.1) H25(-6.8,2.2) H27(-6.8,3.3) H29(-6.8,4.4) H31(-6.8,5.5) J4(-6.6,-9.2) J5(-6.6,-8.4) J7(-6.6,-7.6) J8(-6.6,-6.8) J34(-6.6,6.8) J35(-6.6,7.6) J37(-6.6,8.4) J38(-6.6,9.2) K11(-6,-5.5) K13(-6,-4.4) K15(-6,-3.3) K17(-6,-2.2) K19(-6,-1.1) K21(-6,0) K23(-6,1.1) K25(-6,2.2) K27(-6,3.3) K29(-6,4.4) K31(-6,5.5) L4(-5.5,-9.2) L5(-5.5,-8.4) L7(-5.5,-7.6) L8(-5.5,-6.8) L10(-5.5,-6) L11(-5,-5) L13(-5,-4) L15(-5,-3) L17(-5,-2) L19(-5,-1) L21(-5,0) L23(-5,1) L25(-5,2) L27(-5,3) L29(-5,4) L31(-5,5) L32(-5.5,6) L34(-5.5,6.8) L35(-5.5,7.6) L37(-5.5,8.4) L38(-5.5,9.2) N4(-4.4,-9.2) N5(-4.4,-8.4) N7(-4.4,-7.6) N8(-4.4,-6.8) N10(-4.4,-6) N11(-4,-5) N13(-4,-4) N15(-4,-3) N17(-4,-2) N19(-4,-1) N21(-4,0) N23(-4,1) N25(-4,2) N27(-4,3) N29(-4,4) N31(-4,5) N32(-4.4,6) N34(-4.4,6.8) N35(-4.4,7.6) N37(-4.4,8.4) N38(-4.4,9.2) R4(-3.3,-9.2) R5(-3.3,-8.4) R7(-3.3,-7.6) R8(-3.3,-6.8) R10(-3.3,-6) R11(-3,-5) R13(-3,-4) R15(-3,-3) R17(-3,-2) R19(-3,-1) R21(-3,0) R23(-3,1) R25(-3,2) R27(-3,3) R29(-3,4) R31(-3,5) R32(-3.3,6) R34(-3.3,6.8) R35(-3.3,7.6) R37(-3.3,8.4) R38(-3.3,9.2) U4(-2.2,-9.2) U5(-2.2,-8.4) U7(-2.2,-7.6) U8(-2.2,-6.8) U10(-2.2,-6) U11(-2,-5) U13(-2,-4) U15(-2,-3) U17(-2,-2) U19(-2,-1) U21(-2,0) U23(-2,1) U25(-2,2) U27(-2,3) U29(-2,4) U31(-2,5) U32(-2.2,6) U34(-2.2,6.8) U35(-2.2,7.6) U37(-2.2,8.4) U38(-2.2,9.2) W4(-1.1,-9.2) W5(-1.1,-8.4) W7(-1.1,-7.6) W8(-1.1,-6.8) W10(-1.1,-6) W11(-1,-5) W13(-1,-4) W15(-1,-3) W17(-1,-2) W19(-1,-1) W21(-1,0) W23(-1,1) W25(-1,2) W27(-1,3) W29(-1,4) W31(-1,5) W32(-1.1,6) W34(-1.1,6.8) W35(-1.1,7.6) W37(-1.1,8.4) W38(-1.1,9.2)
  round 0.3 smd: A4(-10.95,-9.35) A5(-11.3,-8.8) A6(-10.95,-8.25) A7(-11.3,-7.7) A8(-10.95,-7.15) A9(-11.3,-6.6) A10(-10.95,-6.05) A11(-11.3,-5.5) A12(-10.95,-4.95) A13(-11.3,-4.4) A14(-10.95,-3.85) A15(-11.3,-3.3) A16(-10.95,-2.75) A17(-11.3,-2.2) A18(-10.95,-1.65) A19(-11.3,-1.1) A20(-10.95,-0.55) A21(-11.3,0) A22(-10.95,0.55) A23(-11.3,1.1) A24(-10.95,1.65) A25(-11.3,2.2) A26(-10.95,2.75) A27(-11.3,3.3) A28(-10.95,3.85) A29(-11.3,4.4) A30(-10.95,4.95) A31(-11.3,5.5) A32(-10.95,6.05) A33(-11.3,6.6) A34(-10.95,7.15) A35(-11.3,7.7) A36(-10.95,8.25) A37(-11.3,8.8) A38(-10.95,9.35) AA1(0,-11.3) AA2(0,-10.6) AA3(0,-9.9) AA39(0,9.9) AA40(0,10.6) AA41(0,11.3) AB1(0.55,-10.95) AB2(0.55,-10.25) AB40(0.55,10.25) AB41(0.55,10.95) AC1(1.1,-11.3) AC2(1.1,-10.6) AC3(1.1,-9.9) AC39(1.1,9.9) AC40(1.1,10.6) AC41(1.1,11.3) AD1(1.65,-10.95) AD2(1.65,-10.25) AD40(1.65,10.25) AD41(1.65,10.95) AE1(2.2,-11.3) AE2(2.2,-10.6) AE3(2.2,-9.9) AE39(2.2,9.9) AE40(2.2,10.6) AE41(2.2,11.3) AF1(2.75,-10.95) AF2(2.75,-10.25) AF40(2.75,10.25) AF41(2.75,10.95) AG1(3.3,-11.3) AG2(3.3,-10.6) AG3(3.3,-9.9) AG39(3.3,9.9) AG40(3.3,10.6) AG41(3.3,11.3) AH1(3.85,-10.95) AH2(3.85,-10.25) AH40(3.85,10.25) AH41(3.85,10.95) AJ1(4.4,-11.3) AJ2(4.4,-10.6) AJ3(4.4,-9.9) AJ39(4.4,9.9) AJ40(4.4,10.6) AJ41(4.4,11.3) AK1(4.95,-10.95) AK2(4.95,-10.25) AK40(4.95,10.25) AK41(4.95,10.95) AL1(5.5,-11.3) AL2(5.5,-10.6) AL3(5.5,-9.9) AL39(5.5,9.9) AL40(5.5,10.6) AL41(5.5,11.3) AM1(6.05,-10.95) AM2(6.05,-10.25) AM40(6.05,10.25) AM41(6.05,10.95) AN1(6.6,-11.3) AN2(6.6,-10.6) AN3(6.6,-9.9) AN39(6.6,9.9) AN40(6.6,10.6) AN41(6.6,11.3) AP1(7.15,-10.95) AP2(7.15,-10.25) AP40(7.15,10.25) AP41(7.15,10.95) AR1(7.7,-11.3) AR2(7.7,-10.6) AR3(7.7,-9.9) AR39(7.7,9.9) AR40(7.7,10.6) AR41(7.7,11.3) AT1(8.25,-10.95) AT2(8.25,-10.25) AT40(8.25,10.25) AT41(8.25,10.95) AU1(8.8,-11.3) AU2(8.8,-10.6) AU3(8.8,-9.9) AU39(8.8,9.9) AU40(8.8,10.6) AU41(8.8,11.3) AV1(9.35,-10.95) AV2(9.35,-10.25) AV40(9.35,10.25) AV41(9.35,10.95) AW2(9.9,-10.6) AW3(9.9,-9.9) AW5(9.9,-8.8) AW7(9.9,-7.7) AW9(9.9,-6.6) AW11(9.9,-5.5) AW13(9.9,-4.4) AW15(9.9,-3.3) AW17(9.9,-2.2) AW19(9.9,-1.1) AW21(9.9,0) AW23(9.9,1.1) AW25(9.9,2.2) AW27(9.9,3.3) AW29(9.9,4.4) AW31(9.9,5.5) AW33(9.9,6.6) AW35(9.9,7.7) AW37(9.9,8.8) AW39(9.9,9.9) AW40(9.9,10.6) AY3(10.6,-9.9) AY4(10.25,-9.35) AY5(10.6,-8.8) AY6(10.25,-8.25) AY7(10.6,-7.7) AY8(10.25,-7.15) AY9(10.6,-6.6) AY10(10.25,-6.05) AY11(10.6,-5.5) AY12(10.25,-4.95) AY13(10.6,-4.4) AY14(10.25,-3.85) AY15(10.6,-3.3) AY16(10.25,-2.75) AY17(10.6,-2.2) AY18(10.25,-1.65) AY19(10.6,-1.1) AY20(10.25,-0.55) AY21(10.6,0) AY22(10.25,0.55) AY23(10.6,1.1) AY24(10.25,1.65) AY25(10.6,2.2) AY26(10.25,2.75) AY27(10.6,3.3) AY28(10.25,3.85) AY29(10.6,4.4) AY30(10.25,4.95) AY31(10.6,5.5) AY32(10.25,6.05) AY33(10.6,6.6) AY34(10.25,7.15) AY35(10.6,7.7) AY36(10.25,8.25) AY37(10.6,8.8) AY38(10.25,9.35) AY39(10.6,9.9) B3(-10.6,-9.9) B4(-10.25,-9.35) B5(-10.6,-8.8) B6(-10.25,-8.25) B7(-10.6,-7.7) B8(-10.25,-7.15) B9(-10.6,-6.6) B10(-10.25,-6.05) B11(-10.6,-5.5) B12(-10.25,-4.95) B13(-10.6,-4.4) B14(-10.25,-3.85) B15(-10.6,-3.3) B16(-10.25,-2.75) B17(-10.6,-2.2) B18(-10.25,-1.65) B19(-10.6,-1.1) B20(-10.25,-0.55) B21(-10.6,0) B22(-10.25,0.55) B23(-10.6,1.1) B24(-10.25,1.65) B25(-10.6,2.2) B26(-10.25,2.75) B27(-10.6,3.3) B28(-10.25,3.85) B29(-10.6,4.4) B30(-10.25,4.95) B31(-10.6,5.5) B32(-10.25,6.05) B33(-10.6,6.6) B34(-10.25,7.15) B35(-10.6,7.7) B36(-10.25,8.25) B37(-10.6,8.8) B38(-10.25,9.35) B39(-10.6,9.9) BA4(10.95,-9.35) BA5(11.3,-8.8) BA6(10.95,-8.25) BA7(11.3,-7.7) BA8(10.95,-7.15) BA9(11.3,-6.6) BA10(10.95,-6.05) BA11(11.3,-5.5) BA12(10.95,-4.95) BA13(11.3,-4.4) BA14(10.95,-3.85) BA15(11.3,-3.3) BA16(10.95,-2.75) BA17(11.3,-2.2) BA18(10.95,-1.65) BA19(11.3,-1.1) BA20(10.95,-0.55) BA21(11.3,0) BA22(10.95,0.55) BA23(11.3,1.1) BA24(10.95,1.65) BA25(11.3,2.2) BA26(10.95,2.75) BA27(11.3,3.3) BA28(10.95,3.85) BA29(11.3,4.4) BA30(10.95,4.95) BA31(11.3,5.5) BA32(10.95,6.05) BA33(11.3,6.6) BA34(10.95,7.15) BA35(11.3,7.7) BA36(10.95,8.25) BA37(11.3,8.8) BA38(10.95,9.35) C2(-9.9,-10.6) C3(-9.9,-9.9) C5(-9.9,-8.8) C7(-9.9,-7.7) C9(-9.9,-6.6) C11(-9.9,-5.5) C13(-9.9,-4.4) C15(-9.9,-3.3) C17(-9.9,-2.2) C19(-9.9,-1.1) C21(-9.9,0) C23(-9.9,1.1) C25(-9.9,2.2) C27(-9.9,3.3) C29(-9.9,4.4) C31(-9.9,5.5) C33(-9.9,6.6) C35(-9.9,7.7) C37(-9.9,8.8) C39(-9.9,9.9) C40(-9.9,10.6) D1(-9.35,-10.95) D2(-9.35,-10.25) D40(-9.35,10.25) D41(-9.35,10.95) E1(-8.8,-11.3) E2(-8.8,-10.6) E3(-8.8,-9.9) E39(-8.8,9.9) E40(-8.8,10.6) E41(-8.8,11.3) F1(-8.25,-10.95) F2(-8.25,-10.25) F40(-8.25,10.25) F41(-8.25,10.95) G1(-7.7,-11.3) G2(-7.7,-10.6) G3(-7.7,-9.9) G39(-7.7,9.9) G40(-7.7,10.6) G41(-7.7,11.3) H1(-7.15,-10.95) H2(-7.15,-10.25) H40(-7.15,10.25) H41(-7.15,10.95) J1(-6.6,-11.3) J2(-6.6,-10.6) J3(-6.6,-9.9) J39(-6.6,9.9) J40(-6.6,10.6) J41(-6.6,11.3) K1(-6.05,-10.95) K2(-6.05,-10.25) K40(-6.05,10.25) K41(-6.05,10.95) L1(-5.5,-11.3) L2(-5.5,-10.6) L3(-5.5,-9.9) L39(-5.5,9.9) L40(-5.5,10.6) L41(-5.5,11.3) M1(-4.95,-10.95) M2(-4.95,-10.25) M40(-4.95,10.25) M41(-4.95,10.95) N1(-4.4,-11.3) N2(-4.4,-10.6) N3(-4.4,-9.9) N39(-4.4,9.9) N40(-4.4,10.6) N41(-4.4,11.3) P1(-3.85,-10.95) P2(-3.85,-10.25) P40(-3.85,10.25) P41(-3.85,10.95) R1(-3.3,-11.3) R2(-3.3,-10.6) R3(-3.3,-9.9) R39(-3.3,9.9) R40(-3.3,10.6) R41(-3.3,11.3) T1(-2.75,-10.95) T2(-2.75,-10.25) T40(-2.75,10.25) T41(-2.75,10.95) U1(-2.2,-11.3) U2(-2.2,-10.6) U3(-2.2,-9.9) U39(-2.2,9.9) U40(-2.2,10.6) U41(-2.2,11.3) V1(-1.65,-10.95) V2(-1.65,-10.25) V40(-1.65,10.25) V41(-1.65,10.95) W1(-1.1,-11.3) W2(-1.1,-10.6) W3(-1.1,-9.9) W39(-1.1,9.9) W40(-1.1,10.6) W41(-1.1,11.3) Y1(-0.55,-10.95) Y2(-0.55,-10.25) Y40(-0.55,10.25) Y41(-0.55,10.95)
BGA1140-AMD-FP5
  round 0.305 smd: A3(-16.3,-10.4) A5(-16.3,-9.5) A7(-16.3,-8) A8(-16.3,-7) A10(-16.3,-6) A11(-16.3,-5) A12(-16.3,-4) A13(-16.3,-3) A14(-16.3,-2) A15(-16.3,-1) A16(-16.3,0) A18(-16.3,1) A19(-16.3,2) A20(-16.3,3) A21(-16.3,4) A22(-16.3,5) A23(-16.3,6) A25(-16.3,7) A26(-16.3,8) A28(-16.3,9.5) A30(-16.3,10.4) AA1(-1,-11.3) AA2(-1.5,-10.9) AA3(-1,-10.5) AA4(-1.5,-10.1) AA5(-1,-9.4) AA13(-1.2,-2.8) AA14(-1.2,-2) AA15(-1.2,-1.2) AA16(-1.2,-0.4) AA17(-1.2,0.4) AA18(-1.2,1.2) AA19(-1.2,2) AA20(-1.2,2.8) AA28(-1,9.4) AA29(-1.5,10.1) AA30(-1,10.5) AA31(-1.5,10.9) AA32(-1,11.3) AB2(-0.5,-10.9) AB4(-0.5,-10.1) AB13(-0.4,-2.8) AB14(-0.4,-2) AB15(-0.4,-1.2) AB16(-0.4,-0.4) AB17(-0.4,0.4) AB18(-0.4,1.2) AB19(-0.4,2) AB20(-0.4,2.8) AB29(-0.5,10.1) AB31(-0.5,10.9) AC1(0,-11.3) AC2(0.5,-10.9) AC3(0,-10.5) AC4(0.5,-10.1) AC5(0,-9.4) AC13(0.4,-2.8) AC14(0.4,-2) AC15(0.4,-1.2) AC16(0.4,-0.4) AC17(0.4,0.4) AC18(0.4,1.2) AC19(0.4,2) AC20(0.4,2.8) AC28(0,9.4) AC29(0.5,10.1) AC30(0,10.5) AC31(0.5,10.9) AC32(0,11.3) AD1(1,-11.3) AD2(1.5,-10.9) AD3(1,-10.5) AD4(1.5,-10.1) AD5(1,-9.4) AD13(1.2,-2.8) AD14(1.2,-2) AD15(1.2,-1.2) AD16(1.2,-0.4) AD17(1.2,0.4) AD18(1.2,1.2) AD19(1.2,2) AD20(1.2,2.8) AD28(1,9.4) AD29(1.5,10.1) AD30(1,10.5) AD31(1.5,10.9) AD32(1,11.3) AE1(2,-11.3) AE3(2,-10.5) AE5(2,-9.4) AE13(2,-2.8) AE14(2,-2) AE15(2,-1.2) AE16(2,-0.4) AE17(2,0.4) AE18(2,1.2) AE19(2,2) AE20(2,2.8) AE28(2,9.4) AE30(2,10.5) AE32(2,11.3) AF1(3,-11.3) AF2(2.5,-10.9) AF3(3,-10.5) AF4(2.5,-10.1) AF5(3,-9.4) AF13(2.8,-2.8) AF14(2.8,-2) AF15(2.8,-1.2) AF16(2.8,-0.4) AF17(2.8,0.4) AF18(2.8,1.2) AF19(2.8,2) AF20(2.8,2.8) AF28(3,9.4) AF29(2.5,10.1) AF30(3,10.5) AF31(2.5,10.9) AF32(3,11.3) AG1(4,-11.3) AG2(3.5,-10.9) AG3(4,-10.5) AG4(3.5,-10.1) AG5(4,-9.4) AG13(3.6,-2.8) AG14(3.6,-2) AG15(3.6,-1.2) AG16(3.6,-0.4) AG17(3.6,0.4) AG18(3.6,1.2) AG19(3.6,2) AG20(3.6,2.8) AG28(4,9.4) AG29(3.5,10.1) AG30(4,10.5) AG31(3.5,10.9) AG32(4,11.3) AH2(4.5,-10.9) AH4(4.5,-10.1) AH13(4.4,-2.8) AH14(4.4,-2) AH15(4.4,-1.2) AH16(4.4,-0.4) AH17(4.4,0.4) AH18(4.4,1.2) AH19(4.4,2) AH20(4.4,2.8) AH29(4.5,10.1) AH31(4.5,10.9) AJ1(5,-11.3) AJ2(5.5,-10.9) AJ3(5,-10.5) AJ4(5.5,-10.1) AJ5(5,-9.4) AJ13(5.2,-2.8) AJ14(5.2,-2) AJ15(5.2,-1.2) AJ16(5.2,-0.4) AJ17(5.2,0.4) AJ18(5.2,1.2) AJ19(5.2,2) AJ20(5.2,2.8) AJ28(5,9.4) AJ29(5.5,10.1) AJ30(5,10.5) AJ31(5.5,10.9) AJ32(5,11.3) AK1(6,-11.3) AK3(6,-10.5) AK5(6,-9.4) AK13(6,-2.8) AK14(6,-2) AK15(6,-1.2) AK16(6,-0.4) AK17(6,0.4) AK18(6,1.2) AK19(6,2) AK20(6,2.8) AK28(6,9.4) AK30(6,10.5) AK32(6,11.3) AL1(7,-11.3) AL2(6.5,-10.9) AL3(7,-10.5) AL4(6.5,-10.1) AL5(7,-9.4) AL13(6.8,-2.8) AL14(6.8,-2) AL15(6.8,-1.2) AL16(6.8,-0.4) AL17(6.8,0.4) AL18(6.8,1.2) AL19(6.8,2) AL20(6.8,2.8) AL28(7,9.4) AL29(6.5,10.1) AL30(7,10.5) AL31(6.5,10.9) AL32(7,11.3) AM1(8,-11.3) AM2(7.5,-10.9) AM3(8,-10.5) AM4(7.5,-10.1) AM5(8,-9.4) AM13(7.6,-2.8) AM14(7.6,-2) AM15(7.6,-1.2) AM16(7.6,-0.4) AM17(7.6,0.4) AM18(7.6,1.2) AM19(7.6,2) AM20(7.6,2.8) AM28(8,9.4) AM29(7.5,10.1) AM30(8,10.5) AM31(7.5,10.9) AM32(8,11.3) AN1(9,-11.3) AN2(8.5,-10.9) AN3(9,-10.5) AN4(8.5,-10.1) AN5(9,-9.4) AN28(9,9.4) AN29(8.5,10.1) AN30(9,10.5) AN31(8.5,10.9) AN32(9,11.3) AP1(10,-11.3) AP2(9.5,-10.9) AP3(10,-10.5) AP4(9.5,-10.1) AP5(10,-9.4) AP28(10,9.4) AP29(9.5,10.1) AP30(10,10.5) AP31(9.5,10.9) AP32(10,11.3) AR1(11,-11.3) AR2(10.5,-10.9) AR3(11,-10.5) AR4(10.5,-10.1) AR5(11,-9.4) AR28(11,9.4) AR29(10.5,10.1) AR30(11,10.5) AR31(10.5,10.9) AR32(11,11.3) AT2(11.5,-10.9) AT4(11.5,-10.1) AT29(11.5,10.1) AT31(11.5,10.9) AU1(12,-11.3) AU2(12.5,-10.9) AU3(12,-10.5) AU4(12.5,-10.1) AU5(12,-9.4) AU28(12,9.4) AU29(12.5,10.1) AU30(12,10.5) AU31(12.5,10.9) AU32(12,11.3) AV1(13,-11.3) AV3(13,-10.5) AV5(13,-9.4) AV28(13,9.4) AV30(13,10.5) AV32(13,11.3) AW2(13.5,-10.9) AW3(14,-10.5) AW4(13.5,-10.1) AW5(14,-9.5) AW28(14,9.5) AW29(13.5,10.1) AW30(14,10.5) AW31(13.5,10.9) AY1(14.5,-11.3) AY4(14.5,-10.1) AY6(14.5,-9) AY7(14.4,-8) AY8(14.4,-7) AY10(14.4,-6) AY11(14.4,-5) AY12(14.4,-4) AY13(14.4,-3) AY14(14.4,-2) AY15(14.4,-1) AY16(14.4,0) AY18(14.4,1) AY19(14.4,2) AY20(14.4,3) AY21(14.4,4) AY22(14.4,5) AY23(14.4,6) AY25(14.4,7) AY26(14.4,8) AY27(14.5,9) AY29(14.5,10.1) AY32(14.5,11.3) B6(-15.9,-8.5) B8(-15.9,-7.5) B9(-15.9,-6.5) B10(-15.9,-5.5) B11(-15.9,-4.5) B12(-15.9,-3.5) B13(-15.9,-2.5) B15(-15.9,-1.5) B16(-15.9,-0.5) B17(-15.9,0.5) B18(-15.9,1.5) B20(-15.9,2.5) B21(-15.9,3.5) B22(-15.9,4.5) B23(-15.9,5.5) B24(-15.9,6.5) B25(-15.9,7.5) B27(-15.9,8.5) BA5(15.1,-9.5) BA6(15.1,-8.5) BA8(15.1,-7.5) BA9(15.1,-6.5) BA10(15.1,-5.5) BA11(15.1,-4.5) BA12(15.1,-3.5) BA13(15.1,-2.5) BA15(15.1,-1.5) BA16(15.1,-0.5) BA17(15.1,0.5) BA18(15.1,1.5) BA20(15.1,2.5) BA21(15.1,3.5) BA22(15.1,4.5) BA23(15.1,5.5) BA24(15.1,6.5) BA25(15.1,7.5) BA27(15.1,8.5) BA28(15.1,9.5) BB1(15.4,-11.3) BB3(15.4,-10.4) BB6(15.5,-9) BB7(15.5,-8) BB8(15.5,-7) BB10(15.5,-6) BB11(15.5,-5) BB12(15.5,-4) BB13(15.5,-3) BB14(15.5,-2) BB15(15.5,-1) BB16(15.5,0) BB18(15.5,1) BB19(15.5,2) BB20(15.5,3) BB21(15.5,4) BB22(15.5,5) BB23(15.5,6) BB25(15.5,7) BB26(15.5,8) BB27(15.5,9) BB30(15.4,10.4) BB32(15.4,11.3) BC6(15.9,-8.5) BC8(15.9,-7.5) BC9(15.9,-6.5) BC10(15.9,-5.5) BC11(15.9,-4.5) BC12(15.9,-3.5) BC13(15.9,-2.5) BC15(15.9,-1.5) BC16(15.9,-0.5) BC17(15.9,0.5) BC18(15.9,1.5) BC20(15.9,2.5) BC21(15.9,3.5) BC22(15.9,4.5) BC23(15.9,5.5) BC24(15.9,6.5) BC25(15.9,7.5) BC27(15.9,8.5) BD3(16.3,-10.4) BD5(16.3,-9.5) BD7(16.3,-8) BD8(16.3,-7) BD10(16.3,-6) BD11(16.3,-5) BD12(16.3,-4) BD13(16.3,-3) BD14(16.3,-2) BD15(16.3,-1) BD16(16.3,0) BD18(16.3,1) BD19(16.3,2) BD20(16.3,3) BD21(16.3,4) BD22(16.3,5) BD23(16.3,6) BD25(16.3,7) BD26(16.3,8) BD28(16.3,9.5) BD30(16.3,10.4) C1(-15.4,-11.3) C3(-15.4,-10.4) C6(-15.5,-9) C7(-15.5,-8) C8(-15.5,-7) C10(-15.5,-6) C11(-15.5,-5) C12(-15.5,-4) C13(-15.5,-3) C14(-15.5,-2) C15(-15.5,-1) C16(-15.5,0) C18(-15.5,1) C19(-15.5,2) C20(-15.5,3) C21(-15.5,4) C22(-15.5,5) C23(-15.5,6) C25(-15.5,7) C26(-15.5,8) C27(-15.5,9) C30(-15.4,10.4) C32(-15.4,11.3) D5(-15.1,-9.5) D6(-15.1,-8.5) D8(-15.1,-7.5) D9(-15.1,-6.5) D10(-15.1,-5.5) D11(-15.1,-4.5) D12(-15.1,-3.5) D13(-15.1,-2.5) D15(-15.1,-1.5) D16(-15.1,-0.5) D17(-15.1,0.5) D18(-15.1,1.5) D20(-15.1,2.5) D21(-15.1,3.5) D22(-15.1,4.5) D23(-15.1,5.5) D24(-15.1,6.5) D25(-15.1,7.5) D27(-15.1,8.5) D28(-15.1,9.5) E1(-14.5,-11.3) E4(-14.5,-10.1) E6(-14.5,-9) E7(-14.4,-8) E8(-14.4,-7) E10(-14.4,-6) E11(-14.4,-5) E12(-14.4,-4) E13(-14.4,-3) E14(-14.4,-2) E15(-14.4,-1) E16(-14.4,0) E18(-14.4,1) E19(-14.4,2) E20(-14.4,3) E21(-14.4,4) E22(-14.4,5) E23(-14.4,6) E25(-14.4,7) E26(-14.4,8) E27(-14.5,9) E29(-14.5,10.1) E32(-14.5,11.3) F2(-13.5,-10.9) F3(-14,-10.5) F4(-13.5,-10.1) F5(-14,-9.5) F28(-14,9.5) F29(-13.5,10.1) F30(-14,10.5) F31(-13.5,10.9) G1(-13,-11.3) G3(-13,-10.5) G5(-13,-9.4) G28(-13,9.4) G30(-13,10.5) G32(-13,11.3) H1(-12,-11.3) H2(-12.5,-10.9) H3(-12,-10.5) H4(-12.5,-10.1) H5(-12,-9.4) H28(-12,9.4) H29(-12.5,10.1) H30(-12,10.5) H31(-12.5,10.9) H32(-12,11.3) J2(-11.5,-10.9) J4(-11.5,-10.1) J29(-11.5,10.1) J31(-11.5,10.9) K1(-11,-11.3) K2(-10.5,-10.9) K3(-11,-10.5) K4(-10.5,-10.1) K5(-11,-9.4) K28(-11,9.4) K29(-10.5,10.1) K30(-11,10.5) K31(-10.5,10.9) K32(-11,11.3) L1(-10,-11.3) L2(-9.5,-10.9) L3(-10,-10.5) L4(-9.5,-10.1) L5(-10,-9.4) L28(-10,9.4) L29(-9.5,10.1) L30(-10,10.5) L31(-9.5,10.9) L32(-10,11.3) M1(-9,-11.3) M2(-8.5,-10.9) M3(-9,-10.5) M4(-8.5,-10.1) M5(-9,-9.4) M28(-9,9.4) M29(-8.5,10.1) M30(-9,10.5) M31(-8.5,10.9) M32(-9,11.3) N1(-8,-11.3) N2(-7.5,-10.9) N3(-8,-10.5) N4(-7.5,-10.1) N5(-8,-9.4) N13(-7.6,-2.8) N14(-7.6,-2) N15(-7.6,-1.2) N16(-7.6,-0.4) N17(-7.6,0.4) N18(-7.6,1.2) N19(-7.6,2) N20(-7.6,2.8) N28(-8,9.4) N29(-7.5,10.1) N30(-8,10.5) N31(-7.5,10.9) N32(-8,11.3) P1(-7,-11.3) P2(-6.5,-10.9) P3(-7,-10.5) P4(-6.5,-10.1) P5(-7,-9.4) P13(-6.8,-2.8) P14(-6.8,-2) P15(-6.8,-1.2) P16(-6.8,-0.4) P17(-6.8,0.4) P18(-6.8,1.2) P19(-6.8,2) P20(-6.8,2.8) P28(-7,9.4) P29(-6.5,10.1) P30(-7,10.5) P31(-6.5,10.9) P32(-7,11.3) R1(-6,-11.3) R3(-6,-10.5) R5(-6,-9.4) R13(-6,-2.8) R14(-6,-2) R15(-6,-1.2) R16(-6,-0.4) R17(-6,0.4) R18(-6,1.2) R19(-6,2) R20(-6,2.8) R28(-6,9.4) R30(-6,10.5) R32(-6,11.3) T1(-5,-11.3) T2(-5.5,-10.9) T3(-5,-10.5) T4(-5.5,-10.1) T5(-5,-9.4) T13(-5.2,-2.8) T14(-5.2,-2) T15(-5.2,-1.2) T16(-5.2,-0.4) T17(-5.2,0.4) T18(-5.2,1.2) T19(-5.2,2) T20(-5.2,2.8) T28(-5,9.4) T29(-5.5,10.1) T30(-5,10.5) T31(-5.5,10.9) T32(-5,11.3) U2(-4.5,-10.9) U4(-4.5,-10.1) U13(-4.4,-2.8) U14(-4.4,-2) U15(-4.4,-1.2) U16(-4.4,-0.4) U17(-4.4,0.4) U18(-4.4,1.2) U19(-4.4,2) U20(-4.4,2.8) U29(-4.5,10.1) U31(-4.5,10.9) V1(-4,-11.3) V2(-3.5,-10.9) V3(-4,-10.5) V4(-3.5,-10.1) V5(-4,-9.4) V13(-3.6,-2.8) V14(-3.6,-2) V15(-3.6,-1.2) V16(-3.6,-0.4) V17(-3.6,0.4) V18(-3.6,1.2) V19(-3.6,2) V20(-3.6,2.8) V28(-4,9.4) V29(-3.5,10.1) V30(-4,10.5) V31(-3.5,10.9) V32(-4,11.3) W1(-3,-11.3) W2(-2.5,-10.9) W3(-3,-10.5) W4(-2.5,-10.1) W5(-3,-9.4) W13(-2.8,-2.8) W14(-2.8,-2) W15(-2.8,-1.2) W16(-2.8,-0.4) W17(-2.8,0.4) W18(-2.8,1.2) W19(-2.8,2) W20(-2.8,2.8) W28(-3,9.4) W29(-2.5,10.1) W30(-3,10.5) W31(-2.5,10.9) W32(-3,11.3) Y1(-2,-11.3) Y3(-2,-10.5) Y5(-2,-9.4) Y13(-2,-2.8) Y14(-2,-2) Y15(-2,-1.2) Y16(-2,-0.4) Y17(-2,0.4) Y18(-2,1.2) Y19(-2,2) Y20(-2,2.8) Y28(-2,9.4) Y30(-2,10.5) Y32(-2,11.3)
  round 0.406 smd: AA6(-1,-8.7) AA7(-1,-8) AA8(-1,-7.2) AA9(-1,-6.4) AA10(-1,-5.6) AA11(-1,-4.8) AA12(-1,-4) AA21(-1,4) AA22(-1,4.8) AA23(-1,5.6) AA24(-1,6.4) AA25(-1,7.2) AA26(-1,8) AA27(-1,8.7) AC6(0,-8.7) AC7(0,-8) AC8(0,-7.2) AC9(0,-6.4) AC10(0,-5.6) AC11(0,-4.8) AC12(0,-4) AC21(0,4) AC22(0,4.8) AC23(0,5.6) AC24(0,6.4) AC25(0,7.2) AC26(0,8) AC27(0,8.7) AD6(1,-8.7) AD7(1,-8) AD8(1,-7.2) AD9(1,-6.4) AD10(1,-5.6) AD11(1,-4.8) AD12(1,-4) AD21(1,4) AD22(1,4.8) AD23(1,5.6) AD24(1,6.4) AD25(1,7.2) AD26(1,8) AD27(1,8.7) AE6(2,-8.7) AE7(2,-8) AE8(2,-7.2) AE9(2,-6.4) AE10(2,-5.6) AE11(2,-4.8) AE12(2,-4) AE21(2,4) AE22(2,4.8) AE23(2,5.6) AE24(2,6.4) AE25(2,7.2) AE26(2,8) AE27(2,8.7) AF6(3,-8.7) AF7(3,-8) AF8(3,-7.2) AF9(3,-6.4) AF10(3,-5.6) AF11(3,-4.8) AF12(3,-4) AF21(3,4) AF22(3,4.8) AF23(3,5.6) AF24(3,6.4) AF25(3,7.2) AF26(3,8) AF27(3,8.7) AG6(4,-8.7) AG7(4,-8) AG8(4,-7.2) AG9(4,-6.4) AG10(4,-5.6) AG11(4,-4.8) AG12(4,-4) AG21(4,4) AG22(4,4.8) AG23(4,5.6) AG24(4,6.4) AG25(4,7.2) AG26(4,8) AG27(4,8.7) AJ6(5,-8.7) AJ7(5,-8) AJ8(5,-7.2) AJ9(5,-6.4) AJ10(5,-5.6) AJ11(5,-4.8) AJ12(5,-4) AJ21(5,4) AJ22(5,4.8) AJ23(5,5.6) AJ24(5,6.4) AJ25(5,7.2) AJ26(5,8) AJ27(5,8.7) AK6(6,-8.7) AK7(6,-8) AK8(6,-7.2) AK9(6,-6.4) AK10(6,-5.6) AK11(6,-4.8) AK12(6,-4) AK21(6,4) AK22(6,4.8) AK23(6,5.6) AK24(6,6.4) AK25(6,7.2) AK26(6,8) AK27(6,8.7) AL6(7,-8.7) AL7(7,-8) AL8(7,-7.2) AL9(7,-6.4) AL10(7,-5.6) AL11(7,-4.8) AL12(7,-4) AL21(7,4) AL22(7,4.8) AL23(7,5.6) AL24(7,6.4) AL25(7,7.2) AL26(7,8) AL27(7,8.7) AM6(8,-8.7) AM7(8,-8) AM8(8,-7.2) AM9(8,-6.4) AM10(8,-5.6) AM11(8,-4.8) AM12(8,-4) AM21(8,4) AM22(8,4.8) AM23(8,5.6) AM24(8,6.4) AM25(8,7.2) AM26(8,8) AM27(8,8.7) AN6(9,-8.7) AN7(9,-8) AN8(9,-7.2) AN9(9,-6.4) AN10(9,-5.6) AN11(9,-4.8) AN12(9,-4) AN13(9,-3) AN14(9,-2) AN15(9,-1) AN16(9,0) AN18(9,1) AN19(9,2) AN20(9,3) AN21(9,4) AN22(9,4.8) AN23(9,5.6) AN24(9,6.4) AN25(9,7.2) AN26(9,8) AN27(9,8.7) AP6(10,-8.7) AP7(10,-8) AP8(10,-7.2) AP9(10,-6.4) AP10(10,-5.6) AP12(9.8,-4) AP13(9.8,-3) AP14(9.8,-2) AP15(9.8,-1) AP16(9.8,0) AP18(9.8,1) AP19(9.8,2) AP20(9.8,3) AP21(9.8,4) AP23(10,5.6) AP24(10,6.4) AP25(10,7.2) AP26(10,8) AP27(10,8.7) AR6(11,-8.7) AR7(11,-8) AR8(11,-7.2) AR11(10.6,-5) AR12(10.6,-4) AR13(10.6,-3) AR14(10.6,-2) AR15(10.6,-1) AR16(10.6,0) AR18(10.6,1) AR19(10.6,2) AR20(10.6,3) AR21(10.6,4) AR22(10.6,5) AR25(11,7.2) AR26(11,8) AR27(11,8.7) AT10(11.1,-6.1) AT11(11.4,-5) AT12(11.4,-4) AT13(11.4,-3) AT14(11.4,-2) AT15(11.4,-1) AT16(11.4,0) AT18(11.4,1) AT19(11.4,2) AT20(11.4,3) AT21(11.4,4) AT22(11.4,5) AT23(11.1,6.1) AU6(12,-8.7) AU7(12,-8) AU8(12,-7) AU10(12.2,-6) AU11(12.2,-5) AU12(12.2,-4) AU13(12.2,-3) AU14(12.2,-2) AU15(12.2,-1) AU16(12.2,0) AU18(12.2,1) AU19(12.2,2) AU20(12.2,3) AU21(12.2,4) AU22(12.2,5) AU23(12.2,6) AU25(12,7) AU26(12,8) AU27(12,8.7) AV6(13,-8.7) AV7(13,-8) AV8(13,-7) AV10(13,-6) AV11(13,-5) AV12(13,-4) AV13(13,-3) AV14(13,-2) AV15(13,-1) AV16(13,0) AV18(13,1) AV19(13,2) AV20(13,3) AV21(13,4) AV22(13,5) AV23(13,6) AV25(13,7) AV26(13,8) AV27(13,8.7) AW7(13.7,-8) AW8(13.7,-7) AW10(13.7,-6) AW11(13.7,-5) AW12(13.7,-4) AW13(13.7,-3) AW14(13.7,-2) AW15(13.7,-1) AW16(13.7,0) AW18(13.7,1) AW19(13.7,2) AW20(13.7,3) AW21(13.7,4) AW22(13.7,5) AW23(13.7,6) AW25(13.7,7) AW26(13.7,8) F7(-13.7,-8) F8(-13.7,-7) F10(-13.7,-6) F11(-13.7,-5) F12(-13.7,-4) F13(-13.7,-3) F14(-13.7,-2) F15(-13.7,-1) F16(-13.7,0) F18(-13.7,1) F19(-13.7,2) F20(-13.7,3) F21(-13.7,4) F22(-13.7,5) F23(-13.7,6) F25(-13.7,7) F26(-13.7,8) G6(-13,-8.7) G7(-13,-8) G8(-13,-7) G10(-13,-6) G11(-13,-5) G12(-13,-4) G13(-13,-3) G14(-13,-2) G15(-13,-1) G16(-13,0) G18(-13,1) G19(-13,2) G20(-13,3) G21(-13,4) G22(-13,5) G23(-13,6) G25(-13,7) G26(-13,8) G27(-13,8.7) H6(-12,-8.7) H7(-12,-8) H8(-12,-7) H10(-12.2,-6) H11(-12.2,-5) H12(-12.2,-4) H13(-12.2,-3) H14(-12.2,-2) H15(-12.2,-1) H16(-12.2,0) H18(-12.2,1) H19(-12.2,2) H20(-12.2,3) H21(-12.2,4) H22(-12.2,5) H23(-12.2,6) H25(-12,7) H26(-12,8) H27(-12,8.7) J10(-11.1,-6.1) J11(-11.4,-5) J12(-11.4,-4) J13(-11.4,-3) J14(-11.4,-2) J15(-11.4,-1) J16(-11.4,0) J18(-11.4,1) J19(-11.4,2) J20(-11.4,3) J21(-11.4,4) J22(-11.4,5) J23(-11.1,6.1) K6(-11,-8.7) K7(-11,-8) K8(-11,-7.2) K11(-10.6,-5) K12(-10.6,-4) K13(-10.6,-3) K14(-10.6,-2) K15(-10.6,-1) K16(-10.6,0) K18(-10.6,1) K19(-10.6,2) K20(-10.6,3) K21(-10.6,4) K22(-10.6,5) K25(-11,7.2) K26(-11,8) K27(-11,8.7) L6(-10,-8.7) L7(-10,-8) L8(-10,-7.2) L9(-10,-6.4) L10(-10,-5.6) L12(-9.8,-4) L13(-9.8,-3) L14(-9.8,-2) L15(-9.8,-1) L16(-9.8,0) L18(-9.8,1) L19(-9.8,2) L20(-9.8,3) L21(-9.8,4) L23(-10,5.6) L24(-10,6.4) L25(-10,7.2) L26(-10,8) L27(-10,8.7) M6(-9,-8.7) M7(-9,-8) M8(-9,-7.2) M9(-9,-6.4) M10(-9,-5.6) M11(-9,-4.8) M12(-9,-4) M13(-9,-3) M14(-9,-2) M15(-9,-1) M16(-9,0) M18(-9,1) M19(-9,2) M20(-9,3) M21(-9,4) M22(-9,4.8) M23(-9,5.6) M24(-9,6.4) M25(-9,7.2) M26(-9,8) M27(-9,8.7) N6(-8,-8.7) N7(-8,-8) N8(-8,-7.2) N9(-8,-6.4) N10(-8,-5.6) N11(-8,-4.8) N12(-8,-4) N21(-8,4) N22(-8,4.8) N23(-8,5.6) N24(-8,6.4) N25(-8,7.2) N26(-8,8) N27(-8,8.7) P6(-7,-8.7) P7(-7,-8) P8(-7,-7.2) P9(-7,-6.4) P10(-7,-5.6) P11(-7,-4.8) P12(-7,-4) P21(-7,4) P22(-7,4.8) P23(-7,5.6) P24(-7,6.4) P25(-7,7.2) P26(-7,8) P27(-7,8.7) R6(-6,-8.7) R7(-6,-8) R8(-6,-7.2) R9(-6,-6.4) R10(-6,-5.6) R11(-6,-4.8) R12(-6,-4) R21(-6,4) R22(-6,4.8) R23(-6,5.6) R24(-6,6.4) R25(-6,7.2) R26(-6,8) R27(-6,8.7) T6(-5,-8.7) T7(-5,-8) T8(-5,-7.2) T9(-5,-6.4) T10(-5,-5.6) T11(-5,-4.8) T12(-5,-4) T21(-5,4) T22(-5,4.8) T23(-5,5.6) T24(-5,6.4) T25(-5,7.2) T26(-5,8) T27(-5,8.7) V6(-4,-8.7) V7(-4,-8) V8(-4,-7.2) V9(-4,-6.4) V10(-4,-5.6) V11(-4,-4.8) V12(-4,-4) V21(-4,4) V22(-4,4.8) V23(-4,5.6) V24(-4,6.4) V25(-4,7.2) V26(-4,8) V27(-4,8.7) W6(-3,-8.7) W7(-3,-8) W8(-3,-7.2) W9(-3,-6.4) W10(-3,-5.6) W11(-3,-4.8) W12(-3,-4) W21(-3,4) W22(-3,4.8) W23(-3,5.6) W24(-3,6.4) W25(-3,7.2) W26(-3,8) W27(-3,8.7) Y6(-2,-8.7) Y7(-2,-8) Y8(-2,-7.2) Y9(-2,-6.4) Y10(-2,-5.6) Y11(-2,-4.8) Y12(-2,-4) Y21(-2,4) Y22(-2,4.8) Y23(-2,5.6) Y24(-2,6.4) Y25(-2,7.2) Y26(-2,8) Y27(-2,8.7)
C0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
C0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0402_2
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
C0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
C1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
C1808
  rect 1.041x2.311 smd: 1(-2.175,0) 2(2.175,0)
C3528
  rect 1.6x2.591 smd: 1(1.5,0) 2(-1.5,0)
CC7343
  rect 2.413x2.819 smd: 1(-3.2,0) 2(3.2,0)
CF34302D0RA-05-NH-30P-L
  rect 0.305x1.295 smd: 1(-7.25,5.65) 2(-6.75,5.65) 3(-6.25,5.65) 4(-5.75,5.65) 5(-5.25,5.65) 6(-4.75,5.65) 7(-4.25,5.65) 8(-3.75,5.65) 9(-3.25,5.65) 10(-2.75,5.65) 11(-2.25,5.65) 12(-1.75,5.65) 13(-1.25,5.65) 14(-0.75,5.65) 15(-0.25,5.65) 16(0.25,5.65) 17(0.75,5.65) 18(1.25,5.65) 19(1.75,5.65) 20(2.25,5.65) 21(2.75,5.65) 22(3.25,5.65) 23(3.75,5.65) 24(4.25,5.65) 25(4.75,5.65) 26(5.25,5.65) 27(5.75,5.65) 28(6.25,5.65) 29(6.75,5.65) 30(7.25,5.65)
  rect 1.803x2.21 smd: 31(-9.4,0) 32(9.4,0)
D-0_6X0_3-0_32H-SMT
  custom 0.051x0.051 smd: 1(-0.242,0) 2(0.242,0)
D-1_2X0_8-0_7H
  rect 0.61x0.787 smd: 1(-0.85,0) 2(0.85,0)
D-1_85X1_25-2P-0_95H
  rect 0.787x0.889 smd: 1(-1.07,0) 2(1.07,0)
D-3_8X2_5
  rect 1.6x1.905 smd: 1(-2.15,0) 2(2.15,0)
D-SOD323-1_7X1_3-B0530WS
  rect 0.584x0.457 smd: 1(-1.055,0) 2(1.055,0)
D-SOD323-1_7X1_25-PMEG4005AEA
  rect 0.61x0.61 smd: 1(-1.1,0) 2(1.1,0)
D-SOD323-1_85X1_25-0_95H
  rect 0.559x0.813 smd: 1(-1.15,0) 2(1.15,0)
DCJK-30706-00042-001-3P-SMT
  oval 1.6x2.489 hole 0.991x1.905: 1(0,8.15)
  oval 1.092x2.108 hole 0.508x1.499: 2(2.15,7.5) 3(-2.15,7.5)
  oval 1.194x3.607 hole 0.508x2.997: 4(-4.25,0) 5(4.25,0)
DDR4-D4AS0-26001-1P40-STD-SMT
  round 1.6 hole 1.6 unplated: (-34.4,0)
  round 1.092 hole 1.092 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 3.505x4.597 smd: 261(-33.8,12) 262(33.8,12)
DFN6-1_4X1_2-4
  rect 0.508x0.203 smd: 1(0.5,-0.4) 2(0.5,0) 3(0.5,0.4) 4(-0.5,0.4) 5(-0.5,0) 6(-0.5,-0.4)
DFN8-2X2-5-9P-MAX8902B
  rect 0.305x0.889 smd: 1(-0.75,-1.15) 2(-0.25,-1.15) 3(0.25,-1.15) 4(0.75,-1.15) 5(0.75,1.15) 6(0.25,1.15) 7(-0.25,1.15) 8(-0.75,1.15)
  rect 1.295x0.711 smd: 9(0,0)
DFN10-4_1X2-8-11P
  rect 0.203x0.61 smd: 1(-1.8,-0.9) 2(-1,-0.9) 3(-0.2,-0.9) 4(0.6,-0.9) 5(1.4,-0.9) 6(1.8,0.9) 7(1,0.9) 8(0.2,0.9) 9(-0.6,0.9) 10(-1.4,0.9)
  rect 1.397x0.787 smd: 11(-0.4,0)
DFN14-3X2-4-11P-0_8H
  custom 0.125x0.125 smd: 1(-1.2,-0.9) 6(0.8,-0.9) 8(1.2,0.9) 13(-0.8,0.9)
  rect 0.203x0.508 smd: 3(-0.4,-0.9) 4(0,-0.9) 5(0.4,-0.9) 10(0.4,0.9) 11(0,0.9) 12(-0.4,0.9)
  rect 2.591x0.889 smd: 15(0,0)
ESD-1X0_6-2P
  rect 0.559x0.61 smd: 1(-0.425,0) 2(0.425,0)
H-C75D75N
  round 1.905 hole 1.905 unplated: (0,0)
H-DAVIDOFF-1
  round 5.994 hole 3.2: 1(0,0)
H-DAVIDOFF-1-1
  custom 2.15x2.15 hole 3.2: 1(0,0)
  round 0.61 hole 0.356: 2(0,2.921) 3(2.066,2.066) 4(2.921,0) 5(2.066,-2.066) 6(0,-2.921) 7(-2.066,-2.066) 8(-2.921,0) 9(-2.066,2.066)
H-S157D157N
  rect 3.988x3.988 hole 3.988 unplated: (0,0)
H-TC154IC154BC237D154PT-1
  round 3.912 hole 3.912: 1(0,0)
HDMI-10591-19001-19P
  round 0.813 hole 0.559: 1(-4.5,6.65) 2(-4,8.2) 3(-3.5,6.65) 4(-3,8.2) 5(-2.5,6.65) 6(-2,8.2) 7(-1.5,6.65) 8(-1,8.2) 9(-0.5,6.65) 10(0,8.2) 11(0.5,6.65) 12(1,8.2) 13(1.5,6.65) 14(2,8.2) 15(2.5,6.65) 16(3,8.2) 17(3.5,6.65) 18(4,8.2) 19(4.5,6.65)
  oval 1.803x2.794 hole 0.787x1.803: 20(-9.25,0) 22(9.25,0)
  oval 1.803x3.607 hole 0.787x2.591: 21(-7.25,7.6) 23(7.25,7.6)
HG-C276D126P2
  round 7.01 hole 3.2: 1(0,0)
  round 0.61 hole 0.356: 2(2.235,0) 3(1.581,1.581) 4(0,2.235) 5(-1.581,1.581) 6(-2.235,0) 7(-1.581,-1.581) 8(0,-2.235) 9(1.581,-1.581)
HG-C354I158D118P2
  round 8.992 hole 2.997: 1(0,0)
  round 0.61 hole 0.356: 2(0,3.048) 3(2.155,2.155) 4(3.048,0) 5(2.155,-2.155) 6(0,-3.048) 7(-2.155,-2.155) 8(-3.048,0) 9(-2.155,2.155)
HG-O335X315D252X232P2
  oval 8.509x8.001 hole 6.401x5.893: 1(0,0)
  round 0.61 hole 0.356: 2(0,3.556) 3(2.514,2.514) 4(3.683,0) 5(2.514,-2.514) 6(0,-3.556) 7(-2.514,-2.514) 8(-3.683,0) 9(-2.514,2.514)
HG-Z8E-EDADOC-1
  round 3.2 hole 3.2: 1(0,0)
  round 0.61 hole 0.356: 2(1.58,1.58) 3(0,2.235) 4(-1.58,1.58) 5(-2.235,0) 6(-1.58,-1.58) 7(0,-2.235) 8(1.58,-1.58) 9(2.235,0)
  custom 2.25x2.25 hole 2.515: 10(-6.37,0)
HG-Z8E-EDADOC-3
  custom 2x2 hole 5.613: 1(0,0)
JOPEN25X30_S
  custom 0.159x0.159 smd: 1(-0.368,0) 2(0.368,0)
L2_5X2-1_2
  rect 0.787x2.007 smd: 1(-1,0) 2(1,0)
L2_5X2-1_2H
  rect 0.889x2.108 smd: 1(-0.85,0) 2(0.85,0)
L6_6X6_6-2_8H
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
LGA16-3X3-5
  rect 0.305x0.94 smd: 1(-1,-1.525) 2(-0.5,-1.525) 3(0,-1.525) 4(0.5,-1.525) 5(1,-1.525) 9(1,1.525) 10(0.5,1.525) 11(0,1.525) 12(-0.5,1.525) 13(-1,1.525)
  rect 0.94x0.305 smd: 6(1.525,-0.5) 7(1.525,0) 8(1.525,0.5) 14(-1.525,0.5) 15(-1.525,0) 16(-1.525,-0.5)
LQFP128-16X16-4-1_6H
  rect 0.203x1.499 smd: 1(-6.2,-7.85) 2(-5.8,-7.85) 3(-5.4,-7.85) 4(-5,-7.85) 5(-4.6,-7.85) 6(-4.2,-7.85) 7(-3.8,-7.85) 8(-3.4,-7.85) 9(-3,-7.85) 10(-2.6,-7.85) 11(-2.2,-7.85) 12(-1.8,-7.85) 13(-1.4,-7.85) 14(-1,-7.85) 15(-0.6,-7.85) 16(-0.2,-7.85) 17(0.2,-7.85) 18(0.6,-7.85) 19(1,-7.85) 20(1.4,-7.85) 21(1.8,-7.85) 22(2.2,-7.85) 23(2.6,-7.85) 24(3,-7.85) 25(3.4,-7.85) 26(3.8,-7.85) 27(4.2,-7.85) 28(4.6,-7.85) 29(5,-7.85) 30(5.4,-7.85) 31(5.8,-7.85) 32(6.2,-7.85) 65(6.2,7.85) 66(5.8,7.85) 67(5.4,7.85) 68(5,7.85) 69(4.6,7.85) 70(4.2,7.85) 71(3.8,7.85) 72(3.4,7.85) 73(3,7.85) 74(2.6,7.85) 75(2.2,7.85) 76(1.8,7.85) 77(1.4,7.85) 78(1,7.85) 79(0.6,7.85) 80(0.2,7.85) 81(-0.2,7.85) 82(-0.6,7.85) 83(-1,7.85) 84(-1.4,7.85) 85(-1.8,7.85) 86(-2.2,7.85) 87(-2.6,7.85) 88(-3,7.85) 89(-3.4,7.85) 90(-3.8,7.85) 91(-4.2,7.85) 92(-4.6,7.85) 93(-5,7.85) 94(-5.4,7.85) 95(-5.8,7.85) 96(-6.2,7.85)
  rect 1.499x0.203 smd: 33(7.85,-6.2) 34(7.85,-5.8) 35(7.85,-5.4) 36(7.85,-5) 37(7.85,-4.6) 38(7.85,-4.2) 39(7.85,-3.8) 40(7.85,-3.4) 41(7.85,-3) 42(7.85,-2.6) 43(7.85,-2.2) 44(7.85,-1.8) 45(7.85,-1.4) 46(7.85,-1) 47(7.85,-0.6) 48(7.85,-0.2) 49(7.85,0.2) 50(7.85,0.6) 51(7.85,1) 52(7.85,1.4) 53(7.85,1.8) 54(7.85,2.2) 55(7.85,2.6) 56(7.85,3) 57(7.85,3.4) 58(7.85,3.8) 59(7.85,4.2) 60(7.85,4.6) 61(7.85,5) 62(7.85,5.4) 63(7.85,5.8) 64(7.85,6.2) 97(-7.85,6.2) 98(-7.85,5.8) 99(-7.85,5.4) 100(-7.85,5) 101(-7.85,4.6) 102(-7.85,4.2) 103(-7.85,3.8) 104(-7.85,3.4) 105(-7.85,3) 106(-7.85,2.6) 107(-7.85,2.2) 108(-7.85,1.8) 109(-7.85,1.4) 110(-7.85,1) 111(-7.85,0.6) 112(-7.85,0.2) 113(-7.85,-0.2) 114(-7.85,-0.6) 115(-7.85,-1) 116(-7.85,-1.4) 117(-7.85,-1.8) 118(-7.85,-2.2) 119(-7.85,-2.6) 120(-7.85,-3) 121(-7.85,-3.4) 122(-7.85,-3.8) 123(-7.85,-4.2) 124(-7.85,-4.6) 125(-7.85,-5) 126(-7.85,-5.4) 127(-7.85,-5.8) 128(-7.85,-6.2)
MSOP8-4_9-65-G547
  rect 0.356x1.397 smd: 1(-0.975,-2.5) 2(-0.325,-2.5) 3(0.325,-2.5) 4(0.975,-2.5) 5(0.975,2.5) 6(0.325,2.5) 7(-0.325,2.5) 8(-0.975,2.5)
NGFF-NASE0-S6701-TS40-KE-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
