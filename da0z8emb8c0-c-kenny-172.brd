# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_A5: length 36.8
  IN1 w0.14: v1(54.8,63.57) 55.35,64.12 59.5,64.12 61.17,62.44 65.2,62.44 68.01,59.64 79.06,59.64 80.57,58.13 82.23,58.13 v1(82.89,57.46)
  BOTTOM w0.165: v1(54.8,63.57) 53.63,64.73 52.61,64.73 52.39,64.96 CN2019.126 ; U2030.AC26 82.89,57.39 v1(82.89,57.46)
M_A_A6: length 39.6
  IN1 w0.14: v1(55.43,65.41) 55.92,65.9 59.37,65.9 61.72,63.55 70.61,63.55 72.81,61.35 78.91,61.35 79.81,60.44 82.45,60.44 83.22,59.68 83.22,59.31 83.49,59.04 83.88,59.04 84.06,58.86 84.06,58.3 84.31,58.05 84.64,58.05 84.95,57.75 84.95,57.34 85.28,57.01 85.61,57.01 v1(86.07,56.55)
  BOTTOM w0.165: CN2019.127 55.99,64.71 55.43,65.26 v1(55.43,65.41) ; U2030.AD21 86.07,56.45 v1(86.07,56.55)
M_A_A7: length 36.3
  IN1 w0.14: v1(82.13,57.48) 82.13,57.49 81.88,57.75 80.43,57.75 78.9,59.27 67.8,59.27 65,62.08 60.91,62.08 60.01,62.98 54.68,62.98 54.29,63.37 54.29,63.74 53.78,64.25 53.38,64.25 v1(52.22,65.41)
  BOTTOM w0.165: U2030.AC27 82.13,57.33 v1(82.13,57.48) ; CN2019.122 51.8,65.96 52.22,65.54 v1(52.22,65.41)
M_A_A8: length 35.3
  IN1 w0.14: v1(85.33,56.47) 85.25,56.47 84.71,57.01 84.39,57.01 84.14,57.26 84.14,57.64 83.75,58.03 83.5,58.03 83.22,58.3 83.22,58.79 82.97,59.04 82.09,59.04 81.71,59.42 80.31,59.42 78.77,60.97 72.57,60.97 70.36,63.18 61.57,63.18 59.34,65.41 v1(56.7,65.41)
  BOTTOM w0.165: v1(85.33,56.47) 85.71,56.08 U2030.AD22 ; v1(56.7,65.41) 56.91,65.21 CN2019.125
M_A_A9: length 37.8
  IN1 w0.14: v1(86.07,57.53) 85.5,58.1 85.13,58.1 84.9,58.33 84.9,58.7 84.26,59.33 84.26,59.59 83.79,60.06 83.36,60.06 82.6,60.82 79.96,60.82 79.06,61.72 73.07,61.72 70.88,63.92 61.99,63.92 58.84,67.07 v2(56.07,67.07)
  BOTTOM w0.165: v2(56.07,67.07) 56.86,66.28 57.27,66.28 57.34,66.21 CN2019.121 ; v1(86.07,57.53) 86.51,57.09 U2030.AC21
M_A_A10: length 39.5
  TOP w0.165: v1(85.3,53.56) 84.82,53.07 83.5,53.07 83.23,52.8 83.23,52.29 82.99,52.06 80.71,52.06 80.24,52.53 74.45,52.53 74.22,52.3 63.57,52.3 60.87,55 54.9,55 54.16,55.74 v1(54.16,55.99)
  BOTTOM w0.165: CN2019.146 52.46,57.96 54.16,56.25 v1(54.16,55.99) ; U2030.AF22 85.71,53.97 v1(85.3,53.56)
M_A_A11: length 38.9
  TOP w0.165: v1(52.85,65.41) 52.85,65.3 53.8,64.36 56.95,64.36 62.42,58.89 v2(62.93,58.89) 63.18,58.63 79.34,58.63 79.94,58.03 83.75,58.03 84.25,57.53 v1(84.54,57.53)
  BOTTOM w0.165: v1(52.85,65.41) 52.85,65.69 52.09,66.46 CN2019.120 ; U2030.AA24 84.54,57.58 v1(84.54,57.53)
M_A_A12: length 40.3
  TOP w0.165: v2(55.66,68.08) 56.15,68.57 57.79,68.57 64.61,61.75 82.57,61.75 84.52,59.8 84.52,59.17 84.97,58.71 84.97,56.96 84.56,56.54 v1(84.52,56.54)
  BOTTOM w0.165: v2(55.66,68.08) 55.71,68.08 57.09,66.71 CN2019.119 ; U2030.AC23 84.91,56.94 v1(84.52,56.54)
M_A_A13: length 36.9
  IN1 w0.14: v2(53.78,53.33) 59.22,53.33 61.12,51.42 72.58,51.42 74.03,49.97 79.13,49.97 79.95,50.79 81.35,50.79 81.9,51.34 83.63,51.34 v1(83.7,51.42)
  BOTTOM w0.165: U2030.AJ25 83.7,51.62 v1(83.7,51.42) ; CN2019.158 52.15,54.96 v2(53.78,53.33)
M_A_ACT#: length 40.4
  IN1 w0.14: v2(52.39,68.31) 53.15,67.55 59.12,67.55 62.38,64.29 71.27,64.29 72.92,62.64 78.72,62.64 80.17,61.2 82.74,61.2 83.51,60.43 83.95,60.43 84.8,59.57 84.8,59.32 85.39,58.72 v1(85.39,58.53)
  BOTTOM w0.165: v1(85.39,58.53) 85.39,58.38 85.71,58.06 U2030.AA22 ; CN2019.114 51.22,67.96 51.37,67.8 51.88,67.8 v2(52.39,68.31)
M_A_ALERT#: length 38.6
  TOP w0.165: v1(83.65,58.54) 83.49,58.54 82.99,59.04 81.62,59.04 81.24,59.42 64.27,59.42 v2(58.27,65.43) 57.82,65.87 53.31,65.87 v2(52.17,67.01) 52.17,67.26 52.1,67.32 R2290.2
  BOTTOM w0.165: v1(83.65,58.54) 83.65,58.52 83.31,58.17 U2030.AA25 ; v2(52.17,67.01) 52.17,67.13 51.79,67.51 51.33,67.51 51.27,67.46 CN2019.116
M_A_BG#0: length 35.8
  IN1 w0.14: v1(85.99,58.53) 85.99,59.35 85.41,59.93 84.96,59.93 84.1,60.79 83.67,60.79 82.88,61.58 80.31,61.58 78.88,63.01 73.07,63.01 71.42,64.65 62.65,64.65 59.22,68.08 v2(57.03,68.08)
  BOTTOM w0.165: v2(57.03,68.08) 57.06,68.06 57.06,67.96 57.31,67.71 CN2019.115 ; v1(85.99,58.53) 85.99,58.53 U2030.AA21
M_A_BG#1: length 37.8
  TOP w0.165: v1(54.29,65.41) 54.95,64.76 58.38,64.76 64.11,59.03 81.08,59.03 81.49,58.61 v1(81.49,58.53)
  BOTTOM w0.165: CN2019.113 57.57,68.21 57.09,68.69 55.56,68.69 54.16,67.3 54.16,65.54 v1(54.29,65.41) ; U2030.AA27 81.81,58.22 v1(81.49,58.53)
M_A_BS#0: length 40.5
  TOP w0.165: v1(86.07,53.56) 85.72,53.22 85.72,52.37 85.41,52.06 83.75,52.06 83.25,51.55 81.72,51.55 81.24,51.07 80.68,51.07 80.2,51.55 77.02,51.55 76.67,51.9 63.33,51.9 61.28,53.96 v2(58.61,53.96) 55.43,53.96 54.93,54.47 v1(54.8,54.47)
  BOTTOM w0.165: U2030.AF21 86.51,54.01 v1(86.07,53.56) ; v1(54.8,54.47) 54.16,55.1 53.66,55.1 52.83,55.93 52.83,56.06 51.93,56.96 CN2019.150
M_A_BS#1: length 31.4
  IN1 w0.14: v1(56.79,58.23) 56.59,58.03 56.59,57.88 57,57.47 60.32,57.47 60.58,57.21 60.78,57.21 61,57.43 61.2,57.43 61.39,57.23 61.39,57.03 61.18,56.82 61.18,56.62 61.38,56.42 61.57,56.42 61.79,56.64 61.99,56.64 62.18,56.44 62.18,56.24 61.97,56.03 61.97,55.83 62.69,55.1 63.18,55.1 63.59,55.52 70.64,55.52 71.3,54.86 73.98,54.86 74.62,54.22 78.4,54.22 78.49,54.12 81.08,54.12 81.47,54.51 v1(81.47,54.53)
  BOTTOM w0.165: v1(56.79,58.23) 56.82,58.21 CN2019.145 ; U2030.AF27 81.47,54.35 v1(81.47,54.53)
M_A_CAS#: length 38.2
  IN1 w0.14: v1(84.46,52.55) 84.46,52.26 84.03,51.83 83.49,51.83 83.37,51.71 81.76,51.71 81.14,51.09 80.66,51.09 80.53,51.22 79.84,51.22 78.98,50.35 74.28,50.35 72.83,51.8 61.26,51.8 59.36,53.71 54.16,53.71 v1(53.4,54.47)
  BOTTOM w0.165: U2030.AG23 84.46,52.56 v1(84.46,52.55) ; v1(53.4,54.47) 52.42,55.46 CN2019.156
M_A_CKE0: length 39.7
  TOP w0.165: v2(54.42,68.19) 55.05,67.55 58.25,67.55 64.44,61.35 82.41,61.35 84.14,59.63 84.14,58.86 v1(84.46,58.53)
  BOTTOM w0.165: U2030.Y23 84.91,58.98 v1(84.46,58.53) ; CN2019.109 55.31,69.21 54.42,68.31 v2(54.42,68.19)
M_A_CKE1: length 37.6
  IN1 w0.14: v2(53.66,67.02) 54.8,65.87 54.8,65.39 55.43,64.76 59.47,64.76 61.42,62.81 70.2,62.81 72.43,60.59 78.63,60.59 80.17,59.04 81.57,59.04 82.08,58.53 v1(82.21,58.53)
  BOTTOM w0.165: v1(82.21,58.53) 82.21,58.7 U2030.Y26 ; CN2019.110 52.5,68.96 52.89,68.57 52.89,67.78 v2(53.66,67.02)
M_A_CLKN0: length 37.6
  IN1 w0.14: v1(56.23,60.83) 56.08,60.68 56.08,60.41 56.22,60.27 64.28,60.27 64.58,59.98 64.58,59.2 64.28,58.9 63.83,58.9 63.69,58.76 63.69,57.7 63.86,57.53 72.44,57.53 72.83,57.14 78.78,57.14 79.78,56.14 82.88,56.14 83.46,55.55 v1(83.65,55.55)
  BOTTOM w0.165: U2030.AD24 v1(83.65,55.55) ; v1(56.23,60.83) 55.91,60.83 55.75,60.98 55.75,61.5 56.19,61.94 57.24,61.94 57.47,61.71 CN2019.139
M_A_CLKN1: length 37.4
  IN1 w0.14: v1(82.31,54.51) 82.31,54.81 82.19,54.93 78.65,54.93 78.42,55.15 74.81,55.15 74.36,55.61 72.45,55.61 71.8,56.27 63.42,56.27 61.46,58.22 57.86,58.22 57.02,59.07 53.63,59.07 52.63,60.07 52.63,60.48 v1(52.28,60.82)
  BOTTOM w0.165: v1(52.28,60.82) 52.28,61.07 52.4,61.19 52.6,61.19 52.7,61.28 52.7,61.52 52.53,61.69 51.48,61.69 51.24,61.46 CN2019.140 ; v1(82.31,54.51) 81.81,55.01 U2030.AE27
M_A_CLKP0: length 37.6
  IN1 w0.14: v1(55.34,60.83) 55.65,60.83 55.81,60.66 55.81,60.3 56.11,60.01 64.17,60.01 64.31,59.87 64.31,59.31 64.17,59.17 63.72,59.17 63.42,58.87 63.42,57.59 63.75,57.26 72.32,57.26 72.72,56.87 78.67,56.87 79.67,55.87 82.77,55.87 82.89,55.74 v1(82.89,55.55)
  BOTTOM w0.165: CN2019.137 56.08,62.21 55.48,61.61 55.48,60.97 v1(55.34,60.83) ; v1(82.89,55.55) 82.89,55.59 U2030.AD25
M_A_CLKP1: length 37.3
  IN1 w0.14: v1(52.97,60.82) 52.89,60.74 52.89,60.18 53.75,59.33 57.13,59.33 57.97,58.49 61.57,58.49 63.53,56.53 71.91,56.53 72.56,55.88 74.47,55.88 74.92,55.42 78.53,55.42 78.76,55.2 82.3,55.2 v1(82.94,54.55)
  BOTTOM w0.165: CN2019.138 52.64,61.96 52.97,61.63 v1(52.97,60.82) ; v1(82.94,54.55) 82.51,54.99 U2030.AE26
M_A_CS#0: length 34.7
  IN1 w0.14: v1(56.66,57.09) 56.68,57.09 56.69,57.1 60.17,57.1 62.55,54.72 63.43,54.72 63.86,55.15 70.38,55.15 71.03,54.49 73.82,54.49 74.47,53.85 78.23,53.85 78.37,53.71 81.04,53.71 81.32,53.99 86.37,53.99 v1(86.84,53.52)
  BOTTOM w0.165: v1(86.84,53.52) 86.51,53.19 U2030.AG21 ; CN2019.149 56.78,57.21 v1(56.66,57.09)
M_A_CS#1: length 31.6
  IN1 w0.14: v1(57.05,54.49) 57.05,55 57.15,55.1 58.1,55.1 58.48,54.72 58.99,54.72 59.37,55.1 60.61,55.1 61.38,54.33 61.38,54.14 60.83,53.59 60.83,53.39 61.03,53.19 61.22,53.19 61.77,53.74 61.97,53.74 63.02,52.69 73.47,52.69 74.53,51.62 78.88,51.62 79.64,52.39 80.5,52.39 80.73,52.16 81.09,52.16 v1(81.49,52.56)
  BOTTOM w0.165: v1(81.49,52.56) 81.81,52.25 U2030.AJ27 ; CN2019.157 57.57,55.21 57.05,54.68 v1(57.05,54.49)
M_A_DM0: length 52.2
  IN1 w0.089: v1(86.02,70.99) 86.05,70.99 86.4,71.33 86.4,71.77 86.29,71.87 86.29,72.25 84.9,73.65 84.9,75.75 81.98,78.67 75.98,78.67 63.06,91.58 60.84,91.58 58.08,94.35 54.53,94.35 54.44,94.26 54.44,93.67 54.35,93.59 54.17,93.59 54.08,93.67 54.08,94.26 53.99,94.35 53.81,94.35 53.73,94.26 53.73,93.93 53.64,93.84 53.46,93.84 53.37,93.93 53.37,94.26 53.28,94.35 52.31,94.35 52.22,94.26 v2(52.22,92.97)
  BOTTOM w0.102: U2030.F21 86.3,70.71 v1(86.02,70.99) ; CN2019.12 51.73,93.46 v2(52.22,92.97)
M_A_DM1: length 52.5
  IN1 w0.089: v2(57.08,88.91) 57.6,88.91 64.55,81.97 64.55,81.84 63.91,81.2 63.91,81.08 64.04,80.95 64.16,80.95 64.86,81.65 64.99,81.65 65.12,81.53 65.12,81.4 64.24,80.52 64.24,80.4 64.34,80.29 64.51,80.29 65.37,81.15 65.49,81.15 65.62,81.02 65.62,80.9 64.33,79.61 64.33,79.48 64.43,79.38 64.6,79.38 65.87,80.65 66,80.65 66.15,80.5 66.15,80.37 64.6,78.83 64.6,78.7 64.76,78.55 64.88,78.55 66.11,79.77 66.26,79.77 66.45,79.58 66.45,79.46 65.08,78.09 65.08,77.97 65.21,77.84 65.33,77.84 66.7,79.21 66.82,79.21 68.32,77.71 68.32,76.11 70.61,73.83 72.81,73.83 73.25,73.39 78.8,73.39 79.21,72.99 79.79,72.99 80.63,72.15 80.63,71.42 81.5,70.56 v1(81.5,70.48)
  BOTTOM w0.102: CN2019.33 57.52,88.21 57.08,88.64 v2(57.08,88.91) ; U2030.G27 81.81,70.16 v1(81.5,70.48)
M_A_DM2: length 52.5
  IN1 w0.089: v1(83.68,65.53) 83.28,65.92 80.53,65.92 78.38,68.07 73.07,68.07 71.25,69.89 63.35,69.89 62.69,70.55 62.69,71.51 60.98,73.21 58.63,73.21 58.2,73.65 57.83,73.65 57.74,73.73 57.74,74 58.13,74.39 58.13,75.65 57.78,76 55.88,76 55.62,76.25 55.62,77.49 55.71,77.58 57.91,77.58 58.13,77.81 58.13,78.76 58.45,79.08 58.45,81.61 57.22,82.85 52.6,82.85 52.51,82.76 v2(52.51,82.46)
  BOTTOM w0.102: U2030.N24 84.11,65.1 v1(83.68,65.53) ; CN2019.54 52.09,82.96 52.51,82.54 v2(52.51,82.46)
M_A_DM3: length 52.8
  TOP w0.102: v2(56.32,76.95) 56.75,77.38 63.8,77.38 63.9,77.48 63.9,78.12 64,78.22 64.2,78.22 64.3,78.12 64.3,77.05 64.41,76.95 64.61,76.95 64.71,77.05 64.71,78.12 64.81,78.22 65.02,78.22 65.12,78.12 65.12,77.05 65.22,76.95 65.42,76.95 65.52,77.05 65.52,78.12 65.62,78.22 65.83,78.22 65.93,78.12 65.93,77.05 66.03,76.95 66.23,76.95 66.34,77.05 66.34,78.12 66.44,78.22 66.64,78.22 66.74,78.12 66.74,77.05 66.84,76.95 67.05,76.95 67.15,77.05 67.15,78.12 67.25,78.22 67.45,78.22 67.56,78.12 67.56,77.05 67.66,76.95 67.86,76.95 67.96,77.05 67.96,78.12 68.06,78.22 68.27,78.22 68.37,78.12 68.37,77.05 68.47,76.95 69.74,76.95 72.92,73.77 72.92,71.65 73.98,70.6 77.79,70.6 78.17,70.22 78.17,69.96 81.14,66.99 83.83,66.99 84.14,66.69 84.14,66.36 84.9,65.59 84.9,65.26 85.31,64.86 v1(85.31,64.51)
  BOTTOM w0.102: v1(85.31,64.51) 85.31,64.62 U2030.N23 ; CN2019.75 57.08,77.71 v2(56.32,76.95)
M_A_DM4: length 51.9
  IN1 w0.089: v1(83.65,49.54) 83.02,48.91 80.78,48.91 80.54,48.67 80.54,48.55 79.26,47.27 78.83,47.27 78.74,47.18 78.74,46.75 78.65,46.66 78.47,46.66 78.38,46.75 78.38,47.18 78.29,47.27 78.12,47.27 78.03,47.18 78.03,46.75 77.94,46.66 77.76,46.66 77.67,46.75 77.67,47.18 77.58,47.27 77.41,47.27 77.32,47.18 77.32,46.75 77.23,46.66 77.05,46.66 76.96,46.75 76.96,47.18 76.87,47.27 74.9,47.27 74.58,46.96 67.95,46.96 67.63,47.27 61.59,47.27 58.04,50.82 54.13,50.82 54.04,50.74 54.04,50.2 53.68,49.85 53.68,49.16 53.59,49.07 53.39,49.07 53.3,49.16 53.3,49.86 53.21,49.95 53.01,49.95 52.92,49.86 52.92,49.16 52.83,49.07 52.65,49.07 52.56,49.17 52.56,49.43 52.47,49.52 52.24,49.52 52.15,49.43 52.15,48.83 52.06,48.74 51.85,48.74 51.76,48.83 51.76,49.43 51.67,49.52 51.44,49.52 51.35,49.43 51.35,47.83 51.18,47.66 51.01,47.66 50.93,47.75 50.93,49.85 51.06,49.98 51.31,49.98 51.4,49.9 52.26,49.9 52.35,49.99 v2(52.35,50.34)
  BOTTOM w0.102: CN2019.178 51.18,49.96 51.24,49.9 51.91,49.9 v2(52.35,50.34) ; v1(83.65,49.54) 84.11,50 U2030.AL24
M_A_DM5: length 52.9
  TOP w0.102: v2(56.32,45.1) 55.36,45.1 55.21,44.94 55.21,44.41 55.31,44.31 58.06,44.31 59.2,43.17 59.88,43.17 60.89,42.15 61.27,42.15 61.37,42.05 61.37,41.06 61.47,40.96 61.64,40.96 61.78,41.09 61.78,42.05 61.88,42.15 62.08,42.15 62.18,42.05 62.18,41.06 62.28,40.96 62.46,40.96 62.59,41.09 62.59,42.05 62.69,42.15 62.89,42.15 62.99,42.05 62.99,41.06 63.1,40.96 63.27,40.96 63.4,41.09 63.4,42.05 63.5,42.15 63.71,42.15 63.81,42.05 63.81,41.06 63.91,40.96 64.08,40.96 64.21,41.09 64.21,42.05 64.32,42.15 64.52,42.15 64.62,42.05 64.62,41.06 64.72,40.96 64.91,40.96 65.03,41.07 65.03,42.05 65.13,42.15 65.33,42.15 65.43,42.05 65.43,41.19 65.53,41.09 65.68,41.09 65.84,41.25 65.84,42.05 65.94,42.15 66.14,42.15 66.25,42.05 66.25,41.62 66.35,41.51 66.55,41.51 66.65,41.62 66.65,42.05 66.75,42.15 66.96,42.15 67.06,42.05 67.06,41.62 67.16,41.51 67.36,41.51 67.46,41.62 67.46,42.05 67.57,42.15 67.77,42.15 67.87,42.05 67.87,41.62 67.97,41.51 68.18,41.51 68.28,41.62 68.28,42.05 68.38,42.15 68.58,42.15 68.68,42.05 68.68,41.62 68.79,41.51 68.99,41.51 69.09,41.62 69.09,42.05 69.19,42.15 69.4,42.15 69.5,42.05 69.5,41.62 69.6,41.51 69.8,41.51 69.9,41.62 69.9,42.05 70,42.15 70.21,42.15 70.31,42.05 70.31,41.62 70.41,41.51 70.61,41.51 70.72,41.62 70.72,42.05 70.82,42.15 71.45,42.15 74.37,45.07 78.42,45.07 80.45,47.1 81.06,47.1 v1(81.49,47.54)
  BOTTOM w0.102: CN2019.199 57.48,44.71 57.34,44.56 56.86,44.56 v2(56.32,45.1) ; U2030.AN27 81.81,47.85 v1(81.49,47.54)
M_A_DM6: length 52
  IN1 w0.089: v1(82.94,42.98) 82.48,42.53 82.48,42.35 82.21,42.07 81.72,42.07 81.63,41.98 81.63,41.76 81.51,41.65 81.36,41.65 81.27,41.74 81.27,41.98 81.18,42.07 79.9,42.07 79.67,41.85 77.74,41.85 77.46,41.57 77.05,41.57 76.92,41.44 76.92,41.29 77.02,41.18 77.24,41.18 77.34,41.08 77.34,40.85 77.21,40.73 72.93,40.73 72.69,40.97 72.69,41.15 72.59,41.24 67.86,41.24 67.74,41.36 67.74,42.15 67.65,42.24 67.48,42.24 67.39,42.15 67.39,41.31 67.32,41.24 67.07,41.24 66.98,41.33 66.98,42.15 66.89,42.24 66.72,42.24 66.63,42.15 66.63,41.33 66.54,41.24 66.36,41.24 66.27,41.33 66.27,42.15 66.18,42.24 66,42.24 65.92,42.15 65.92,41.33 65.83,41.24 65.65,41.24 65.56,41.33 65.56,42.15 65.47,42.24 65.29,42.24 65.2,42.15 65.2,40.14 65.11,40.05 64.98,40.05 64.85,40.18 64.85,40.37 64.76,40.46 64.16,40.46 64.07,40.55 64.07,40.73 64.16,40.81 64.76,40.81 64.85,40.9 64.85,42.15 64.76,42.24 64.58,42.24 64.49,42.15 64.49,41.33 64.4,41.24 60.72,41.24 60.59,41.11 60.59,40.63 60.39,40.44 57.63,40.44 57.43,40.24 56.07,40.24 55.64,39.8 55.2,39.8 55.11,39.71 55.11,39.53 55.01,39.42 54.85,39.42 54.76,39.51 54.76,39.71 54.67,39.8 54.49,39.8 54.4,39.71 54.4,39.51 54.31,39.43 54.13,39.43 54.05,39.51 54.05,39.71 53.96,39.8 53.64,39.8 53.51,39.67 v2(53.51,39.01)
  BOTTOM w0.102: CN2019.220 53.07,39.46 v2(53.51,39.01) ; v1(82.94,42.98) 82.97,43.01 83.21,43.01 U2030.AW25
M_A_DM7: length 52.8
  IN1 w0.089: v1(86,45.16) 86.34,45.16 86.65,44.84 86.65,42.28 86.78,42.15 86.78,40.52 85.68,39.42 85.68,37.59 84.12,36.03 75.22,36.03 73.41,34.23 69.17,34.23 68.62,34.78 66.32,34.78 66.23,34.69 66.23,33.72 66.14,33.63 65.94,33.63 65.82,33.74 65.82,34.68 65.73,34.78 65.48,34.78 65.39,34.69 65.39,34.52 65.3,34.43 65.04,34.43 64.45,35.01 61.87,35.01 61.78,34.92 61.78,34.52 61.61,34.35 58.44,34.35 58.35,34.26 58.35,34.09 58.44,34 61.69,34 61.78,33.91 61.78,33.72 61.69,33.63 56.72,33.63 v2(56.44,33.91)
  BOTTOM w0.102: CN2019.241 56.7,34.21 56.44,33.94 v2(56.44,33.91) ; U2030.AT21 86.06,45.16 v1(86,45.16)
M_A_DQ0: length 52.2
  IN1 w0.089: v2(52.35,94.9) 52.58,94.66 52.95,94.66 53.04,94.75 53.04,95.02 53.13,95.11 53.31,95.11 53.39,95.02 53.39,94.75 53.48,94.66 58.21,94.66 60.98,91.9 63.19,91.9 76.11,78.99 82.11,78.99 85.22,75.88 85.22,73.78 86.63,72.37 86.63,70.29 86.07,69.74 v1(86.07,68.83)
  BOTTOM w0.102: v1(86.07,68.83) 86.49,68.41 U2030.J21 ; v2(52.35,94.9) 51.9,94.46 CN2019.8
M_A_DQ1: length 52.8
  IN1 w0.089: v1(87,69.64) 87.34,70.01 87.73,70.69 88.03,71 88.03,72.31 87.94,72.5 86.66,75.3 86.5,75.66 86.25,76.19 82.51,79.94 76.5,79.94 62.9,93.54 61.77,93.54 59.45,95.86 57.78,96.78 56.03,96.78 54.8,96 v2(52.26,96)
  BOTTOM w0.102: v2(52.26,96) 51.72,95.46 CN2019.4 ; U2030.H21 v1(87,69.64)
M_A_DQ2: length 51.9
  IN1 w0.089: v1(84.02,70.99) 83.73,70.99 83.63,71.09 83.63,72.42 82.84,73.2 82.84,74.99 82.44,75.39 81.75,75.39 80.86,76.27 73.32,76.27 70.86,78.73 70.86,79.86 70.04,80.69 70.04,80.82 70.44,81.22 70.44,81.35 70.22,81.57 70.09,81.57 69.72,81.2 69.59,81.2 69.47,81.33 69.47,81.45 69.84,81.82 69.84,81.95 69.71,82.08 69.59,82.08 69.22,81.71 69.09,81.71 68.97,81.83 68.97,81.96 69.34,82.33 69.34,82.45 69.21,82.58 69.08,82.58 68.71,82.21 68.59,82.21 68.46,82.33 68.46,82.46 68.83,82.83 68.83,82.95 68.71,83.08 68.58,83.08 68.21,82.71 68.09,82.71 67.96,82.84 67.96,82.96 68.33,83.33 68.33,83.46 68.2,83.58 68.08,83.58 67.71,83.21 67.58,83.21 67.46,83.34 67.46,83.47 67.78,83.79 67.78,84 61.8,89.98 59.91,89.98 58.53,91.36 57.66,91.36 57.49,91.53 57.49,91.87 57.21,92.14 55.1,92.14 55.01,92.06 v2(55.01,91.72)
  BOTTOM w0.102: v2(55.01,91.72) 55.49,92.21 CN2019.17 ; U2030.F23 84.3,70.71 v1(84.02,70.99)
M_A_DQ3: length 51.8
  IN1 w0.089: v1(84.04,69.46) 84.04,69.79 84.42,70.17 84.42,71.72 84.31,71.82 84.31,72.18 83.16,73.34 83.16,75.12 82.58,75.7 81.88,75.7 80.99,76.59 73.45,76.59 71.18,78.86 71.18,79.3 71.97,80.09 71.97,80.22 71.75,80.45 71.62,80.45 71.24,80.06 71.12,80.06 70.99,80.19 70.99,80.31 71.37,80.7 71.37,80.82 71.25,80.95 71.12,80.95 70.74,80.57 70.61,80.57 70.49,80.69 70.49,80.82 70.88,81.21 70.88,81.36 61.93,90.3 60.04,90.3 58.66,91.68 58.25,91.68 57.47,92.46 54.06,92.46 53.57,91.97 v2(52.24,91.97)
  BOTTOM w0.102: U2030.H23 84.26,69.46 v1(84.04,69.46) ; CN2019.20 51.72,91.46 v2(52.24,91.97)
M_A_DQ4: length 52.1
  IN1 w0.089: v1(87.02,70.23) 87.02,70.43 87.71,71.13 87.71,72.18 85.85,74.04 85.85,76.15 82.37,79.62 76.37,79.62 62.77,93.22 61.13,93.22 60.44,93.92 59.86,93.92 59.56,94.21 59.56,94.34 59.98,94.76 59.98,94.88 59.85,95.01 59.73,95.01 59.31,94.59 59.19,94.59 59.06,94.72 59.06,94.84 59.48,95.26 59.48,95.38 59.35,95.51 59.22,95.51 58.81,95.09 58.68,95.09 57.31,96.46 56.12,96.46 v2(55.73,96.07)
  BOTTOM w0.102: CN2019.7 57.3,94.71 56.29,95.5 v2(55.73,96.07) ; U2030.G20 87.24,70.01 v1(87.02,70.23)
M_A_DQ5: length 52.1
  IN1 w0.089: v1(87.02,70.99) 87.07,70.99 87.4,71.32 87.4,72.05 85.53,73.91 85.53,76.01 82.24,79.3 76.24,79.3 63.32,92.22 61.11,92.22 58.34,94.98 53.83,94.98 53.7,95.11 53.7,95.36 53.83,95.49 57.06,95.49 57.15,95.58 v2(57.15,96.06)
  BOTTOM w0.102: U2030.F20 87.3,70.71 v1(87.02,70.99) ; CN2019.3 57.51,95.71 v2(57.15,96.06)
M_A_DQ6: length 52.3
  IN1 w0.089: v1(85.07,68.8) 84.64,69.23 84.64,72.3 83.48,73.47 83.48,75.25 81.4,77.32 80.24,77.32 79.83,76.91 75.27,76.91 75.19,77 75.19,77.41 75.1,77.5 74.74,77.5 74.65,77.41 74.65,77 74.56,76.91 73.58,76.91 71.56,78.93 71.56,79.23 72.43,80.1 72.43,80.25 62.07,90.62 60.17,90.62 58.79,92 58.38,92 57.6,92.78 54.46,92.78 53.73,93.51 53.39,93.51 v2(52.93,93.05)
  BOTTOM w0.102: v1(85.07,68.8) 85.47,68.41 U2030.J22 ; CN2019.16 52.34,92.46 v2(52.93,93.05)
M_A_DQ7: length 51.9
  IN1 w0.089: v2(56.43,91.72) 56.22,91.51 56.22,91.27 56.45,91.05 58.4,91.05 59.77,89.67 61.67,89.67 64.2,87.14 64.2,86.99 63.81,86.6 63.81,86.48 63.94,86.35 64.06,86.35 64.46,86.75 64.59,86.75 64.71,86.63 64.71,86.5 64.44,86.23 64.44,86.1 64.57,85.98 64.69,85.98 64.96,86.25 65.09,86.25 65.21,86.12 65.21,86 64.82,85.6 64.82,85.47 64.94,85.35 65.07,85.35 65.47,85.75 65.59,85.75 65.72,85.62 65.72,85.5 65.32,85.1 65.32,84.97 65.44,84.84 65.57,84.84 65.97,85.24 66.09,85.24 66.22,85.12 66.22,84.99 65.82,84.59 65.82,84.47 65.95,84.34 66.07,84.34 66.47,84.74 66.6,84.74 66.72,84.62 66.72,84.49 66.32,84.09 66.32,83.96 66.45,83.84 66.58,83.84 66.96,84.22 67.1,84.22 67.31,84.02 67.31,83.87 66.92,83.48 66.92,83.36 70.55,79.73 70.55,78.6 73.2,75.94 80.74,75.94 81.95,74.73 81.95,73.64 83.4,72.2 83.4,70.7 83.63,70.47 83.63,69.27 v1(84.07,68.83)
  BOTTOM w0.102: v2(56.43,91.72) 56.95,91.21 CN2019.21 ; U2030.J23 84.41,68.49 v1(84.07,68.83)
M_A_DQ8: length 52.3
  IN1 w0.089: v1(83.02,70.45) 82.43,71.04 82.43,71.76 82.2,72 82.15,72 80.45,73.69 80.45,73.99 79.54,74.9 71.99,74.9 71.84,75.05 71.84,75.2 72.07,75.42 72.07,75.57 71.97,75.68 71.82,75.68 71.47,75.33 71.34,75.33 69.36,77.31 69.36,79.48 62.52,86.32 62.39,86.32 62.23,86.15 62.1,86.15 61.91,86.35 61.91,86.47 62.55,87.11 62.55,87.23 62.36,87.42 62.24,87.42 61.51,86.69 61.38,86.69 61.26,86.81 61.26,86.94 61.99,87.67 61.99,87.79 61.86,87.92 61.74,87.92 61.01,87.19 60.88,87.19 60.75,87.32 60.75,87.44 61.48,88.17 61.48,88.3 61.36,88.42 61.23,88.42 60.5,87.69 60.38,87.69 60.17,87.9 60.17,88.03 60.48,88.34 60.48,88.52 60.35,88.65 59.35,88.65 57.97,90.03 55.96,90.03 55.56,90.43 53.87,90.43 v2(53.52,90.07)
  BOTTOM w0.102: U2030.G25 83.47,70.01 v1(83.02,70.45) ; v2(53.52,90.07) 52.9,89.46 CN2019.28
M_A_DQ9: length 52.6
  IN1 w0.089: v2(54.76,90.02) 55.15,89.63 57.79,89.63 61.58,85.84 62.56,85.84 67.43,80.96 67.43,80.83 66.86,80.26 66.86,80.13 66.98,80 67.11,80 67.69,80.58 67.81,80.58 67.94,80.46 67.94,80.33 67.36,79.75 67.36,79.63 67.49,79.5 67.61,79.5 68.19,80.08 68.31,80.08 68.44,79.95 68.44,79.83 67.86,79.25 67.86,79.12 67.99,79 68.11,79 68.69,79.58 68.82,79.58 69.04,79.35 69.04,77.17 69.42,76.8 69.42,76.67 69.1,76.36 69.1,76.23 69.23,76.11 69.35,76.11 69.67,76.42 69.79,76.42 69.92,76.3 69.92,76.17 69.6,75.86 69.6,75.73 69.73,75.6 69.86,75.6 70.17,75.92 70.3,75.92 70.42,75.79 70.42,75.67 70.11,75.35 70.11,75.23 70.23,75.1 70.36,75.1 70.67,75.42 70.8,75.42 70.93,75.29 70.93,75.16 70.61,74.85 70.61,74.72 70.74,74.6 70.86,74.6 71.18,74.91 71.3,74.91 71.63,74.59 73.91,74.59 74,74.5 74,74.18 74.09,74.09 74.27,74.09 74.36,74.18 74.36,74.5 74.45,74.59 74.62,74.59 74.71,74.5 74.71,74.18 74.8,74.09 74.98,74.09 75.07,74.18 75.07,74.5 75.16,74.59 79.41,74.59 80.12,73.87 80.12,73.57 81.62,72.07 81.62,71.46 82.04,71.04 v1(82.05,71.04)
  BOTTOM w0.102: U2030.F26 82.38,70.71 v1(82.05,71.04) ; v2(54.76,90.02) 55.22,90.48 56.25,90.48 56.53,90.21 CN2019.25
M_A_DQ10: length 52.5
  IN1 w0.089: v2(55.18,86.6) 55.69,87.11 57.14,87.11 62.23,82.02 62.23,79.61 62.32,79.52 62.58,79.52 62.67,79.43 62.67,75.99 62.58,75.9 61.89,75.9 61.8,75.81 61.8,75.63 61.89,75.54 62.58,75.54 62.67,75.45 62.67,74.79 62.8,74.66 63.22,74.66 63.31,74.75 63.31,76.35 63.4,76.44 63.62,76.44 63.75,76.31 63.75,75.37 63.84,75.28 64.54,75.28 64.63,75.2 64.63,75.02 64.54,74.93 63.84,74.93 63.75,74.84 63.75,73.68 65.25,72.18 72.2,72.18 73.45,70.93 78.78,70.93 79.31,70.39 79.31,69.84 81.01,68.13 83.03,68.13 v1(83.75,67.42)
  BOTTOM w0.102: U2030.L24 84.11,67.05 v1(83.75,67.42) ; CN2019.37 55.79,87.21 v2(55.18,86.6)
M_A_DQ11: length 52.4
  IN1 w0.089: v1(82.23,67.55) 81.85,67.94 80.83,67.94 78.98,69.79 78.98,70.27 78.65,70.6 73.33,70.6 72.07,71.86 65.12,71.86 61.1,75.88 61.1,76.19 61.19,76.28 61.82,76.28 61.91,76.37 61.91,76.55 61.82,76.64 61.19,76.64 61.1,76.73 61.1,76.9 61.19,76.99 61.82,76.99 61.91,77.08 61.91,77.26 61.82,77.35 61.19,77.35 61.1,77.44 61.1,77.62 61.19,77.7 61.82,77.7 61.91,77.79 61.91,77.97 61.82,78.06 61.19,78.06 61.1,78.15 61.1,78.33 61.19,78.42 61.82,78.42 61.91,78.5 61.91,78.68 61.82,78.77 61.19,78.77 61.1,78.86 61.1,79.04 61.19,79.13 61.82,79.13 61.91,79.22 61.91,79.39 61.82,79.48 61.19,79.48 61.1,79.57 61.1,79.75 61.19,79.84 61.82,79.84 61.91,79.93 61.91,80.1 61.82,80.19 61.19,80.19 61.1,80.28 61.1,80.46 61.19,80.55 61.82,80.55 61.91,80.64 61.91,80.82 61.82,80.91 61.19,80.91 61.1,80.99 61.1,81.17 61.19,81.26 61.82,81.26 61.91,81.35 61.91,81.53 61.82,81.62 61.19,81.62 61.1,81.71 61.1,81.84 61.19,81.93 61.31,81.93 61.44,82.06 61.44,82.36 57.63,86.17 56.88,86.17 v2(56.45,86.6)
  BOTTOM w0.102: v2(56.45,86.6) 56.9,86.15 57.53,86.15 57.58,86.21 CN2019.41 ; U2030.L26 82.51,67.27 v1(82.23,67.55)
M_A_DQ12: length 52.3
  IN1 w0.089: v1(84.44,67.44) 84.44,67.55 82.61,69.38 82.61,69.91 81.42,71.11 81.42,71.82 79.92,73.32 79.39,73.32 78.93,73.77 73.32,73.77 72.94,74.15 70.73,74.15 68.64,76.24 68.64,77.84 68.4,78.08 68.4,78.21 68.72,78.53 68.72,78.66 68.61,78.77 68.49,78.77 68.17,78.46 68.02,78.46 66.54,79.94 66.54,80.55 66.31,80.78 66.31,80.9 66.61,81.2 66.61,81.33 66.49,81.46 66.36,81.46 66.06,81.16 65.94,81.16 65.81,81.28 65.81,81.41 66.11,81.71 66.11,81.83 65.98,81.96 65.86,81.96 65.56,81.66 65.43,81.66 65.31,81.78 65.31,81.91 65.61,82.21 65.61,82.34 65.48,82.46 65.36,82.46 65.06,82.16 64.93,82.16 64.81,82.29 64.81,82.41 65.11,82.71 65.11,82.84 64.98,82.96 64.85,82.96 64.55,82.66 64.43,82.66 64.3,82.79 64.3,82.92 64.6,83.22 64.6,83.34 64.48,83.47 64.35,83.47 64.05,83.17 63.93,83.17 63.8,83.29 63.8,83.42 64.1,83.72 64.1,83.84 63.97,83.97 63.85,83.97 63.55,83.67 63.42,83.67 63.3,83.8 63.3,83.92 63.6,84.22 63.6,84.35 63.47,84.47 63.34,84.47 63.04,84.17 62.92,84.17 62.79,84.3 62.79,84.42 63.09,84.72 63.09,84.85 62.97,84.98 62.42,85.52 61.45,85.52 57.65,89.31 56.16,89.31 v2(55.78,88.93)
  BOTTOM w0.102: U2030.L23 84.48,67.44 v1(84.44,67.44) ; v2(55.78,88.93) 56.21,89.37 57.36,89.37 57.53,89.21 CN2019.29
M_A_DQ13: length 52.5
  IN1 w0.089: v1(83.02,71.04) 82.64,71.42 82.64,71.97 81.21,73.39 81.21,74.03 80.99,74.26 80.99,74.56 80.3,75.25 72.91,75.25 71.96,76.2 71.83,76.2 71.44,75.8 71.31,75.8 71.19,75.93 71.19,76.05 71.58,76.45 71.58,76.58 71.46,76.7 71.33,76.7 70.93,76.3 70.81,76.3 70.68,76.43 70.68,76.56 71.08,76.95 71.08,77.08 70.95,77.2 70.83,77.2 70.43,76.81 70.31,76.81 70.18,76.93 70.18,77.06 70.58,77.46 70.58,77.58 70.45,77.71 70.33,77.71 69.93,77.31 69.8,77.31 69.68,77.44 69.68,77.56 70.07,77.96 70.07,78.08 69.85,78.31 69.85,79.44 63.11,86.18 63.11,87.12 61.4,88.83 60.89,88.83 60.75,88.97 59.48,88.97 58.11,90.35 56.09,90.35 55.69,90.75 51.2,90.75 50.99,90.54 50.99,89.78 51.12,89.65 51.82,89.65 v2(52.25,90.07)
  BOTTOM w0.102: CN2019.24 51.23,90.46 51.31,90.54 51.78,90.54 v2(52.25,90.07) ; U2030.F25 83.18,71.04 v1(83.02,71.04)
M_A_DQ14: length 53
  IN1 w0.089: v1(82.92,68.52) 82.78,68.52 82.36,68.95 80.91,68.95 80.52,69.34 80.52,69.52 79.96,70.08 79.96,70.66 78.57,72.05 73.23,72.05 72.41,72.86 65.61,72.86 65.47,73.01 65.47,74.7 65.56,74.79 65.89,74.79 65.97,74.7 65.97,73.48 66.06,73.39 66.41,73.39 66.5,73.48 66.5,76.08 67.05,76.63 67.05,76.76 66.61,77.2 66.48,77.2 66.04,76.76 64.24,76.76 63.31,77.69 63.31,79.96 62.86,80.4 62.86,82.29 57.35,87.8 53.58,87.8 v2(52.36,86.58)
  BOTTOM w0.102: v2(52.36,86.58) 51.88,87.06 51.37,87.06 51.27,86.96 CN2019.38 ; U2030.K25 82.92,68.4 v1(82.92,68.52)
M_A_DQ15: length 53.2
  IN1 w0.089: v1(81.56,68.52) 81,68.52 80.2,69.33 80.2,69.39 79.64,69.95 79.64,70.52 78.9,71.26 73.57,71.26 72.28,72.55 65.33,72.55 65.15,72.73 65.15,73.46 65.06,73.54 64.54,73.54 64.45,73.63 64.45,73.81 64.54,73.9 65.06,73.9 65.15,73.99 65.15,74.17 65.06,74.26 64.16,74.26 64.07,74.34 64.07,74.52 64.16,74.61 65.06,74.61 65.15,74.7 65.15,75.02 65.24,75.11 66.09,75.11 66.18,75.2 66.18,76.22 66.09,76.31 65.78,76.31 65.69,76.22 65.69,75.64 65.6,75.55 65.42,75.55 65.33,75.64 65.33,76.22 65.24,76.31 65.07,76.31 64.98,76.22 64.98,75.64 64.89,75.55 64.71,75.55 64.62,75.64 64.62,76.22 64.53,76.31 64.2,76.31 62.99,77.52 62.99,79.83 62.9,79.92 62.63,79.92 62.55,80.01 62.55,82.15 57.24,87.46 54.02,87.46 v2(53.14,86.59)
  BOTTOM w0.102: v2(53.14,86.59) 52.51,85.96 CN2019.42 ; v1(81.56,68.52) 81.81,68.27 U2030.K27
M_A_DQ16: length 52.9
  IN1 w0.089: v1(82.92,66.54) 82.73,66.54 82.33,66.94 80.43,66.94 78.66,68.71 73.34,68.71 71.51,70.53 63.61,70.53 63.32,70.82 63.32,71.77 61.24,73.85 60.34,73.85 60.25,73.94 60.25,74.57 60.16,74.66 59.98,74.66 59.89,74.57 59.89,73.94 59.8,73.85 59.61,73.85 59.52,73.94 59.52,75.52 59.43,75.61 59.26,75.61 59.17,75.52 59.17,73.95 59.08,73.86 58.9,73.86 58.8,73.96 58.8,78.53 59.09,78.81 59.09,81.88 57.85,83.11 57.85,83.95 57.76,84.03 57.53,84.03 57.44,83.95 57.44,83.58 57.34,83.48 57.11,83.48 57.02,83.57 57.02,83.97 56.94,84.06 56.76,84.06 56.67,83.97 56.67,83.57 56.58,83.48 54.83,83.48 54.75,83.57 54.75,83.87 54.94,84.06 55.89,84.06 v2(56.43,84.61)
  BOTTOM w0.102: v2(56.43,84.61) 57.03,85.21 CN2019.45 ; U2030.M25 82.92,66.4 v1(82.92,66.54)
M_A_DQ17: length 52.4
  IN1 w0.089: v2(55.04,84.61) 54.6,84.17 54.28,84.17 54.19,84.08 54.19,83.64 54.1,83.55 53.92,83.55 53.83,83.64 53.83,84.08 53.75,84.17 52.98,84.17 52.89,84.08 52.89,83.43 53.15,83.16 57.35,83.16 58.77,81.74 58.77,78.94 58.48,78.66 58.48,76.84 58.39,76.75 58.04,76.75 57.97,76.82 57.97,77.11 57.89,77.2 57.63,77.2 57.54,77.11 57.54,76.48 57.63,76.39 58.39,76.39 58.48,76.31 58.48,73.81 58.76,73.53 61.11,73.53 63,71.64 63,70.69 63.48,70.21 71.38,70.21 73.21,68.39 78.52,68.39 80.75,66.16 81.13,66.16 v1(81.52,66.55)
  BOTTOM w0.102: CN2019.49 57.48,84.21 57.34,84.06 55.58,84.06 v2(55.04,84.61) ; U2030.M27 81.81,66.26 v1(81.52,66.55)
M_A_DQ18: length 52.6
  IN1 w0.089: v2(56.32,81.39) 57.49,80.23 57.49,79.63 57.21,79.36 54.76,79.36 54.5,79.1 54.5,73.9 55.03,73.37 55.03,72.86 54.93,72.76 53.87,72.76 53.78,72.85 53.78,74.09 53.66,74.22 53.19,74.22 53.1,74.13 53.1,72.46 53.44,72.13 55.88,72.13 56.3,72.55 57.77,72.55 58.07,72.25 60.58,72.25 61.68,71.15 61.68,70.2 62.95,68.93 70.85,68.93 73.42,66.36 78.27,66.36 80.11,64.51 v1(81.52,64.51)
  BOTTOM w0.102: CN2019.59 57.53,81.71 57.34,81.9 56.83,81.9 v2(56.32,81.39) ; v1(81.52,64.51) 81.81,64.22 U2030.P27
M_A_DQ19: length 52.7
  IN1 w0.089: v1(82.94,63.61) 82.23,62.9 80.38,62.9 78.33,64.95 73.48,64.95 71.14,67.3 62.42,67.3 60.13,69.58 60.13,69.71 60.39,69.96 60.39,70.09 60.26,70.21 60.14,70.21 59.88,69.96 59.76,69.96 58.62,71.1 51.34,71.1 50.88,71.56 50.88,81.92 50.99,82.03 52.13,82.03 52.25,81.91 v2(52.25,81.44)
  BOTTOM w0.102: U2030.R24 83.57,63.55 83.01,63.55 v1(82.94,63.61) ; v2(52.25,81.44) 51.76,80.96 CN2019.62
M_A_DQ20: length 52.4
  IN1 w0.089: v2(52.23,84.57) 52.23,83.01 52.14,82.92 51.92,82.92 51.83,83.01 51.83,83.98 51.7,84.11 51.48,84.11 51.4,84.02 51.4,83.03 51.28,82.92 51.08,82.92 50.99,83.01 50.99,85.11 51.08,85.2 53.02,85.2 53.29,85.47 57.22,85.47 60.41,82.28 60.41,75.59 63.97,72.02 63.97,71.33 64.14,71.16 71.78,71.16 73.13,69.81 77.68,69.81 78.14,69.35 78.93,69.35 80.72,67.56 v1(81.39,67.56)
  BOTTOM w0.102: CN2019.50 51.66,83.96 52.23,84.53 v2(52.23,84.57) ; U2030.L27 81.81,67.14 v1(81.39,67.56)
M_A_DQ21: length 52.8
  IN1 w0.089: v2(53.54,84.58) 53.54,84.96 53.67,85.09 57.15,85.09 58.16,84.08 58.16,83.25 59.4,82.01 59.4,81.2 59.49,81.11 59.92,81.11 60.01,81.02 60.01,80.84 59.92,80.75 59.49,80.75 59.4,80.66 59.4,79.24 59.49,79.15 59.92,79.15 60.01,79.06 60.01,78.89 59.92,78.8 59.49,78.8 59.4,78.71 59.4,78.51 59.49,78.42 59.92,78.42 60.01,78.33 60.01,78.13 59.92,78.04 59.21,78.04 59.12,77.95 59.12,77.77 59.21,77.68 59.92,77.68 60.01,77.59 60.01,77.41 59.92,77.32 59.21,77.32 59.12,77.23 59.12,76.43 59.45,76.09 59.58,76.09 59.86,76.38 59.99,76.38 60.09,76.28 60.09,76.1 59.83,75.84 59.83,75.72 63.64,71.9 63.64,71.03 63.82,70.85 71.65,70.85 73.47,69.02 78.79,69.02 80.65,67.17 83.12,67.17 83.71,66.58 v1(83.71,66.52)
  BOTTOM w0.102: U2030.M24 83.71,66.42 v1(83.71,66.52) ; CN2019.46 51.25,84.96 51.3,85.01 53.11,85.01 v2(53.54,84.58)
M_A_DQ22: length 52.3
  IN1 w0.089: v1(83.55,64.51) 83.55,64.43 83.25,64.12 82.87,64.12 81.98,63.23 80.5,63.23 78.46,65.27 73.61,65.27 71.23,67.65 63.27,67.65 61.04,69.87 61.04,70.89 60.91,71.02 59.14,71.02 58.75,71.42 53.22,71.42 52.45,72.19 51.56,72.19 51.22,72.52 51.22,80.48 51.62,80.89 53,80.89 v2(53.55,81.44)
  BOTTOM w0.102: CN2019.58 53.04,81.96 v2(53.55,81.44) ; U2030.P24 83.61,64.51 v1(83.55,64.51)
M_A_DQ23: length 52.6
  IN1 w0.089: v1(82.92,64.51) 82.75,64.51 82.36,64.12 80.06,64.12 78.15,66.03 73.3,66.03 70.72,68.61 62.75,68.61 61.36,70.01 61.36,71.02 60.45,71.93 57.94,71.93 57.64,72.23 56.43,72.23 56.01,71.81 53.27,71.81 52.79,72.3 52.79,74.45 52.87,74.54 53.95,74.54 54.18,74.76 54.18,75.27 54.07,75.39 52.98,75.39 52.89,75.48 52.89,76.46 52.98,76.55 54.09,76.55 54.18,76.64 54.18,77.18 54.01,77.36 53.25,77.36 53.16,77.45 53.16,79.36 53.66,79.86 v2(55.81,79.86)
  BOTTOM w0.102: v2(55.81,79.86) 56.66,80.71 CN2019.63 ; U2030.P25 83.31,64.12 v1(82.92,64.51)
M_A_DQ24: length 52
  TOP w0.102: v2(52.26,78.71) 53.02,77.94 57.83,77.94 58.43,78.55 58.83,78.55 58.93,78.45 58.93,77.81 59.03,77.71 59.24,77.71 59.34,77.81 59.34,78.45 59.44,78.55 59.64,78.55 59.74,78.45 59.74,77.81 59.85,77.71 60.05,77.71 60.15,77.81 60.15,78.45 60.25,78.55 60.46,78.55 60.56,78.45 60.56,77.81 60.66,77.71 60.86,77.71 60.96,77.81 60.96,78.45 61.06,78.55 61.27,78.55 61.37,78.45 61.37,77.81 61.47,77.71 61.67,77.71 61.78,77.81 61.78,78.45 61.88,78.55 62.08,78.55 62.18,78.45 62.18,77.81 62.28,77.71 62.49,77.71 62.59,77.81 62.59,78.45 62.69,78.55 62.89,78.55 63,78.45 63,77.81 63.1,77.71 63.3,77.71 63.4,77.81 63.4,78.45 63.5,78.55 68.61,78.55 73.25,73.9 73.25,71.85 74.18,70.93 78.47,70.93 79.18,70.22 79.18,69.84 80.96,68.06 84.4,68.06 84.9,67.56 84.9,66.95 v1(85.33,66.52)
  BOTTOM w0.102: v2(52.26,78.71) 51.83,79.14 51.43,79.14 51.24,78.96 CN2019.70 ; U2030.M22 85.33,66.39 v1(85.33,66.52)
M_A_DQ25: length 52.3
  TOP w0.102: v1(85.92,65.51) 85.74,65.7 85.74,66.71 85.53,66.92 85.53,68.11 85.25,68.39 83.93,68.39 83.25,69.07 80.58,69.07 79.69,69.96 79.69,70.18 78.61,71.26 74.32,71.26 73.58,71.99 73.58,74.04 68.52,79.1 58.48,79.1 57.65,78.27 55.29,78.27 55.18,78.38 55.18,79.77 55.08,79.87 54.88,79.87 54.78,79.77 54.78,78.38 54.68,78.27 54.47,78.27 54.37,78.38 54.37,79.77 54.27,79.87 54.07,79.87 v2(53.96,79.77) 53.96,78.38 53.86,78.27 53.3,78.27 52.39,79.19 v2(52.39,79.86)
  BOTTOM w0.102: v2(52.39,79.86) 51.95,80.3 51.56,80.3 51.22,79.96 CN2019.66 ; U2030.N21 86.43,65.01 v1(85.92,65.51)
M_A_DQ26: length 52.6
  TOP w0.102: v1(85.28,62.47) 84.52,62.47 83.78,63.21 81.24,63.21 78.17,66.28 75.3,66.28 75.2,66.38 75.2,66.69 75.1,66.79 74.89,66.79 74.79,66.69 74.79,66.38 74.69,66.28 73.94,66.28 65.71,74.51 65.52,74.51 65.42,74.41 65.42,73.75 65.31,73.65 65.09,73.65 64.96,73.77 64.96,74.41 64.86,74.51 64.62,74.51 64.52,74.41 64.52,73.75 64.42,73.65 64.21,73.65 64.11,73.75 64.11,74.41 64.01,74.51 63.81,74.51 63.7,74.41 63.7,73.75 63.6,73.65 63.4,73.65 63.3,73.75 63.3,74.41 63.2,74.51 62.99,74.51 62.89,74.41 62.89,73.75 62.79,73.65 62.59,73.65 62.49,73.75 62.49,74.41 62.38,74.51 62.18,74.51 62.08,74.41 62.08,73.75 61.98,73.65 61.77,73.65 61.67,73.75 61.67,74.41 61.57,74.51 61.37,74.51 61.27,74.41 61.27,73.75 61.16,73.65 60.96,73.65 60.86,73.75 60.86,74.41 60.76,74.51 60.55,74.51 60.45,74.41 60.45,73.75 60.35,73.65 60.15,73.65 60.05,73.75 60.05,74.41 59.95,74.51 54.02,74.51 v2(53.57,74.96)
  BOTTOM w0.102: U2030.T22 85.28,62.44 v1(85.28,62.47) ; CN2019.80 52.07,76.46 v2(53.57,74.96)
M_A_DQ27: length 52.8
  TOP w0.102: v2(52.27,74.96) 52.85,74.38 52.85,73.57 53.1,73.32 53.43,73.32 53.53,73.42 53.53,74.05 53.63,74.15 53.83,74.15 53.94,74.05 53.94,73.42 54.04,73.32 54.24,73.32 54.34,73.42 54.34,74.05 54.44,74.15 54.65,74.15 54.75,74.05 54.75,73.42 54.85,73.32 55.05,73.32 55.15,73.42 55.15,74.05 55.26,74.15 55.46,74.15 55.56,74.05 55.56,73.42 55.66,73.32 55.87,73.32 55.97,73.42 55.97,74.05 56.07,74.15 56.27,74.15 56.37,74.05 56.37,73.42 56.48,73.32 57.39,73.32 57.49,73.42 57.49,74.05 57.6,74.15 57.8,74.15 57.9,74.05 57.9,73.42 58,73.32 58.21,73.32 58.31,73.42 58.31,74.05 58.41,74.15 58.61,74.15 58.71,74.05 58.71,73.42 58.82,73.32 59.02,73.32 59.12,73.42 59.12,74.05 59.22,74.15 59.43,74.15 59.53,74.05 59.53,73.42 59.63,73.32 66.43,73.32 74.51,65.24 78.74,65.24 81.1,62.88 83.6,62.88 84.97,61.5 v1(85.91,61.5)
  BOTTOM w0.102: U2030.V21 86.02,61.5 v1(85.91,61.5) ; v2(52.27,74.96) 51.78,75.46 CN2019.84
M_A_DQ28: length 53
  TOP w0.102: v1(86.07,67.19) 86.07,68.04 85.53,68.58 85.53,68.92 85.23,69.23 84.87,69.23 84.16,69.94 80.82,69.94 78.68,72.07 76.03,72.07 68.67,79.43 68.05,79.43 67.95,79.53 67.95,79.77 67.85,79.87 67.65,79.87 67.54,79.77 67.54,79.53 67.44,79.43 67.24,79.43 67.14,79.53 67.14,80.97 67.01,81.1 66.83,81.1 66.73,80.99 66.73,79.53 66.63,79.43 66.43,79.43 66.33,79.53 66.33,80.97 66.2,81.1 66.02,81.1 65.92,80.99 65.92,79.53 65.82,79.43 65.61,79.43 65.51,79.53 65.51,80.97 65.38,81.1 65.21,81.1 65.11,80.99 65.11,79.53 65,79.43 64.8,79.43 64.7,79.53 64.7,80.97 64.57,81.1 64.4,81.1 64.29,80.99 64.29,79.53 64.19,79.43 63.99,79.43 63.89,79.53 63.89,80.97 63.76,81.1 63.58,81.1 63.48,80.99 63.48,79.53 63.38,79.43 58.3,79.43 57.57,78.71 v2(57.08,78.71)
  BOTTOM w0.102: v1(86.07,67.19) 86.46,66.81 U2030.L21 ; CN2019.71 v2(57.08,78.71)
M_A_DQ29: length 52.5
  TOP w0.102: v1(87.05,66.41) 86.52,66.93 86.52,68.97 85.53,69.96 85.53,71.63 84.66,72.5 76.07,72.5 67.15,81.43 63.08,81.43 62.98,81.32 62.98,79.86 62.88,79.76 62.68,79.76 62.58,79.86 62.58,81.32 62.48,81.43 62.27,81.43 62.17,81.32 62.17,79.86 62.07,79.76 61.87,79.76 61.76,79.86 61.76,81.32 61.66,81.43 61.46,81.43 61.36,81.32 61.36,79.86 61.26,79.76 61.05,79.76 60.95,79.86 60.95,81.32 v2(60.85,81.43) 60.52,81.43 60.42,81.32 60.42,80.61 60.32,80.5 60.11,80.5 60.01,80.61 60.01,81.32 59.91,81.43 59.73,81.43 59.62,81.32 59.62,80.38 59.11,79.86 v2(57.08,79.86)
  BOTTOM w0.102: CN2019.67 57.24,79.71 v2(57.08,79.86) ; v1(87.05,66.41) 87.44,66.01 U2030.M20
M_A_DQ30: length 52.6
  TOP w0.102: v2(55.18,75.01) 54.8,75.39 54.8,75.7 54.9,75.81 69.46,75.81 70.55,74.72 70.55,74.39 69.15,72.99 69.15,72.25 71.78,69.62 72.05,69.62 72.72,70.29 72.86,70.29 73,70.15 73,70.01 72.33,69.34 72.33,69.19 72.48,69.05 72.62,69.05 73.29,69.72 73.44,69.72 73.58,69.58 73.58,69.43 72.91,68.76 72.91,68.62 73.05,68.47 73.2,68.47 73.87,69.14 74.01,69.14 74.15,69 74.15,68.86 73.48,68.19 73.48,68.04 73.63,67.9 73.77,67.9 74.29,68.42 74.43,68.42 74.61,68.24 74.61,67.6 74.71,67.5 75.06,67.5 75.16,67.6 75.16,68.21 75.26,68.31 78.18,68.31 79.18,67.31 79.18,66.66 80.83,65.01 83.63,65.01 84.14,64.5 84.14,63.99 v1(84.52,63.61)
  BOTTOM w0.102: CN2019.79 57.6,76.71 57.08,76.19 56.34,76.19 55.18,75.03 v2(55.18,75.01) ; U2030.R23 84.52,63.4 v1(84.52,63.61)
M_A_DQ31: length 52.7
  TOP w0.102: v1(86.02,62.47) 85.64,62.85 84.64,62.85 83.4,64.1 81.24,64.1 78.17,67.17 73.51,67.17 68.1,72.59 68.1,72.73 69.76,74.39 69.76,74.54 69.61,74.68 69.47,74.68 67.81,73.02 67.66,73.02 67.52,73.16 67.52,73.31 69.18,74.97 69.18,75.11 69.04,75.25 68.9,75.25 67.23,73.59 67.09,73.59 66.86,73.83 66.86,73.97 68.05,75.16 68.05,75.35 67.93,75.47 67.78,75.47 66.57,74.26 66.42,74.26 66.28,74.4 66.28,74.55 66.69,74.95 66.69,75.09 66.54,75.24 66.4,75.24 66,74.84 58.02,74.84 57.43,75.42 56.94,75.42 v2(56.49,74.97)
  BOTTOM w0.102: v1(86.02,62.47) 86.05,62.47 U2030.T21 ; v2(56.49,74.97) 56.49,75.02 57.17,75.71 CN2019.83
M_A_DQ32: length 52.5
  IN1 w0.089: v1(81.47,49.54) 81.44,49.52 80.6,49.52 79.04,47.95 78.87,47.95 78.8,48.02 78.8,48.28 78.67,48.41 74.81,48.41 74.69,48.28 74.69,47.95 74.57,47.84 74.42,47.84 74.33,47.93 74.33,48.32 74.24,48.41 74.06,48.41 73.98,48.32 73.98,47.68 73.89,47.59 73.71,47.59 73.62,47.68 73.62,48.32 73.53,48.41 73.35,48.41 73.26,48.32 73.26,47.68 73.18,47.59 73,47.59 72.91,47.68 72.91,48.32 72.82,48.41 72.64,48.41 72.55,48.32 72.55,47.68 72.46,47.59 72.32,47.59 72.2,47.72 72.2,48.32 72.11,48.41 70.84,48.41 70.65,48.23 70.65,47.72 70.53,47.59 69.02,47.59 68.9,47.72 68.9,47.95 68.77,48.07 68.56,48.07 68.49,48.01 68.49,47.69 68.39,47.59 68.21,47.59 68.08,47.72 68.08,48.96 67.96,49.08 67.64,49.08 67.55,49 67.55,48.49 67.46,48.4 67.28,48.4 67.19,48.49 67.19,49 67.11,49.08 66.93,49.08 66.84,49 66.84,48.49 66.75,48.4 66.57,48.4 66.48,48.49 66.48,49 66.39,49.08 66.22,49.08 66.13,49 66.13,48.49 66.04,48.4 65.86,48.4 65.77,48.49 65.77,49 65.68,49.08 65.51,49.08 65.42,49 65.42,48 65.33,47.91 65.16,47.91 65.06,48.01 65.06,49 64.97,49.08 64.79,49.08 64.7,49 64.7,48 64.62,47.91 64.44,47.91 64.35,48 64.35,49 64.26,49.08 64.08,49.08 63.99,49 63.99,48.04 63.87,47.91 63.73,47.91 63.64,48 63.64,49 63.55,49.08 63.37,49.08 63.28,49 63.28,48 63.19,47.91 63.04,47.91 62.93,48.02 62.93,49 62.84,49.08 62.66,49.08 62.57,49 62.57,48 62.48,47.91 62.3,47.91 62.22,48 62.22,49 62.13,49.08 61.95,49.08 61.86,49 61.86,48.32 61.76,48.22 61.61,48.22 61.5,48.33 61.5,49 61.42,49.08 61.28,49.08 61.07,48.88 60.89,48.88 58.2,51.57 v2(57.1,51.57)
  BOTTOM w0.102: CN2019.169 57.36,52.21 57.1,51.94 v2(57.1,51.57) ; U2030.AL27 81.47,49.67 v1(81.47,49.54)
M_A_DQ33: length 52.2
  IN1 w0.089: v1(82.94,49.54) 82.64,49.54 82.26,49.16 80.69,49.16 79.12,47.59 74.77,47.59 74.45,47.27 68.08,47.27 67.76,47.59 61.73,47.59 58.18,51.14 50.31,51.14 50.22,51.05 50.22,46.35 50.29,46.28 50.52,46.28 50.61,46.37 50.61,50.67 50.7,50.76 53.2,50.76 v2(53.62,50.35)
  BOTTOM w0.102: v2(53.62,50.35) 53.01,50.96 CN2019.174 ; v1(82.94,49.54) 83.31,49.91 U2030.AL25
M_A_DQ34: length 52.5
  IN1 w0.089: v1(82.18,46.51) 82.12,46.51 81.74,46.13 80.95,46.13 80.54,45.72 80.54,45.29 80.41,45.16 79.45,45.16 78.82,44.53 66.52,44.53 66.39,44.65 66.39,45.55 66.26,45.67 62.29,45.67 62.04,45.42 62.04,44.38 61.7,44.04 51.71,44.04 51.62,44.13 51.62,44.47 51.71,44.56 54.2,44.56 54.29,44.65 54.29,45.48 54.19,45.58 51.91,45.58 51.82,45.67 51.82,45.83 51.95,45.96 54.2,45.96 54.29,46.05 54.29,46.76 54.2,46.85 53.36,46.85 53.27,46.94 53.27,47.12 53.36,47.21 54.11,47.21 54.29,47.38 54.29,47.97 54.21,48.05 54.21,48.56 54.02,48.75 52.79,48.75 v2(52.39,48.35)
  BOTTOM w0.102: v1(82.18,46.51) 82.51,46.84 U2030.AP26 ; v2(52.39,48.35) 51.9,47.86 51.38,47.86 51.29,47.96 CN2019.186
M_A_DQ35: length 51.8
  IN1 w0.089: v1(80.91,46.5) 80.91,46.63 80.78,46.76 80.6,46.76 80.37,46.52 80.37,46.34 80.48,46.23 80.48,46.11 80.35,45.98 80.23,45.98 80.09,46.12 79.96,46.12 79.81,45.97 79.81,45.81 79.91,45.72 79.91,45.59 79.79,45.48 79.32,45.48 78.69,44.84 69.78,44.84 69.66,44.97 69.66,45.55 69.53,45.67 69.35,45.67 69.26,45.59 69.26,44.93 69.17,44.84 68.99,44.84 68.9,44.93 68.9,45.59 68.82,45.67 68.64,45.67 68.55,45.59 68.55,44.93 68.46,44.84 68.28,44.84 68.19,44.93 68.19,45.59 68.1,45.67 67.93,45.67 67.84,45.59 67.84,44.93 67.75,44.84 67.57,44.84 67.44,44.97 67.44,45.62 67.33,45.74 67.18,45.74 67.07,45.62 67.07,44.96 66.95,44.84 66.78,44.84 66.71,44.92 66.71,45.86 66.58,45.99 62.16,45.99 61.72,45.56 61.72,44.51 61.6,44.39 61.42,44.39 61.33,44.48 61.33,45.45 61.23,45.55 61.1,45.55 60.97,45.43 60.97,44.48 60.84,44.35 55.58,44.35 54.99,44.94 54.76,44.94 54.67,45.03 54.67,48.04 54.53,48.18 54.53,48.7 54.04,49.18 54.04,49.75 54.18,49.9 55.11,49.9 55.2,49.81 55.2,49.63 55.09,49.52 54.58,49.52 54.49,49.43 54.49,49.25 54.61,49.14 55.33,49.14 55.42,49.05 55.42,48.84 55.51,48.75 55.92,48.75 v2(56.32,48.35)
  BOTTOM w0.102: U2030.AR27 81.55,46.01 81.06,46.5 v1(80.91,46.5) ; v2(56.32,48.35) 56.97,47.71 CN2019.187
M_A_DQ36: length 51.7
  IN1 w0.089: v1(82.15,50.56) 81.87,50.28 81.16,50.28 81.04,50.15 80.33,50.15 79.24,49.06 73.92,49.06 73.58,49.4 73.25,49.4 73.13,49.53 73.13,49.85 72.95,50.02 67.9,50.02 67.78,49.9 67.78,49.81 67.69,49.72 67.51,49.72 67.42,49.81 67.42,49.94 67.33,50.02 67.16,50.02 67.07,49.94 67.07,49.81 66.98,49.72 66.8,49.72 66.71,49.81 66.71,49.91 66.62,50 66.44,50 66.35,49.91 66.35,49.82 66.26,49.73 66.09,49.73 66,49.82 66,49.91 65.91,50 65.73,50 65.64,49.91 65.64,49.82 65.55,49.73 65.38,49.73 65.29,49.82 65.29,49.96 65.2,50.05 65.02,50.05 64.93,49.96 64.93,49.82 64.84,49.73 64.66,49.73 64.57,49.82 64.57,50.11 64.49,50.2 64.31,50.2 64.22,50.11 64.22,49.82 64.11,49.72 63.95,49.72 63.86,49.81 63.86,50.11 63.77,50.2 63.6,50.2 63.51,50.11 63.51,49.82 63.4,49.72 63.24,49.72 63.15,49.81 63.15,50.11 63.06,50.2 62.89,50.2 62.8,50.11 62.8,49.82 62.71,49.73 62.53,49.73 62.44,49.82 62.44,50.11 62.35,50.2 62.17,50.2 62.09,50.11 62.09,49.81 62,49.72 61.82,49.72 61.73,49.81 61.73,50.11 61.64,50.2 61.46,50.2 61.37,50.11 61.37,49.81 61.28,49.72 61.11,49.72 61.02,49.81 61.02,50.11 60.93,50.2 60.46,50.2 58.23,52.44 55.87,52.44 55.78,52.35 55.78,52.04 55.69,51.95 55.51,51.95 55.42,52.04 55.42,52.35 55.33,52.44 55.15,52.44 55.07,52.35 55.07,52 54.98,51.91 54.82,51.91 54.71,52.02 54.71,52.35 54.62,52.44 54.44,52.44 54.35,52.35 54.35,52 54.27,51.91 54.09,51.91 54,52 54,52.35 53.91,52.44 53.73,52.44 53.64,52.35 53.64,52.02 53.55,51.94 53.38,51.94 53.29,52.02 53.29,52.35 53.2,52.44 53.02,52.44 52.93,52.35 52.93,51.84 53.05,51.73 53.05,51.57 52.97,51.49 52.68,51.49 52.58,51.59 52.58,52.35 52.49,52.44 50.61,52.44 50.23,52.06 50.23,51.55 50.32,51.46 50.48,51.46 50.61,51.59 50.61,51.93 50.73,52.06 50.94,52.06 51.09,51.9 51.27,51.9 51.42,52.06 52.08,52.06 52.17,51.97 v2(52.17,51.57)
  BOTTOM w0.102: U2030.AK26 82.51,50.92 v1(82.15,50.56) ; CN2019.170 51.24,51.96 51.47,52.18 52.03,52.18 52.17,52.04 v2(52.17,51.57)
M_A_DQ37: length 52.1
  IN1 w0.089: v1(84.54,50.56) 84.75,50.56 84.92,50.38 84.92,49.36 84.69,49.14 84.36,49.14 84.11,49.39 84.11,50.46 83.99,50.58 83.45,50.58 83.4,50.53 83.4,50.43 83.69,50.14 83.69,50.03 83.61,49.95 81.29,49.95 81.18,49.83 80.47,49.83 79.37,48.74 73.79,48.74 73.44,49.08 73.26,49.08 73.16,48.98 73.16,48.79 73.1,48.73 72.93,48.73 72.81,48.86 72.81,49.58 72.68,49.71 72.53,49.71 72.45,49.63 72.45,48.9 72.32,48.77 72.15,48.77 72.07,48.85 72.07,49.58 71.94,49.71 71.79,49.71 71.7,49.62 71.7,48.82 71.61,48.73 71.43,48.73 71.34,48.82 71.34,49.62 71.25,49.71 71.08,49.71 70.99,49.62 70.99,48.82 70.9,48.73 70.72,48.73 70.63,48.82 70.63,49.62 70.54,49.71 70.36,49.71 70.27,49.62 70.27,48.48 70.19,48.39 70.03,48.39 69.92,48.51 69.92,49.62 69.83,49.71 69.65,49.71 69.56,49.62 69.56,48.48 69.47,48.39 69.32,48.39 69.21,48.51 69.21,49.62 69.12,49.71 68.94,49.71 68.85,49.62 68.85,48.48 68.76,48.39 68.61,48.39 68.5,48.51 68.5,49.62 68.41,49.71 68.23,49.71 68.1,49.58 68.1,49.54 67.96,49.4 60.81,49.4 58.1,52.12 56.23,52.12 56.12,52.01 56.12,51.89 v2(55.8,51.57)
  BOTTOM w0.102: U2030.AK24 84.54,50.58 v1(84.54,50.56) ; v2(55.8,51.57) 56.33,51.04 57.21,51.04 57.38,51.21 CN2019.173
M_A_DQ38: length 52.6
  IN1 w0.089: v1(83.75,48.5) 84.14,48.12 84.14,46.47 83.63,45.96 82.02,45.96 81.78,45.72 81.78,45.2 81.52,44.94 80.76,44.94 80.66,44.84 79.59,44.84 78.95,44.21 66.3,44.21 66.07,44.44 66.07,45.23 65.95,45.36 62.52,45.36 62.36,45.2 62.36,44.25 61.83,43.72 51.35,43.72 51.22,43.85 51.22,46.72 51.38,46.87 52.87,46.87 52.96,46.96 52.96,47.15 52.87,47.24 51.59,47.24 51.5,47.33 51.5,47.51 51.59,47.6 53.65,47.6 53.77,47.71 v2(53.77,48.35)
  BOTTOM w0.102: v1(83.75,48.5) 84.11,48.86 U2030.AM24 ; CN2019.182 53.16,48.96 v2(53.77,48.35)
M_A_DQ39: length 52.8
  IN1 w0.089: v1(81.6,46.52) 81.88,46.8 81.88,47 81.77,47.1 81.47,47.1 81.34,46.98 81.09,46.98 80.96,47.1 80.5,47.1 78.56,45.16 75.3,45.16 75.2,45.26 75.2,45.57 75.07,45.69 74.89,45.69 74.79,45.59 74.79,45.27 74.68,45.16 74.55,45.16 74.42,45.29 74.42,45.86 74.29,45.99 74.11,45.99 74.02,45.9 74.02,45.25 73.94,45.16 73.76,45.16 73.67,45.25 73.67,45.9 73.58,45.99 73.4,45.99 73.31,45.9 73.31,45.25 73.22,45.16 73.05,45.16 72.96,45.25 72.96,45.9 72.87,45.99 72.69,45.99 72.6,45.9 72.6,45.25 72.51,45.16 72.34,45.16 72.25,45.25 72.25,45.9 72.16,45.99 71.98,45.99 71.85,45.86 71.85,45.29 71.72,45.16 71.54,45.16 71.42,45.29 71.42,45.9 71.33,45.99 71.13,45.99 71.04,45.9 71.04,45.25 70.95,45.16 70.77,45.16 70.68,45.25 70.68,45.9 70.6,45.99 70.42,45.99 70.33,45.9 70.33,45.25 70.24,45.16 70.06,45.16 69.97,45.25 69.97,45.9 69.88,45.99 67.52,45.99 67.2,46.31 62.03,46.31 61.59,45.87 60.89,45.87 60.64,45.63 60.64,44.76 60.55,44.67 57.89,44.67 57.67,44.89 57.49,44.89 57.27,44.67 55.72,44.67 55.15,45.24 55.15,45.45 55.28,45.58 55.51,45.58 55.76,45.33 55.94,45.33 56.2,45.58 57.41,45.58 57.51,45.68 57.51,46.05 57.36,46.19 57.22,46.19 56.98,45.96 55.14,45.96 55.05,46.05 55.05,47.87 55.16,47.97 55.16,48.12 v2(54.93,48.35)
  BOTTOM w0.102: v1(81.6,46.52) 81.81,46.73 U2030.AP27 ; CN2019.183 57.39,48.71 57.29,48.8 55.38,48.8 v2(54.93,48.35)
M_A_DQ40: length 52.7
  TOP w0.102: v2(56.84,46.46) 60.44,46.46 60.54,46.36 60.54,44.41 60.64,44.31 60.84,44.31 60.95,44.41 60.95,46.36 61.05,46.46 61.38,46.46 61.48,46.36 61.48,44.41 61.58,44.31 61.83,44.31 61.94,44.41 61.94,46.36 62.04,46.46 62.32,46.46 62.42,46.36 62.42,44.41 62.52,44.31 62.75,44.31 62.85,44.41 62.85,46.11 62.95,46.21 63.14,46.21 63.28,46.07 63.28,44.55 63.68,44.16 70.78,44.16 70.88,44.26 70.88,45.95 70.98,46.05 71.31,46.05 71.41,45.95 71.41,44.25 71.51,44.14 71.72,44.14 71.82,44.25 71.82,45.95 71.92,46.05 72.12,46.05 72.22,45.95 72.22,44.88 72.32,44.78 72.53,44.78 72.63,44.88 72.63,45.95 72.73,46.05 73.05,46.05 74.48,47.48 79.14,47.48 80.56,48.91 84.2,48.91 v1(84.54,48.56)
  BOTTOM w0.102: v2(56.84,46.46) 57.08,46.71 CN2019.191 ; U2030.AM23 84.91,48.93 v1(84.54,48.56)
M_A_DQ41: length 52.7
  TOP w0.102: v2(55.5,46.44) 55.95,46.9 62.92,46.9 63.61,46.2 63.61,44.69 63.82,44.49 67.12,44.49 67.22,44.59 67.22,46.11 67.32,46.21 67.52,46.21 67.63,46.11 67.63,44.59 67.73,44.49 67.93,44.49 68.03,44.59 68.03,46.11 68.13,46.21 68.34,46.21 68.44,46.11 68.44,44.59 68.54,44.49 68.74,44.49 68.84,44.59 68.84,46.11 68.95,46.21 69.15,46.21 69.25,46.11 69.25,44.59 69.35,44.49 69.56,44.49 69.66,44.59 69.66,46.11 69.76,46.21 69.96,46.21 70.06,46.11 70.06,44.59 70.17,44.49 70.42,44.49 70.55,44.61 70.55,46.28 70.65,46.38 72.79,46.38 74.85,48.44 79.63,48.44 80.35,49.16 85.39,49.16 v1(86.04,48.51)
  BOTTOM w0.102: U2030.AM21 86.51,48.98 v1(86.04,48.51) ; CN2019.195 57.39,45.71 57.26,45.58 56.36,45.58 v2(55.5,46.44)
M_A_DQ42: length 52.1
  TOP w0.102: v1(82.89,45.56) 82.4,45.07 80.41,45.07 80.31,44.97 80.31,44.21 80.2,44.11 80,44.11 79.9,44.21 79.9,44.87 79.77,44.99 79.59,44.99 79.47,44.87 79.47,44.2 79.34,44.08 79.13,44.08 78.9,44.31 78.11,44.31 78.01,44.21 78.01,43.6 77.91,43.5 77.71,43.5 77.61,43.6 77.61,44.21 77.5,44.31 74.55,44.31 70.62,40.38 70.44,40.38 70.14,40.68 69.93,40.68 69.83,40.58 69.83,40.14 69.73,40.04 65.95,40.04 65.32,39.41 63.97,39.41 63.79,39.23 63.79,38.93 63.66,38.8 63.33,38.8 63.23,38.9 63.23,39.38 63.08,39.53 62.87,39.53 62.74,39.4 62.74,38.93 62.62,38.8 62.44,38.8 62.32,38.93 62.32,39.43 62.19,39.56 61,39.56 60.79,39.76 60.79,40.51 60.69,40.62 60.5,40.62 60.36,40.49 60.36,39.69 60.24,39.56 60.06,39.56 59.93,39.69 59.93,40.75 59.8,40.88 59.62,40.88 59.5,40.75 59.5,39.05 59.27,38.82 58.53,38.82 58.38,38.98 58.38,43.01 57.77,43.62 55,43.62 53.86,42.48 v2(53.17,42.48)
  BOTTOM w0.102: v1(82.89,45.56) 82.89,45.59 U2030.AR25 ; v2(53.17,42.48) 53.17,42.51 52.22,43.46 CN2019.204
