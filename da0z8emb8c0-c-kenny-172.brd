# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5V on TOP (solid shape): 60.37,105.37 60.37,104.53 60.73,104.17 60.73,103.17 61.03,102.87 61.03,102.22 61.47,101.78 61.48,101.76 61.51,101.7 61.58,101.66 61.59,101.66 62.02,101.23 62.02,101.23 62.58,100.67 62.58,97.26 62.19,96.86 62.04,96.64 61.99,96.38 61.99,96.31 61.15,95.47 60.37,95.47 60.21,95.63 60.21,96.27 61.47,97.53 61.48,97.54 61.65,97.63 61.74,97.8 61.75,97.81 61.85,97.91 61.85,99.1 61.68,99.27 61.66,99.3 61.33,99.63 61.33,100.32 61.32,100.37 61.3,100.42 61.29,100.43 60.97,100.75 60.97,100.78 60.93,100.87 60.84,100.91 60.13,100.91 60.08,100.9 60.02,100.85 60,100.85 59.69,100.85 59.42,101.12 59.42,103.07 59.6,103.25 59.65,103.44 59.6,103.64 59.45,103.78 59.14,104.08 59.14,105.36 59.2,105.42 60.33,105.42
+5V on BOTTOM (solid shape): 18.05,30.45 18.05,28.47 17.99,28.4 16.09,28.4 15.78,28.71 15.78,30.22 16.08,30.52 17.99,30.52
+5V on BOTTOM (solid shape): 62.04,95.38 62.04,94.88 62.03,94.86 61.94,94.72 61.91,94.58 61.93,94.46 61.98,94.35 61.99,94.32 61.98,94.29 61.91,94.22 59.98,94.22 59.75,94.46 59.75,96.03 59.95,96.23 61.19,96.23
+5V on BOTTOM (solid shape): 216.05,16.28 216.05,14.74 215.89,14.58 214.49,14.58 214.42,14.66 214.4,14.66 214.4,14.67 213.56,14.67 213.53,14.7 213.53,14.92 213.54,14.96 213.58,14.97 214.4,14.97 214.4,15.17 213.58,15.17 213.54,15.18 213.53,15.22 213.53,15.42 213.54,15.46 213.58,15.47 214.4,15.47 214.4,15.67 213.58,15.67 213.54,15.68 213.53,15.72 213.53,15.97 213.53,15.97 214.4,15.97 214.4,15.98 214.55,15.98 214.64,16.07 214.64,16.24 214.91,16.51 215.83,16.51
+5V on BOTTOM (solid shape): 199.41,18.59 199.49,18.56 199.58,18.55 199.67,18.56 199.75,18.59 199.76,18.6 200.3,18.6 200.33,18.58 200.49,18.48 200.68,18.44 201.28,18.44 201.45,18.27 201.45,17.26 201.4,17.17 201.31,17.16 201.23,17.19 201.16,17.2 200.89,17.08 200.78,16.81 200.79,16.7 200.85,16.59 200.85,16.15 199.12,14.42 197.68,14.42 197.53,14.57 197.53,15.32 198.88,16.67 199.18,16.67 199.3,16.8 199.42,16.93 199.46,17.11 199.46,17.12 199.49,17.15 199.49,17.45 199.32,17.62 199.32,18.55 199.36,18.6 199.4,18.6
+5V on BOTTOM (solid shape): 123.66,19.74 123.66,17.82 123.66,17.46 122.93,16.73 122.93,16.25 122.51,15.83 122.51,15.35 121.76,14.59 115.2,14.59 115.12,14.68 115.12,15.88 115.12,15.9 115.14,15.92 115.18,15.95 115.25,15.98 115.32,15.95 115.43,15.88 115.57,15.86 115.84,15.97 115.95,16.24 115.94,16.32 115.92,16.39 115.93,16.49 116.01,16.54 116.05,16.54 116.07,16.53 116.08,16.52 116.21,16.41 116.38,16.37 116.52,16.39 116.63,16.46 116.7,16.49 117.02,16.37 117.33,16.49 117.65,16.37 117.97,16.49 118.04,16.46 118.15,16.39 118.29,16.37 118.42,16.39 118.54,16.47 118.61,16.49 118.93,16.37 119.26,16.49 119.33,16.47 119.44,16.39 119.58,16.37 119.75,16.41 119.9,16.53 119.92,16.54 121.23,16.54 121.33,16.64 121.33,18.18 121.95,18.79 122.01,18.88 122.05,18.97 122.05,18.99 122.08,19.01 122.08,19.7 122.24,19.86 123.54,19.86
+5V on BOTTOM (solid shape): outline of 253 points within 177.61,22.99 180.79,28.34
+5V on IN1 (solid shape): outline of 163 points within 14.77,84.67 31.71,98.97
+5V on IN1 (solid shape): outline of 1388 points within 177.69,16.29 202.42,31.86
+5V on IN2 (solid shape): outline of 7339 points within 15.04,13.47 95.13,86.53
+5V on SVCC (solid shape): outline of 414 points within 91.88,10.1 217.82,18.02
+5V on IN3 (solid shape): outline of 494 points within 29.94,93.21 62.24,96.68
+5V_HDMIC on TOP (solid shape): outline of 316 points within 11.13,78.42 15.54,85.54
+5V_KB on BOTTOM (solid shape): outline of 207 points within 196.78,11.54 205.31,16.3
+5V_S5 on TOP (solid shape): 23.77,19.04 23.77,17.73 23.71,17.67 23.05,17.67 22.58,17.2 21,17.2 20.98,17.23 20.98,18.89 20.99,18.95 21.01,19.01 21.11,19.12 23.69,19.12
+5V_S5 on TOP (solid shape): 18.06,27.94 18.06,26.09 18.12,26.04 18.12,26 18.23,25.72 18.5,25.61 18.54,25.61 19.14,25.01 19.33,25.01 19.37,25.02 21.84,25.02 21.89,25.01 22.07,25.01 22.28,24.8 22.28,22.99 21.74,22.45 21.38,22.45 21.38,22.45 20.91,22.45 20.9,22.45 20.71,22.45 20.56,22.6 16.5,22.6 16,23.1 16,25.52 15.73,25.8 15.73,27.72 16.14,28.13 17.86,28.13
+5V_S5 on TOP (solid shape): outline of 262 points within 15.53,38.45 24.32,44.06
+5V_S5 on BOTTOM (solid shape): 18.05,27.93 18.05,25.93 17.87,25.75 15.83,25.75 15.78,25.8 15.78,27.85 15.97,28.04 17.93,28.04
+5V_S5 on BOTTOM (solid shape): 22.58,24.4 22.58,23.51 22.35,23.28 21.68,23.28 21.49,23.09 19.14,23.09 19,22.96 19,22.38 18.85,22.24 17.63,22.24 17.25,22.61 17.25,23.73 17.27,23.75 17.27,24.21 17.48,24.43 19.15,24.43 19.67,24.95 22.03,24.95
+5V_S5 on BOTTOM (solid shape): 211.61,20.5 211.61,19.49 211.64,19.46 211.64,18.4 211.52,18.27 210.47,18.27 210.47,18.29 209.72,18.29 209.23,18.78 207.96,18.78 207.83,18.91 207.83,19.29 208.09,19.54 208.09,19.67 208.34,19.93 208.34,20.43 208.6,20.69 211.43,20.69
+5V_S5 on BOTTOM (solid shape): 24.43,44.01 24.43,43.15 24.06,42.78 20.96,42.78 20.78,42.96 20.78,43.58 20.82,43.62 21.25,43.62 21.31,43.61 21.37,43.6 21.43,43.61 21.49,43.62 22.09,43.62 22.63,44.16 24.29,44.16
+5V_S5 on BOTTOM (solid shape): 23.96,18.96 23.96,17.62 23.87,17.54 22.3,17.54 22.25,17.49 21.82,17.49 21.78,17.53 21.77,17.55 21.77,17.57 21.77,17.62 21.77,17.92 21.76,17.99 21.72,18.06 21.72,18.95 21.89,19.12 23.8,19.12
+5V_S5 on IN2 (solid shape): outline of 213 points within 200.85,12.43 209.74,20.56
+5V_S5 on IN2 (solid shape): outline of 1763 points within 24.58,8.03 103.12,16.43
+5V_S5 on SVCC (solid shape): 21.27,41.54 21.18,41.41 21.14,41.26 21.26,40.99 21.52,40.88 21.52,33.75 20.96,33.19 20.91,33.1 20.89,33.01 20.89,31.36 20.83,31.25 20.81,31.13 20.83,31.01 20.89,30.9 20.89,26.68 20.7,26.52 20.64,26.29 20.72,26.03 20.93,25.88 20.96,25.84 22.16,24.65 22.16,22.72 22.18,22.62 22.23,22.54 22.34,22.43 22.45,22.2 22.69,22.09 25.6,19.17 25.59,19.12 25.59,19.06 25.7,18.79 25.97,18.68 26.02,18.68 26.08,18.7 27.41,17.37 27.45,17.32 28.13,16.64 28.13,12.92 27.9,12.69 27.21,12.69 27.08,12.78 26.92,12.81 26.77,12.78 26.64,12.69 26.57,12.69 26.44,12.78 26.29,12.81 26.13,12.78 26,12.69 23.54,12.69 23.47,12.75 23.36,12.96 23.16,13.06 17.21,19.01 17.21,20.33 17.39,20.47 17.46,20.69 17.39,20.91 17.21,21.05 17.21,22.34 17.19,22.43 17.13,22.52 14.27,25.38 14.17,25.53 14.03,25.62 13.86,25.79 14.17,26.38 14.28,27.04 14.28,41.64 21.17,41.64
+5V_S5 on IN3 (solid shape): outline of 2812 points within 99.92,10.1 202.05,16.89
+5VODD on BOTTOM (solid shape): 127.96,19.66 132.88,19.66 133.03,19.51 133.03,18.28 133,18.24 133,17.1 132.9,17 132.75,17 132.71,17.02 132.7,17.05 132.7,17.94 132.5,17.94 132.5,17.05 132.49,17.02 132.45,17 132.25,17 132.21,17.02 132.2,17.05 132.2,17.94 132,17.94 132,17.05 131.99,17.02 131.95,17 131.75,17 131.71,17.02 131.7,17.05 131.7,17.94 131.5,17.94 131.5,17.05 131.49,17.02 131.45,17 131.25,17 131.21,17.02 131.2,17.05 131.2,17.94 131,17.94 131,17.05 130.99,17.02 130.95,17 130.75,17 130.71,17.02 130.7,17.05 130.7,17.94 130.5,17.94 130.5,17.05 130.49,17.02 130.45,17 130.25,17 130.21,17.02 130.2,17.05 130.2,17.94 130,17.94 130,17.05 129.99,17.02 129.95,17 129.86,17 129.73,17.13 129.73,18.02 129.6,18.15 124.39,18.15 124.14,18.4 124.14,19.8 124.27,19.93 127.7,19.93
+5VPCU on TOP (solid shape): 19.53,47.52 19.53,45.6 19.39,45.46 17.43,45.46 17.34,45.55 17.34,47.37 17.52,47.54 19.5,47.54
+5VPCU on TOP (solid shape): 24.71,30.84 24.71,30.07 24.47,29.84 24.47,29.57 24.46,29.52 24.45,29.47 24.45,29.28 23.93,28.76 22.91,28.76 22.85,28.82 22.85,31.26 22.91,31.33 24.22,31.33
+5VPCU on TOP (solid shape): 24.44,27.21 24.44,26.99 24.55,26.88 25.01,26.88 25.07,26.81 25.07,25.36 24.95,25.23 22.98,25.23 22.92,25.29 22.92,27.3 22.94,27.34 22.97,27.35 23.39,27.35 23.39,27.36 24.3,27.36
+5VPCU on BOTTOM (solid shape): 118.37,83.88 118.37,83.43 118.35,83.41 118.34,83.4 118.16,83.26 118.1,83.04 118.16,82.83 118.36,82.67 118.37,82.64 118.37,81.8 118.36,81.8 117.46,81.8 117.26,81.99 117.22,82.02 116.93,82.31 116.29,82.31 116.02,82.58 116.02,83.84 116.18,84 118.25,84
+5VPCU on BOTTOM (solid shape): outline of 967 points within 23.07,16.72 30.99,31.39
+5VPCU on IN1 (solid shape): outline of 1389 points within 26.48,8.03 186.97,20.05
+5VPCU on IN3 (solid shape): outline of 1373 points within 15.55,25.23 28.11,47.53
+V3A_LX on BOTTOM (solid shape): 149.6,34.85 150.26,34.85 150.52,34.59 150.52,31.2 150.31,31 149.69,31 148.36,29.67 147.59,29.67 147.27,29.99 147.27,30.5 147.11,30.66 145.9,30.66 145.84,30.72 145.84,32.77 146.04,32.97 147.33,32.97 147.91,33.55 147.91,35.75 147.98,35.82 148.63,35.82
+V3A_OUT on TOP (solid shape): 152.51,36.16 152.51,35.41 152.22,35.13 152.22,34.98 152.2,34.94 152.19,34.89 152.19,31.13 152.2,31.08 152.22,31.04 152.22,30.27 152,30.05 151.16,30.05 151,29.89 148.22,29.89 147.99,30.13 147.99,33.84 150.39,36.24 152.42,36.24
+V3A_OUT on BOTTOM (solid shape): 152.6,37.21 152.6,36.01 152.8,35.81 152.8,35.8 153.24,35.36 153.37,35.09 153.64,34.96 153.87,34.73 157.86,34.73 157.95,34.64 157.95,32.58 156.48,31.11 155.73,31.11 155.71,31.11 155.55,31.15 155.38,31.11 155.37,31.11 155.03,31.11 154.97,31.12 154.91,31.12 154.86,31.12 154.8,31.11 154.48,31.11 154.28,31.16 154.08,31.11 151.82,31.11 150.8,32.12 150.8,34.86 150.55,35.11 149.69,35.11 148.92,35.88 148.92,37.18 149.05,37.3 149.54,37.3 149.55,37.31 149.59,37.31 149.8,37.52 150.79,37.52 150.81,37.53 152.27,37.53
+V5P5A_LX on BOTTOM (solid shape): 41.89,22.36 41.89,21.8 42.08,21.61 42.19,21.61 43.46,20.34 43.46,18.91 43.26,18.71 41.75,18.71 41.31,18.27 41.31,16.45 41.29,16.42 40.91,16.42 40.84,16.49 40.84,17.11 40.48,17.47 38.79,17.47 38.3,17.96 38.3,20.43 40.45,22.58 41.66,22.58
+V5P5A_OUT on BOTTOM (solid shape): outline of 172 points within 27.7,14.59 37.98,25.69
+VCC_CORE on TOP (solid shape): 131.69,55.63 131.69,52.51 130.16,50.98 127.82,50.98 127.72,51.07 127.72,54.24 127.72,54.24 127.72,54.81 128.76,55.84 131.47,55.84
+VCC_CORE on TOP (solid shape): 107.21,57.62 107.21,57.21 107.09,57.09 104.1,57.09 104.06,57.11 104.05,57.15 104.05,57.72 104.02,57.89 103.92,58.03 103.81,58.14 103.81,58.35 103.88,58.42 106.4,58.42
+VCC_CORE on TOP (solid shape): outline of 5496 points within 88.64,50.81 121.56,71.28
+VCC_CORE on BOTTOM (solid shape): 122.96,71.56 122.96,67.96 123.42,67.5 123.46,67.5 123.99,67.5 124.47,67.02 124.47,63.74 124.69,63.52 127.28,63.52 127.69,63.11 127.69,60.3 127.65,60.26 125.77,60.26 125.77,59.75 127.17,59.75 127.67,59.25 127.67,57.25 128.92,56 131.36,56 131.71,55.65 131.71,53.16 131.15,52.6 130.76,52.6 130.28,53.07 128.92,53.07 128.92,52.59 129.68,52.59 129.92,52.35 129.92,50.79 129.6,50.47 123.51,50.47 121.77,52.21 121.74,52.31 121.82,52.38 122.01,52.51 122.09,52.73 122.06,52.87 121.98,52.98 121.97,53.02 121.98,53.06 122.06,53.17 122.09,53.31 121.98,53.57 121.73,53.67 121.51,53.6 121.38,53.42 121.37,53.38 120.73,53.38 120.54,53.57 120.54,54.77 121.05,55.84 121.22,57 120.05,59.83 117.22,61 117.11,61 117,60.99 116.92,61.02 116.89,61.1 116.89,65.01 116.36,65.54 114.29,65.54 114.12,65.7 114.12,67.04 114.14,67.08 114.31,67.44 114.12,67.78 114.12,71.52 114.46,71.86 122.66,71.86
+VCC_CORE on IN1 (solid shape): outline of 388 points within 105.11,62.09 112.46,67.8
+VCC_CORE on IN2 (solid shape): outline of 9083 points within 88.01,49.5 125.9,71.88
+VCC_CORE on SVCC (solid shape): outline of 127 points within 88.61,47.48 125.92,73.77
+VCCRTC_2 on TOP (solid shape): 99.26,31.3 99.29,31.29 99.31,31.25 99.31,31.25 99.33,31.13 99.38,31.03 99.38,30.05 99.27,29.94 98.84,29.94 98.78,30 98.78,30.68 98.49,30.97 98.49,31.23 98.56,31.3
+VDD_08 on TOP (solid shape): 96.38,118.5 96.38,117.74 94.09,115.45 94.09,112.86 93.79,112.56 92.57,112.56 92.37,112.76 92.37,115.15 92.14,115.38 92.14,118.07 92.26,118.2 93.43,118.2 94.45,119.21 95.67,119.21
+VDD_08 on TOP (solid shape): outline of 100 points within 105.42,108.19 116.77,110.83
+VDD_08 on BOTTOM (solid shape): 96.79,118.38 96.79,117.03 97.34,116.47 97.34,116.39 97.3,116.34 97.27,116.29 96.43,115.45 95.82,115.45 94.68,116.6 94.68,117.28 96.07,118.68 96.48,118.68
+VDD_08 on SVCC (solid shape): 101.15,120.13 101.27,119.86 101.53,119.75 101.8,119.86 101.92,120.13 102.45,120.13 102.58,119.94 102.8,119.87 103.03,119.94 103.16,120.13 106.89,120.13 107.03,120.02 107.2,119.98 107.37,120.02 107.5,120.13 114.21,120.13 114.33,120.03 114.49,120 114.64,120.03 114.77,120.13 116.03,120.13 116.27,119.9 116.27,110.2 115.91,109.84 105.86,109.84 105.72,110.04 105.49,110.12 105.26,110.04 105.13,109.84 105.01,109.84 104.87,110.06 104.63,110.15 104.39,110.06 104.26,109.84 98.23,109.84 98.12,110.11 97.85,110.22 97.58,110.11 97.47,109.84 96.05,109.84 95.93,110.09 95.67,110.2 95.41,110.09 95.29,109.84 93.89,109.84 93.28,110.45 93.28,117.74 94.22,118.68 94.28,118.76 94.3,118.86 94.3,119.64 94.78,120.13
+VDD_18 on TOP (solid shape): 87.64,50.66 87.71,50.63 87.85,50.35 88.07,50.26 88.15,50.27 88.23,50.3 88.28,50.3 88.32,50.29 88.33,50.25 88.33,48.89 88.2,48.75 87.57,48.75 87.19,49.13 87.19,50.59 87.26,50.66
+VDD_18 on TOP (solid shape): 84.26,30.47 84.26,29.71 84.02,29.59 83.93,29.35 83.93,29.3 83.94,29.25 83.8,29.12 83.77,29.12 83.73,29.13 83.47,29.02 83.37,28.76 83.37,28.73 83.47,28.48 83.71,28.37 83.73,28.37 83.75,28.34 83.75,26.4 82.99,25.64 82.48,25.64 82.48,25.66 80.69,25.66 80.45,25.89 80.45,28.94 82.36,30.85 83.88,30.85
+VDD_18 on BOTTOM (solid shape): 88.66,49.53 88.66,49.31 88.65,49.29 88.64,49.27 88.58,49.22 88.54,49.15 88.53,49.14 88.16,48.77 87.97,48.77 87.85,48.89 87.85,49.14 87.92,49.22 87.92,49.26 87.93,49.28 87.96,49.34 87.97,49.41 87.89,49.59 87.72,49.66 87.7,49.66 87.52,49.84 87.52,50.3 87.59,50.37 87.81,50.37
+VDD_18 on SVCC (solid shape): outline of 108 points within 81.09,29.45 92.14,50
+VDD_18_S5 on TOP (solid shape): 94.04,38.5 94.04,37.63 94,37.54 93.9,37.53 93.82,37.56 93.73,37.57 93.37,37.42 93.22,37.06 93.22,36.34 93.26,36.15 93.37,35.99 93.47,35.88 93.47,35.74 94.17,35.04 94.17,34.92 94.16,34.9 94.02,34.73 93.98,34.53 94.04,34.3 94.24,34.11 94.25,34.09 94.25,33.08 94.25,33.05 94.24,33.01 94.25,32.98 94.25,32.94 94.25,32.5 94.25,32.46 94.24,32.43 94.25,32.39 94.25,32.35 94.25,31.99 94.16,31.9 93.68,31.9 93.28,32.29 93.27,32.32 93.27,32.35 93.3,32.42 93.31,32.49 93.2,32.75 92.88,32.88 92.85,32.95 92.85,34 92.84,34.05 92.83,34.11 92.83,34.2 92.05,34.97 92.05,37.58 92.04,37.67 92,37.75 91.99,37.76 91.99,37.83 92,37.87 92.27,38 92.37,38.24 92.32,38.41 92.21,38.54 92.16,38.61 92.19,38.69 92.26,38.76 93.78,38.76
+VDD_18_S5 on BOTTOM (solid shape): 89.5,49.51 89.5,49.28 89.5,49.26 89.49,49.24 89.46,49.21 89.43,49.16 89.02,48.75 88.7,48.75 88.61,48.84 88.61,49.07 88.81,49.27 88.81,49.57 88.31,50.06 88.31,50.27 88.42,50.37 88.64,50.37
+VDD_18_S5 on SVCC (solid shape): outline of 81 points within 88.61,36.82 94.42,49.82
+VDDCI on TOP (solid shape): 90.65,124.69 91.96,124.69 92,124.67 92.01,124.64 92.08,124.48 92.21,124.36 92.27,124.29 92.24,124.2 92.16,124.08 92.14,123.94 92.25,123.67 92.52,123.56 92.68,123.59 92.81,123.69 92.88,123.73 92.96,123.7 93.25,123.41 93.26,123.39 93.26,123.31 93.26,123.2 93.6,121.58 94.52,120.2 94.52,119.65 93.53,118.65 92.92,118.65 92.57,119.01 89.13,119.01 89.01,119.13 89.01,122.23 89.05,122.32 89.14,122.33 89.2,122.32 89.26,122.31 89.53,122.42 89.64,122.69 89.61,122.84 89.53,122.96 89.5,123.03 89.53,123.11 89.75,123.33 89.77,123.33 89.87,123.36 89.97,123.42 90.04,123.45 90.1,123.42 90.23,123.33 90.38,123.3 90.76,123.68 90.38,124.07 90.34,124.06 90.26,124.09 90.23,124.16 90.23,124.65 90.28,124.7 90.63,124.7
+VDDCI on TOP (solid shape): outline of 177 points within 108.18,97.7 117.61,108.44
+VDDCI on BOTTOM (solid shape): 93.29,122.86 93.29,122.84 94.07,120.82 95.74,119.44 95.76,119.42 95.77,119.39 95.77,118.91 94.42,117.56 93.87,117.56 92.97,118.46 90.38,118.46 90.28,118.55 90.28,120.16 90.43,120.16 90.43,120.36 90.37,120.43 90.28,120.43 90.28,120.59 89.74,120.59 89.58,120.75 89.58,122.48 89.62,122.58 89.64,122.69 89.64,122.73 89.63,122.78 89.64,122.8 89.89,123.06 93.08,123.06
+VDDCI on IN1 (solid shape): outline of 2195 points within 107.63,98.01 117.64,108.71
+VDDCI on IN2 (solid shape): outline of 7922 points within 92.75,98.03 117.7,122.69
+VDDCI on IN3 (solid shape): outline of 3773 points within 92.81,97.75 117.74,122.45
+VDDCR_SOC on TOP (solid shape): 92.88,81.27 92.88,79.98 92.67,79.77 90.37,79.77 90.26,79.87 90.26,81.15 90.5,81.38 92.78,81.38
+VDDCR_SOC on TOP (solid shape): outline of 363 points within 118,74.15 133.96,81.5
+VDDCR_SOC on TOP (solid shape): outline of 360 points within 86.24,59 92.31,66.59
+VDDCR_SOC on BOTTOM (solid shape): 112.42,81.07 112.42,79.86 112.33,79.76 112.28,79.64 112.16,79.52 111.31,79.52 110.97,79.87 109.38,79.87 109.17,79.66 106.71,79.66 106.4,79.97 106.4,81.13 106.48,81.21 112.28,81.21
+VDDCR_SOC on BOTTOM (solid shape): 92.83,81.48 92.83,80.14 92.68,80 89.95,80 89.88,80.03 89.85,80.1 89.85,80.12 89.74,80.39 89.47,80.5 89.26,80.44 89.12,80.28 89.05,80.22 88.96,80.25 88.59,80.62 88.59,81.45 88.75,81.61 92.69,81.61
+VDDCR_SOC on BOTTOM (solid shape): 129.14,79.85 130,79.85 130.16,79.69 130.16,79.46 130.12,79.38 130.04,79.36 129.98,79.36 129.71,79.25 129.6,78.98 129.63,78.85 129.7,78.73 129.72,78.66 129.7,78.6 129.63,78.48 129.6,78.35 129.71,78.08 129.98,77.96 130.16,78.01 130.3,78.13 130.37,78.17 130.45,78.14 130.48,78.12 130.86,78.12 130.93,78.1 131,78.09 131.06,78.1 131.14,78.12 131.81,78.12 131.88,78.1 131.95,78.09 132.01,78.1 132.09,78.12 132.75,78.12 132.99,77.88 132.99,75.64 132.8,75.45 131.96,75.45 131.96,73.6 131.78,73.41 129.24,73.41 128.86,73.79 124.22,73.79 123.86,74.15 123.86,74.6 123.87,74.6 123.87,79.28 124.21,79.62 128.17,79.62 128.65,80.1 128.89,80.1
+VDDCR_SOC on BOTTOM (solid shape): outline of 683 points within 86.59,58.82 92.61,66.64
+VDDCR_SOC on IN2 (solid shape): 120.35,80.3 120.35,79.84 119.86,79.36 119.11,79.36 119.11,74.6 123.87,74.6 123.87,79.18 123.88,79.22 123.92,79.23 126.73,79.23 128.17,77.79 128.88,77.79 129.06,77.61 129.06,76.74 129.06,73.37 128.72,73.03 117.68,73.03 117.29,73.42 117.29,75.94 117.3,76 117.31,76.05 117.3,76.11 117.29,76.17 117.29,78.11 118.26,79.08 118.26,79.25 118.27,79.31 118.27,79.36 118.27,79.41 118.26,79.47 118.26,80.12 118.71,80.58 120.07,80.58
+VDDCR_SOC on SVCC (solid shape): outline of 477 points within 83.15,59.27 128.97,83.3
+VDDQ_P on TOP (solid shape): 51.41,124.58 51.47,124.57 51.53,124.58 51.6,124.59 53,124.59 53.06,124.58 53.12,124.57 53.18,124.58 53.25,124.59 54.6,124.59 54.66,124.58 54.72,124.57 54.78,124.58 54.85,124.59 56.17,124.59 56.24,124.58 56.3,124.57 56.36,124.58 56.42,124.59 56.53,124.59 56.87,124.25 56.87,120.67 57.14,120.4 58.21,120.4 59.28,119.33 61.63,119.33 61.89,119.07 61.89,118.33 61.81,118.25 58.48,118.25 57.65,119.07 55.93,119.07 55.28,119.72 52,119.72 50.79,120.94 49.81,120.94 49.81,120.94 49.69,120.94 49.52,121.11 49.52,122.64 49.65,122.77 50.99,122.77 50.99,124.39 51.19,124.59 51.35,124.59
+VDDQ_P on BOTTOM (solid shape): 57.61,123.87 57.61,121.39 56.87,120.65 52.99,120.65 52.99,120.71 52.95,120.81 52.86,120.85 51.23,120.85 51.14,120.81 51.1,120.71 51.1,120.65 49.77,120.65 49.56,120.87 49.56,122.61 49.76,122.81 50.93,122.81 51.08,122.96 51.08,123.92 51.36,124.2 57.28,124.2
+VDDQ_VTT on TOP (solid shape): 49.97,31.61 50.48,31.61 50.61,31.48 50.61,30.14 50.59,30.1 50.56,30.09 47.86,30.09 47.83,30.1 47.81,30.14 47.81,30.92 47.82,30.97 47.82,31.95 48.32,32.45 48.36,32.49 48.39,32.5 49.08,32.5
+VDDQ_VTT on TOP (solid shape): 41.97,92.57 41.97,90.54 41.84,90.41 30.8,90.41 30.2,89.81 30.19,89.81 30.14,89.78 30.12,89.74 30.11,89.73 30.03,89.65 30.03,89.27 30.41,88.89 30.41,81.65 30.29,81.52 29.91,81.52 29.78,81.39 29.78,80.89 29.91,80.76 30.29,80.76 30.41,80.63 30.41,79.14 30.4,79.11 30.36,79.09 29.28,79.09 29.23,79.09 29.17,79.07 28.97,78.95 28.89,78.73 28.9,78.67 28.91,78.61 28.9,78.51 28.82,78.47 27.62,78.47 27.5,78.59 27.5,92.45 27.75,92.7 41.85,92.7
+VDDQ_VTT on BOTTOM (solid shape): 49.23,32.35 49.23,30.19 49.34,30.08 51.05,30.08 51.08,30.07 51.1,30.03 51.1,29.87 51.08,29.85 49.38,29.85 49.25,29.72 48.49,29.72 48.19,30.01 48.19,31.81 48.88,32.5 49.08,32.5
+VIN on TOP (solid shape): 138.75,56 138.75,55.47 138.19,54.92 138.19,54.69 137.74,54.23 137.74,54.14 137.63,54.03 137.22,54.03 137.14,54.11 137.14,54.93 138.38,56.16 138.6,56.16
+VIN on TOP (solid shape): 137.33,61.33 137.33,58.99 136.94,58.6 136.68,58.6 136.45,58.83 136.45,59.75 136.6,59.9 136.6,60.93 136.61,60.97 136.61,61.27 136.6,61.33 136.72,61.44 137.22,61.44
+VIN on TOP (solid shape): outline of 9207 points within 53.28,14.77 144.73,125.15
+VIN on BOTTOM (solid shape): 74.94,104.29 74.94,100.43 74.58,100.07 69.61,100.07 69.15,100.53 69.15,103.02 69.26,103.13 72.05,103.13 73.03,104.11 73.36,104.11 73.68,104.43 74.8,104.43
+VIN on BOTTOM (solid shape): 83.37,122.35 83.37,120.63 82.91,120.17 78.92,120.17 78.6,119.84 78.6,119.36 78.33,119.08 76.95,119.08 76.7,119.34 76.7,120.3 76.71,120.31 77.19,120.31 78.08,121.19 79.5,121.19 79.88,121.57 79.88,122.24 80.06,122.42 83.3,122.42
+VIN on BOTTOM (solid shape): 134.38,69.4 134.38,63.17 134.23,63.02 129.76,63.02 129.01,63.76 125.06,63.76 124.73,64.09 124.73,67.03 124.13,67.63 123.51,67.63 123.21,67.93 123.21,68.33 123.32,68.44 124.85,68.44 125.07,68.66 128.54,68.66 129.65,69.77 134.01,69.77
+VIN on BOTTOM (solid shape): 123.31,39.26 123.31,36.86 123.52,36.65 124.96,36.65 125.48,36.13 127.69,36.13 127.83,35.99 127.83,34.03 127.69,33.89 125.28,33.89 125.06,33.67 120.81,33.67 120.48,34 120.48,39.24 120.57,39.33 123.24,39.33
+VIN on BOTTOM (solid shape): 143.11,36.94 143.11,36.29 142.77,35.94 142.77,35.26 142.73,35.18 142.64,35.16 142.6,35.16 142.56,35.17 142.37,35.11 142.23,34.98 138.96,34.98 138.9,34.96 138.86,34.93 138.86,36.27 138.93,36.34 140.27,36.34 140.97,37.04 143.02,37.04
+VIN on BOTTOM (solid shape): 141.68,61.67 141.68,59.77 142,59.44 143.68,59.44 144.07,59.05 144.07,57.64 143.98,57.56 143.58,57.56 143.47,57.46 143.47,55.66 143.41,55.6 141.78,55.6 141.77,55.61 141.46,55.3 141.46,54.89 140.91,54.35 140.91,52.33 141.09,52.15 141.43,52.15 141.69,51.89 141.69,50.92 141.93,50.68 143.04,50.68 143.1,50.61 143.1,47.3 143.09,47.29 141.61,47.29 141.59,47.29 141.57,47.3 141.29,47.43 141,47.3 140.98,47.29 140.96,47.29 140.56,47.29 140.3,47.55 140.3,48.85 139.48,49.67 139.48,54.51 138.23,55.75 138.23,56.5 138.22,56.52 138.22,56.54 138.14,56.62 138.11,56.62 138.08,56.65 137.15,56.65 136.35,57.45 136.35,61.55 136.57,61.77 137.47,61.77 137.69,61.55 137.69,59.79 137.96,59.51 138.51,59.51 138.93,59.1 139.97,59.1 140.42,59.55 140.42,60.49 140.18,60.73 140.05,60.73 139.98,60.79 139.98,61.38 139.88,61.48 139.36,61.48 139.13,61.71 139.13,62.77 139.25,62.89 140.45,62.89
+VIN on BOTTOM (solid shape): outline of 364 points within 48.08,13.11 78.15,16.53
+VIN_BLIGHT on TOP (solid shape): 65.34,109.03 65.34,108.2 65.87,107.68 65.88,107.67 65.94,107.55 66.05,107.47 66.07,107.45 66.07,107.43 66.07,106.69 66.04,106.64 66,106.58 65.94,106.51 64.35,106.51 64.09,106.25 63.18,106.25 63,106.43 63,108.22 63.44,108.65 63.44,109.07 63.51,109.15 65.23,109.15
+VIN_BLIGHT on BOTTOM (solid shape): 64.87,108.14 64.87,107.13 64.22,106.49 64.22,105.95 64.12,105.85 62.71,105.85 62.57,105.98 62.57,106.71 63.07,106.71 63.07,107.54 62.87,107.54 62.87,106.71 62.57,106.71 62.57,107.87 63.02,108.32 64.69,108.32
+VIN_GPU on BOTTOM (solid shape): outline of 84 points within 74.09,93.07 81.61,114.42
GND on TOP (solid shape): 75.34,113.36 75.34,109.95 75.28,109.88 71.88,109.88 71.76,110 71.76,113.3 71.91,113.44 75.26,113.44
GND on TOP (solid shape): 98.47,87.49 98.47,84.06 98.42,84.02 95.03,84.02 94.93,84.13 94.93,87.45 95.03,87.56 98.39,87.56
GND on TOP (solid shape): 105.39,42.55 105.39,42.44 105.35,42.4 105.34,42.34 105.34,41.96 105.02,41.96 103.83,43.14 103.81,43.26 103.91,43.32 104.63,43.32
GND on TOP (solid shape): 117.3,118.68 117.39,118.62 117.37,118.51 113.11,114.25 113,114.23 112.94,114.32 112.94,114.83 116.79,118.68
GND on TOP (solid shape): 123.58,97.17 124.09,97.17 124.52,96.74 124.52,96.26 124.46,96.16 124.35,96.18 122.43,98.11 122.42,98.16 122.46,98.19 122.56,98.19
GND on TOP (solid shape): 90.05,41.93 90.09,41.97 90.14,41.96 91.02,41.09 91.02,39.95 90.51,39.44 90.4,39.41 90.33,39.51 90.33,41.21 90.05,41.49
GND on TOP (solid shape): 94.97,72.45 95.07,72.39 95.05,72.28 94.15,71.39 93.75,71.39 93.5,71.14 93.39,71.12 93.33,71.22 93.33,71.29 94.5,72.45
GND on TOP (solid shape): 100.75,74.52 100.86,74.54 100.92,74.44 100.92,74.08 100.11,73.27 98.98,73.27 98.89,73.33 98.91,73.44 99.7,74.23 100.47,74.23
GND on TOP (solid shape): 93.35,76.46 93.35,76.45 93.42,76.34 93.51,76.26 93.51,76.03 90.72,73.25 90.61,73.22 90.55,73.32 90.55,73.72 91.05,74.22 91.2,74.22 93.22,76.23 93.22,76.42 93.31,76.51
GND on TOP (solid shape): 99.66,43.24 101.08,43.24 101.46,42.86 103.29,42.86 103.65,42.5 103.67,42.39 103.58,42.33 101.99,42.33 101.61,42.71 99.96,42.71 99.48,43.19 99.53,43.24 99.59,43.24 99.65,43.25
GND on TOP (solid shape): 207.72,17.45 207.72,17.23 207.73,17.19 207.75,17.15 207.76,17.12 207.75,17.09 207.73,17.05 207.31,17.05 207.17,17.18 206.19,17.18 206.19,17.58 206.19,17.6 206.21,17.68 206.29,17.71 207.46,17.71
GND on TOP (solid shape): 25.08,113.97 25.17,113.91 25.15,113.8 23.07,111.72 20.99,111.72 20.46,112.25 19.39,112.25 19.25,112.12 19.14,112.1 19.08,112.19 19.08,113.12 19.93,113.97
GND on TOP (solid shape): 140.71,107.41 140.79,107.34 140.76,107.23 140.23,106.7 140.23,105.86 140.22,105.84 139.7,105.84 139.6,105.84 139.55,105.93 139.55,106.28 140.68,107.41
GND on TOP (solid shape): 36.06,41.26 36.1,41.35 36.2,41.36 36.25,41.34 36.31,41.34 36.4,41.35 36.72,41.02 36.72,40.1 36.82,40 36.75,39.93 36.71,39.96 36.65,40.01 36.58,40.03 36.55,40.03 36.1,40.9 36.06,41.01
GND on TOP (solid shape): 93.81,73.16 93.91,73.1 93.88,72.99 92.21,71.32 92.18,71.33 92.11,71.36 92.04,71.36 91.99,71.36 91.94,71.35 91.85,71.37 91.81,71.45 91.81,71.83 93.15,73.16
GND on TOP (solid shape): 90.92,37.76 91.03,37.78 91.1,37.68 91.1,37.66 91.34,37.41 91.34,35.26 91.21,35.13 91.15,35.14 91.12,35.14 91.07,35.14 91.02,35.12 90.93,35.14 90.89,35.22 90.89,37.72
GND on TOP (solid shape): 104.03,50.48 104.13,50.42 104.1,50.31 103,49.2 99.27,49.2 99.18,49.25 99.18,49.35 99.21,49.43 99.22,49.52 99.22,49.55 99.21,49.61 99.45,49.85 100.34,49.85 100.97,50.48
GND on TOP (solid shape): 77.53,52.32 77.62,52.27 77.63,52.18 77.61,52.12 77.61,52.05 77.61,51.97 77.64,51.9 77.63,51.8 77.54,51.76 77.11,51.76 76.76,52.11 74.58,52.11 74.48,52.18 74.5,52.29 74.53,52.32
GND on TOP (solid shape): 79.36,67.33 79.39,67.38 79.45,67.37 79.51,67.31 79.51,66.84 80.61,65.75 81.09,65.75 81.17,65.7 81.18,65.61 81.17,65.56 81.16,65.5 81.17,65.42 81.2,65.34 81.2,65.24 81.11,65.19 80.91,65.19 79.36,66.73
GND on TOP (solid shape): 79,70.14 79,69.76 80.89,67.88 80.99,67.88 81.08,67.83 81.08,67.73 81.05,67.66 81.04,67.58 80.97,67.49 80.87,67.52 78.35,70.04 78.35,70.29 78.06,70.58 78.04,70.69 78.13,70.75 78.4,70.75
GND on TOP (solid shape): 81.1,44.89 81.19,44.84 81.19,44.74 81.15,44.65 81.14,44.56 81.14,44.53 81.15,44.47 80.03,43.34 78.26,43.34 78.16,43.41 78.18,43.52 78.19,43.52 78.19,44.13 78.83,44.13 79.06,43.9 79.41,43.9 79.68,44.17 79.93,43.93 80.28,43.93 80.48,44.13 80.48,44.89
GND on TOP (solid shape): 172.69,20.69 172.78,20.63 172.78,20.53 172.72,20.42 172.71,20.31 172.73,20.18 172.79,20.06 172.82,19.99 172.79,19.92 172.24,19.37 169.66,19.37 169.56,19.44 169.58,19.55 170.72,20.69
GND on TOP (solid shape): 63.17,18.41 63.17,18.35 64.11,18.35 64.11,18.41 64.19,18.45 64.24,18.4 64.24,17.51 64.15,17.42 63.65,17.42 63.44,17.21 63.44,16.85 63.09,16.5 61.73,16.5 61.4,16.82 61.4,17.82 61.43,17.85 64.11,17.85 64.11,18.05 63.17,18.05 63.17,17.85 61.43,17.85 61.99,18.4 62.2,18.4 62.64,18.4 63,18.4 63.06,18.46
GND on TOP (solid shape): 43.96,124.33 43.96,123.8 42.88,122.72 37.45,122.72 36.97,122.23 36.97,121.86 36.86,121.81 36.66,122.01 36.58,122.01 36.58,122.09 36.6,122.1 36.72,122.24 36.77,122.41 36.74,122.56 36.65,122.68 36.23,123.11 36.23,123.49 36.24,123.52 36.24,123.55 36.24,124.33 36.24,124.4 43.96,124.4
GND on TOP (solid shape): 99.17,80.95 99.42,81.14 99.67,80.95 99.7,80.81 101.23,80.81 101.9,80.14 101.92,80.03 101.83,79.97 101.38,79.97 100.71,80.64 99.31,80.64 99.25,80.7 96.42,80.7 96.39,80.72 96.38,80.78 96.43,80.81 99.14,80.81
GND on TOP (solid shape): 58.89,42.98 58.95,43.08 59.06,43.06 59.13,42.99 59.81,42.99 60.55,42.25 60.57,42.14 60.47,42.07 60.19,42.07 59.94,41.83 59.89,41.82 59.85,41.86 59.85,41.93 59.63,42.15 59.22,42.15 59.06,41.99 58.95,41.97 58.89,42.06
GND on TOP (solid shape): 81.08,47.75 81.16,47.71 81.18,47.62 81.17,47.58 81.16,47.54 81.17,47.46 80.99,47.28 80.38,47.28 78.75,45.65 78.66,45.63 78.58,45.69 78.54,45.78 78.47,45.86 78.44,45.97 78.53,46.04 78.88,46.04 80.59,47.75
GND on TOP (solid shape): 104.13,59.38 104.14,59.32 104.1,59.29 104.07,59.29 103.95,59.26 103.87,59.16 103.82,59.14 103.78,59.16 103.75,59.21 103.75,59.44 103.19,59.99 102.64,59.99 102.53,60.04 102.42,60.06 102.31,60.04 102.21,59.99 100.9,59.99 100.9,60.81 101.15,61.05 102.46,61.05
GND on TOP (solid shape): 187.05,17.3 187.15,17.25 187.26,17.23 187.37,17.25 187.47,17.3 187.94,17.3 187.99,17.26 187.97,17.21 187.92,17.15 187.92,16.21 187.5,15.79 186.63,15.79 186.54,15.84 186.55,15.95 186.59,16.02 186.6,16.09 186.6,16.39 186.59,16.48 186.54,16.55 186.54,17.3
GND on TOP (solid shape): 60.6,80.97 60.64,81.05 60.73,81.06 60.77,81.05 60.77,79.79 60.78,79.78 60.8,79.67 60.71,79.61 59.35,79.61 59.26,79.67 59.28,79.78 59.8,80.3 59.8,80.32 59.87,80.41 59.98,80.39 60.04,80.33 60.39,80.33 60.6,80.53
GND on TOP (solid shape): 91.15,28.26 91.24,28.29 91.31,28.23 91.45,28.08 91.65,28.02 91.7,28.03 91.75,28.04 91.84,28.02 91.88,27.94 91.88,27.37 91.91,27.34 91.93,27.23 91.84,27.16 89.93,27.16 89.57,27.52 89.57,28.05 89.67,28.15 91.04,28.15
GND on TOP (solid shape): 82.51,45.91 82.59,45.86 82.59,45.75 82.55,45.66 82.54,45.56 82.54,45.53 82.55,45.47 82.33,45.25 80.33,45.25 80.13,45.04 80.13,45.01 80.1,44.97 80.04,44.98 79.85,45.17 79.52,45.17 79.29,44.94 79.29,44.28 79.26,44.26 79.21,44.26 78.97,44.49 78.8,44.49 78.71,44.55 78.73,44.66 79.98,45.91
GND on TOP (solid shape): 43.66,101.98 43.77,102.01 43.84,101.91 43.84,101.22 43.83,101.21 43.81,101.16 43.8,101.1 43.8,100.8 43.81,100.74 43.84,100.68 43.85,100.67 43.85,100.09 43.84,100.08 43.81,100.02 43.8,99.96 43.8,99.66 43.8,99.61 43.82,99.57 43.83,99.54 43.69,99.4 42.73,99.4 42.67,99.4 42.62,99.38 42.52,99.39 42.48,99.48 42.48,99.81 43.01,100.34 43.01,101.34
GND on TOP (solid shape): 167.27,32.93 167.27,31.92 167.27,31.91 167.29,31.8 167.2,31.74 167,31.74 166.77,31.74 166.7,31.81 166.59,31.81 166.5,31.87 166.51,31.98 166.54,32.04 166.56,32.11 166.56,32.25 166.56,33.01 166.55,33.07 166.54,33.13 166.55,33.22 166.64,33.26 166.94,33.26
GND on TOP (solid shape): 112.71,109.41 112.71,108.9 112.86,108.74 112.89,108.63 112.79,108.57 112.7,108.57 112.69,108.58 112.6,108.61 112.51,108.62 112.41,108.61 112.32,108.57 111.88,108.57 111.63,108.83 111.52,108.83 111.34,108.9 111.26,109.08 111.27,109.14 111.24,109.21 111.22,109.32 111.31,109.38 111.67,109.38 111.77,109.48 112.63,109.48
GND on TOP (solid shape): 81.17,63.92 82.56,63.92 82.65,63.87 82.65,63.77 82.62,63.69 82.61,63.61 82.62,63.56 82.63,63.52 82.61,63.43 82.53,63.38 81.31,63.38 78.24,66.46 77.59,66.46 77.5,66.5 77.49,66.6 77.51,66.66 77.52,66.73 77.51,66.79 77.5,66.85 77.51,66.95 77.59,66.99 78.09,66.99
GND on TOP (solid shape): 29.02,78.44 29.05,78.43 29.14,78.38 29.25,78.37 29.42,78.37 29.43,78.38 31.94,78.38 31.94,78.3 31.87,78.26 31.83,78.23 31.76,78.21 31.7,78.23 31.67,78.25 31.63,78.26 31.43,78.26 31.36,78.23 31.33,78.15 31.33,77.77 31.3,77.69 31.22,77.66 28.98,77.66 28.84,77.79 28.84,78.34 28.88,78.35 28.94,78.38 28.99,78.42
GND on TOP (solid shape): 80.74,69.76 81.07,69.76 81.15,69.71 81.16,69.62 81.15,69.56 81.14,69.49 81.14,69.44 81.16,69.38 81.14,69.29 81.06,69.25 80.65,69.25 79.87,70.04 79.87,70.25 78.68,71.44 78.48,71.44 78.4,71.48 78.38,71.57 78.39,71.62 78.4,71.66 78.39,71.71 78.38,71.76 78.4,71.85 78.48,71.89 78.61,71.89
GND on TOP (solid shape): 88.81,43.44 88.83,43.37 88.8,43.3 88.72,43.19 88.69,43.06 88.7,42.99 88.45,42.74 88.45,40.6 88.83,40.22 88.83,39.52 88.63,39.31 88.57,39.22 88.47,39.22 88.38,39.26 88.28,39.28 88.22,39.27 88.16,39.26 88.06,39.27 88.02,39.35 88.02,42.27 88.07,42.32 88.07,42.9 88.64,43.46 88.79,43.46
GND on TOP (solid shape): 96.59,43.94 96.66,44.03 96.77,44.01 96.82,43.95 97.19,43.95 97.78,43.37 98.79,43.37 98.98,43.18 99.01,43.08 98.93,43.01 98.72,42.89 98.64,42.66 98.67,42.5 98.77,42.38 98.8,42.27 98.71,42.2 98.15,42.2 96.59,43.76
GND on TOP (solid shape): 63.95,77.28 64.06,77.31 64.13,77.21 64.13,76.98 64.33,76.77 64.68,76.77 64.91,77 65.14,76.77 65.5,76.77 65.73,77 65.96,76.77 66.31,76.77 66.54,77 66.77,76.77 67.12,76.77 67.35,77 67.58,76.77 67.93,76.77 68.16,77 68.4,76.77 69.67,76.77 69.73,76.7 69.74,76.65 69.69,76.62 56.75,76.62 56.66,76.67 56.66,76.77 56.69,76.86 56.7,76.95 56.7,76.99 56.69,77.06 56.83,77.2 63.87,77.2
GND on TOP (solid shape): 41.68,99.65 41.73,99.56 41.73,97.91 41.64,97.83 41,97.83 40.56,97.39 40.56,96.94 40.18,96.94 40.18,97.39 39.75,97.83 39.6,97.83 39.52,97.88 39.51,97.98 39.53,98 39.6,98.06 39.69,98.03 39.72,97.99 40.54,97.99 41.03,98.49 41.03,99.53 41.08,99.62 41.18,99.62 41.27,99.59 41.36,99.58 41.47,99.6 41.57,99.64
GND on TOP (solid shape): 81.1,48.73 81.18,48.69 81.2,48.6 81.19,48.56 81.19,48.51 81.19,48.47 81.2,48.43 81.18,48.34 81.1,48.3 80.36,48.3 78.65,46.58 76.92,46.58 76.84,46.63 76.82,46.72 76.84,46.78 76.84,46.85 76.81,47 76.72,47.13 76.69,47.24 76.79,47.31 79.22,47.31 80.64,48.73
GND on TOP (solid shape): 124.33,94.72 124.33,94.39 124.3,94.32 124.23,94.29 123.99,94.19 123.88,93.96 123.81,93.87 123.71,93.89 122.8,94.8 122.8,95.56 122.09,96.27 121.41,96.27 121.33,96.31 121.31,96.4 121.33,96.46 121.33,96.52 121.33,96.58 121.31,96.64 121.33,96.73 121.41,96.77 122.28,96.77
GND on TOP (solid shape): 57.44,44.99 57.76,44.67 58.47,44.67 58.79,44.98 58.79,45.4 58.95,45.4 58.95,44.59 60.17,43.37 60.78,43.37 60.78,42.7 61.06,42.41 61.07,42.36 61.03,42.33 60.97,42.33 59.95,43.34 59.28,43.34 58.13,44.49 55.38,44.49 55.38,44.87 55.43,44.92 55.99,44.92 56.13,44.77 56.32,44.71 56.59,44.83 56.7,45.1 56.7,45.18 56.67,45.26 56.68,45.35 56.76,45.4 57.44,45.4
GND on TOP (solid shape): 101.8,40.49 101.79,40.42 101.79,40.37 101.83,40.2 101.94,40.07 101.97,39.96 101.87,39.89 101.67,39.89 101.63,39.88 101.59,39.86 101.51,39.86 101.45,39.85 101.39,39.83 101.36,39.82 101.33,39.84 101.2,39.95 101.03,39.99 100.98,39.99 100.91,39.98 99.22,41.67 99.2,41.78 99.29,41.84 100.45,41.84
GND on TOP (solid shape): 184.68,22.07 184.72,22 184.8,21.97 185.16,21.97 185.18,21.91 185.17,21.89 185.17,21.82 184.85,21.82 184.76,21.78 184.72,21.69 184.72,21.52 184.57,21.37 183.94,21.37 183.86,21.29 183.83,21.31 183.8,21.32 183.77,21.33 183.39,21.33 183.33,21.31 183.28,21.28 183.17,21.28 183.09,21.31 183.07,21.39 183.07,21.45 183.06,21.52 183.04,21.59 183.05,21.68 183.14,21.73 184.11,21.73 184.49,22.11 184.67,22.11
GND on TOP (solid shape): 89.25,42.75 89.29,42.66 89.29,41.84 89.29,41.83 89.29,41.17 89.57,40.89 89.57,39.22 89.36,39.01 89.36,33.04 89.14,32.82 89.14,32.08 89.05,31.98 88.95,31.96 88.88,32.03 88.82,32.17 88.7,32.27 88.65,32.35 88.68,32.43 88.76,32.51 88.76,32.98 88.98,33.2 88.98,39.16 89.19,39.37 89.19,40.36 88.81,40.74 88.81,42.6 88.95,42.73 89.02,42.73 89.09,42.73 89.15,42.75
GND on TOP (solid shape): 97.53,37.24 97.53,37.19 97.57,37.1 97.66,37.07 98.04,37.07 98.1,37.08 98.14,37.12 98.3,37.12 98.3,36.87 98.3,36.85 98.31,36.81 98.31,36.64 97.75,36.64 97.61,36.5 97.5,36.48 97.43,36.57 97.43,36.63 97.4,36.72 97.31,36.76 96.92,36.76 96.86,36.74 96.81,36.69 96.8,36.66 96.53,36.66 96.23,36.97 96.23,37.22 96.16,37.29 96.15,37.34 96.19,37.37 97.4,37.37
GND on TOP (solid shape): 17.84,20.23 17.89,20.21 17.95,20.2 18.21,20.2 18.55,19.86 18.55,19.09 18.95,18.7 18.95,18.33 18.8,18.33 18.8,18.37 18.6,18.58 18.02,18.58 17.92,18.48 17.43,18.48 17.34,18.54 17.36,18.65 17.43,18.77 17.46,18.91 17.41,19.11 17.26,19.25 17.26,19.47 17.3,19.47 17.37,19.52 17.4,19.6 17.4,19.8 17.39,19.84 17.41,19.93 17.49,19.97 17.53,19.97 17.81,20.24
GND on TOP (solid shape): 88.5,73.25 88.61,73.27 88.68,73.18 88.68,69.69 88.26,69.28 88.26,69.16 88.21,69.07 88.12,69.06 88.06,69.09 87.86,69.29 87.86,69.93 87.9,70.01 87.99,70.03 88.03,70.02 88.08,70.02 88.34,70.12 88.44,70.37 88.35,70.61 88.13,70.73 88.08,70.73 88.08,72.83
GND on TOP (solid shape): 89.32,64.92 89.78,64.46 89.81,64.45 89.92,64.37 89.97,64.23 89.9,64.07 89.74,64.01 89.6,64.05 89.52,64.16 89.51,64.19 89.18,64.52 88.69,64.52 88.34,64.17 88.33,64.13 88.24,64.02 88.11,63.98 87.95,64.05 87.88,64.21 87.93,64.34 88.04,64.43 88.07,64.44 88.5,64.87 88.5,65.21 89.32,65.21
GND on TOP (solid shape): 113.48,50.71 115.41,50.71 115.45,50.68 115.45,50.63 115.42,50.58 113.43,50.58 112.38,51.63 111.55,51.63 110.1,50.18 110.02,50.18 110.02,50.25 110.03,50.26 110.1,50.37 110.12,50.49 110.1,50.62 110.03,50.73 110.01,50.79 110.03,50.86 110.1,50.97 110.12,51.09 110.06,51.29 109.89,51.42 109.83,51.5 109.86,51.59 110.43,52.16 112.03,52.16
GND on TOP (solid shape): 115.85,97.57 115.89,97.54 115.88,97.49 115.85,97.45 115.85,96.8 115.76,96.71 115.76,96.7 115.73,96.66 115.09,96.02 115.06,95.97 115.05,95.91 115.05,95.87 114.97,95.69 114.79,95.62 114.63,95.67 114.54,95.82 114.53,95.85 114.52,95.88 114.5,95.95 114.53,96.01 115.33,96.81 115.33,97.48 115.32,97.49 115.31,97.54 115.36,97.57
GND on TOP (solid shape): 134.68,100.56 134.82,100.42 135.01,100.37 135.05,100.37 135.11,100.38 135.51,99.98 135.85,99.98 136.06,100.19 136.08,100.19 136.15,100.13 136.15,100.1 135.94,99.89 135.94,99.55 136.23,99.26 136.57,99.26 136.78,99.48 136.8,99.48 136.87,99.41 136.87,99.39 136.65,99.17 136.65,98.83 141.07,94.41 141.07,93.04 141.03,92.95 140.93,92.94 140.86,92.97 140.78,92.98 140.74,92.97 140.68,92.96 140.52,93.13 140.52,94.79 135.31,100 134.55,100 134.54,100.01 134.54,100.27 134.42,100.38 134.4,100.49 134.49,100.56
GND on TOP (solid shape): 94.78,108.07 94.81,108.11 94.87,108.1 95.24,107.73 95.66,107.73 95.8,107.58 96,107.53 96.15,107.56 96.28,107.66 96.3,107.67 96.37,107.67 96.37,107.57 96.24,107.44 96.22,107.36 96.23,107.28 96.15,107.1 95.97,107.02 95.81,107.08 95.72,107.23 95.71,107.29 95.39,107.61 95.31,107.61 95.2,107.63 95.1,107.7 94.78,108.01
GND on TOP (solid shape): 120.78,28.09 120.86,28.05 120.87,27.95 120.85,27.88 120.84,27.8 121.22,27.42 121.6,27.8 121.59,27.88 121.57,27.95 121.58,28.05 121.66,28.09 128.74,28.09 128.85,27.98 129.48,27.98 129.81,27.65 129.81,27.09 120.05,27.09 119.95,27.15 119.97,27.26 120.08,27.37 120.08,28.09
GND on TOP (solid shape): 49.09,52.67 49.18,52.58 49.19,52.55 49.28,52.5 49.55,52.5 49.62,52.52 49.64,52.54 49.66,52.55 49.7,52.56 50.05,52.56 50.1,52.58 50.2,52.58 50.25,52.5 50.25,51.52 50.21,51.47 50.2,51.41 50.2,50.41 49.98,50.19 48.64,50.19 48.55,50.18 48.47,50.15 48.37,50.15 48.32,50.24 48.32,52.65 48.35,52.7 48.41,52.69 48.42,52.68 48.83,52.68 48.86,52.69 48.91,52.7 48.96,52.71
GND on TOP (solid shape): 106.72,107.54 106.72,106.85 106.59,106.79 106.56,106.77 106.52,106.75 106.49,106.76 106.03,106.77 105.9,106.33 105.91,106.31 105.89,106.27 105.75,106.14 104.5,106.14 104.39,106.25 104.37,106.29 104.37,106.31 104.39,106.56 104.26,106.76 104.24,106.8 104.25,106.83 104.27,106.89 104.28,106.95 104.28,107.46 104.32,107.5 104.33,107.54 106.64,107.54
GND on TOP (solid shape): 106.78,49.59 106.87,49.53 106.85,49.42 103.48,46.05 103.42,46.06 103.39,46.06 103.14,45.96 103.03,45.71 103.04,45.66 103.05,45.61 103.03,45.52 102.95,45.48 102.58,45.48 102.56,45.51 102.43,45.65 102.24,45.7 102.06,45.65 101.92,45.5 101.85,45.45 101.76,45.48 100.83,46.4 101.05,46.62 103.15,46.62 106.12,49.59
GND on TOP (solid shape): 134.73,91.49 135.24,91.49 135.89,90.84 135.89,90.19 135.95,90.13 135.97,90.02 135.88,89.96 135.06,89.96 134.53,90.49 134.5,90.58 134.55,90.65 134.71,90.79 134.76,90.99 134.65,91.26 134.38,91.38 134.32,91.37 134.26,91.36 134.17,91.37 134.13,91.45 133.81,91.77 133.79,91.88 133.88,91.95 134.27,91.95
GND on TOP (solid shape): 41.2,120.2 41.25,120.21 41.28,120.16 41.28,120.07 41.33,120.02 41.33,119.57 41.37,119.48 41.46,119.44 42.4,119.44 42.47,119.46 42.51,119.52 42.53,119.56 42.65,119.56 42.66,119.55 42.76,119.51 42.86,119.49 42.97,119.51 43.07,119.56 43.11,119.57 43.14,119.55 43.19,119.51 43.25,119.49 43.31,119.49 43.4,119.43 43.38,119.32 43.27,119.21 40.79,119.21 40.79,119.2 40.73,119.19 40.7,119.24 40.7,119.7
GND on TOP (solid shape): 77.99,70.14 77.99,69.89 81.06,66.81 81.09,66.81 81.18,66.77 81.19,66.68 81.17,66.61 81.16,66.55 81.17,66.49 81.18,66.44 81.17,66.35 81.09,66.31 80.82,66.31 80.06,67.07 80.06,67.53 78.49,69.1 77.89,69.1 77.81,69.15 77.8,69.24 77.83,69.32 77.84,69.4 77.79,69.57 77.67,69.7 77.62,69.79 77.67,69.88 77.8,69.99 77.86,70.16 77.86,70.17 77.91,70.22
GND on TOP (solid shape): 89.81,75.45 89.85,75.44 89.86,75.4 89.85,75.35 89.86,75.27 89.89,75.19 89.91,75.16 88.03,73.28 87.92,73.26 87.86,73.35 87.86,74.32 87.94,74.41 88.03,74.43 88.11,74.38 88.25,74.21 88.45,74.15 88.72,74.27 88.84,74.54 88.83,74.6 88.82,74.66 88.83,74.75 88.91,74.79 89.08,74.79 89.75,75.46
GND on TOP (solid shape): 90.87,53.88 91.13,53.88 91.18,53.94 91.25,53.99 91.34,54.01 91.48,53.95 91.54,53.81 91.5,53.69 91.4,53.62 91.37,53.6 91.32,53.56 91.26,53.52 91.2,53.51 90.92,53.51 90.88,53.42 90.1,53.42 90.05,53.51 89.85,53.51 89.79,53.52 89.73,53.56 89.68,53.6 89.64,53.62 89.55,53.69 89.51,53.81 89.57,53.95 89.71,54.01 89.76,54.01 89.8,53.99 89.96,53.97 90.09,54.06 90.87,54.06
GND on TOP (solid shape): 91.32,30.84 92.33,30.84 92.33,30.04 92.3,29.97 92.22,29.94 92.2,29.94 91.95,29.84 91.85,29.58 91.85,29.54 91.86,29.48 90.9,28.51 90.65,28.51 90.57,28.56 90.56,28.65 90.58,28.73 90.59,28.82 90.46,29.12 90.16,29.25 90.07,29.24 89.99,29.21 89.89,29.22 89.84,29.31 89.84,29.72 89.84,29.74 89.84,31.04 90.14,31.34 90.83,31.34
GND on TOP (solid shape): 65.56,120.22 65.52,120.14 65.39,120.14 65.39,119.54 65.52,119.54 65.56,119.47 65.56,119.24 65.73,119.06 65.72,119.03 65.71,119 65.7,118.97 65.7,118.32 65.71,118.29 65.69,118.21 65.61,118.17 64.77,118.17 64.78,118.27 64.78,118.57 64.75,118.67 64.68,118.75 64.64,118.82 64.66,118.9 64.71,119 64.74,119.11 64.74,119.13 64.99,119.39 64.99,119.5 65.01,119.54 65.14,119.54 65.14,120.14 65.01,120.14 64.97,120.22 65.01,120.3 65.52,120.3
GND on TOP (solid shape): 85,63.73 85.51,63.73 85.6,63.69 85.61,63.61 85.6,63.56 85.6,63.52 85.7,63.28 85.93,63.19 85.98,63.19 86.03,63.2 86.13,63.19 86.17,63.11 86.17,62.9 86.13,62.83 86.06,62.8 85.95,62.8 85.72,63.03 84.72,63.03 84.61,63.14 84.58,63.23 84.64,63.31 84.79,63.43 84.85,63.61 84.83,63.71 84.79,63.8 84.86,63.87
GND on TOP (solid shape): 163.22,32.88 163.32,32.86 163.45,32.73 163.6,32.73 163.68,32.69 163.7,32.6 163.69,32.56 163.69,32.18 163.71,32.12 163.74,32.08 163.74,31.9 163.71,31.86 163.69,31.8 163.69,31.42 163.72,31.34 163.79,31.29 163.81,31.29 164.02,31.08 164.02,30.72 164.43,30.31 164.45,30.2 164.36,30.14 164.22,30.14 163.71,30.64 163.46,30.64 163.45,30.68 163.41,30.76 163.33,30.78 163.13,30.78 163.13,31.02 163.13,31.04 163.13,32.18 163.13,32.2 163.13,32.73 163.15,32.8
GND on TOP (solid shape): 101.84,41.97 103.62,41.97 104.08,41.51 104.07,41.45 104.07,41.07 104.11,40.98 104.2,40.94 104.4,40.94 104.47,40.96 104.52,41.02 104.53,41.05 104.57,41.05 104.66,40.99 104.64,40.88 104.57,40.81 104.53,40.82 103.88,40.82 103.8,40.79 103.75,40.72 103.74,40.68 103.65,40.68 103.64,40.72 103.59,40.79 103.51,40.82 103.31,40.82 103.22,40.78 103.18,40.69 103.18,40.37 103.11,40.3 102.8,40.3 102.78,40.32 102.78,40.65 101.25,42.18 101.23,42.29 101.32,42.35 101.46,42.35
GND on TOP (solid shape): 170.7,31.92 170.7,31.83 170.66,31.75 170.57,31.74 170.53,31.74 170.15,31.74 170.07,31.71 170.03,31.62 170.02,31.58 169.92,31.58 169.92,31.65 169.91,31.67 169.86,31.72 169.8,31.74 169.42,31.74 169.37,31.73 169.13,31.97 168.81,31.97 168.76,31.96 168.71,31.94 168.7,31.93 168.63,31.93 168.63,32.01 168.81,32.18 168.88,32.17 168.92,32.17 169.19,32.28 169.3,32.55 169.28,32.68 169.22,32.79 169.2,32.9 169.3,32.95 169.66,32.95
GND on TOP (solid shape): 148.68,114.73 148.7,114.67 148.6,114.58 148.6,114.34 148.39,114.34 148.24,114.19 148.24,113.35 147.68,113.35 147.59,113.25 147.53,113.31 147.54,113.33 147.45,113.61 147.19,113.73 147.14,113.78 147.11,113.88 147.05,113.96 146.96,114.05 146.93,114.18 147,114.36 147.18,114.43 147.27,114.42 147.35,114.37 147.39,114.33 147.77,114.33 147.87,114.38 148.26,114.4 148.64,114.77
GND on TOP (solid shape): 68.13,119.95 69.36,119.95 69.54,119.95 69.59,119.98 69.79,120.09 70.02,120.13 70.06,120.13 70.29,120.08 70.5,119.97 70.5,119.68 70.45,119.59 70.34,119.6 70.2,119.75 69.88,119.75 69.46,119.32 69.46,119.17 69.45,119.14 69.43,119.11 68.92,119.11 68.83,119.09 68.76,119.05 68.4,119.05 68.34,119.11 68.06,119.11 67.92,119.26 67.91,119.26 67.41,119.76 67.41,119.77 67.34,119.83 67.35,119.91 67.35,120.09 67.34,120.13 67.33,120.16 67.34,120.25 67.43,120.3 67.78,120.3
GND on TOP (solid shape): 119.75,110.03 119.84,109.99 119.85,109.89 119.83,109.83 119.82,109.76 119.91,109.53 120.14,109.41 120.22,109.34 120.2,109.24 120.15,109.19 120.15,109.14 120.12,109.08 120.05,109.04 119.92,109.01 119.81,108.92 119.79,108.9 119.72,108.9 119.72,108.98 119.68,109.07 119.59,109.1 119.18,109.1 118.97,109.32 118.94,109.41 119,109.49 119.15,109.62 119.21,109.82 119.21,109.89 119.34,110.03
GND on TOP (solid shape): 132.82,115.3 132.9,115.26 132.92,115.17 132.9,115.11 132.9,115.05 132.91,114.96 132.94,114.87 132.96,114.84 132.89,114.78 132.82,114.84 132.41,114.84 132.17,114.61 132.17,113.8 132.16,113.79 131.53,113.79 131.36,113.63 131.3,113.64 131.27,113.64 131,113.53 130.88,113.26 130.89,113.22 130.9,113.16 128.99,111.25 123.43,111.25 122.83,110.66 122.83,109.59 121.67,108.43 121.25,108.43 121.17,108.47 121.16,108.56 121.17,108.61 121.17,108.66 121.16,108.75 121.13,108.83 121.13,108.93 121.22,108.98 121.92,108.98 122.38,109.43 122.38,110.65 123.39,111.67 128.88,111.67 132.51,115.3
GND on TOP (solid shape): 42.29,103.77 42.37,103.72 42.38,103.63 42.36,103.56 42.35,103.49 42.46,103.24 42.71,103.13 42.79,103.14 42.86,103.17 42.96,103.16 43.01,103.08 43.01,102.67 43.07,102.67 43.07,102.45 42.51,101.89 42.41,101.87 42.34,101.94 42.2,102.14 41.97,102.22 41.9,102.21 41.83,102.2 41.73,102.21 41.69,102.3 41.7,102.32 41.7,102.63 41.68,102.7 41.64,102.77 41.61,102.81 42.07,103.27 42.07,103.65 42.19,103.77
GND on TOP (solid shape): 124.17,113 124.26,112.95 124.25,112.84 124.19,112.73 124.17,112.6 124.18,112.48 124.24,112.38 124.24,112.27 124.15,112.22 123.17,112.22 121.83,110.88 121.83,109.66 121.69,109.52 121.27,109.52 121.19,109.57 121.17,109.66 121.19,109.71 121.19,109.77 121.09,110.02 120.83,110.13 120.7,110.1 120.58,110.02 120.51,109.98 120.43,110.01 120.35,110.08 120.25,110.11 120.23,110.12 120.19,110.16 120.28,110.26 121.02,110.26 121.54,110.78 121.54,110.99 123.55,113
GND on TOP (solid shape): 92.36,40.28 92.43,40.38 92.54,40.35 94.42,38.47 94.42,38.09 95.64,36.87 95.64,36.57 95.5,36.44 95.44,36.25 95.41,36.19 95.34,36.16 94.45,36.16 94.11,36.5 94.11,37.06 94.09,37.18 94.03,37.29 94.01,37.37 94.06,37.43 94.14,37.52 94.17,37.63 94.17,38.55 94.07,38.65 94.01,38.74 93.92,38.8 93.84,38.89 92.2,38.89 92.1,38.78 92.05,38.72 92.03,38.64 92.02,38.61 91.99,38.59 91.91,38.58 91.83,38.55 91.73,38.55 91.68,38.64 91.68,38.7 92.36,39.39
GND on TOP (solid shape): 139.43,110.35 139.46,110.31 139.47,110.26 139.42,110.23 132.49,110.23 128.64,106.38 128.54,106.35 128.47,106.42 128.34,106.61 128.13,106.68 127.88,106.57 127.77,106.32 127.78,106.26 127.79,106.2 127.78,106.11 127.7,106.07 127.18,106.07 127.1,106.12 127.09,106.21 127.12,106.29 127.13,106.37 127.1,106.5 127.04,106.61 127.02,106.72 127.11,106.78 128.64,106.78 132.21,110.35
GND on TOP (solid shape): 33.15,83.15 33.67,83.15 34.19,82.63 34.17,82.55 34.17,82.51 34.27,82.26 34.52,82.15 34.61,82.16 34.65,82.13 34.65,82.06 34.66,82.02 34.64,81.93 34.56,81.89 33.86,81.89 33.81,81.94 33.82,82.03 33.71,82.28 33.46,82.38 33.27,82.33 33.14,82.18 32.84,82.18 31.96,83.06 31.96,83.74 31.37,84.34 30.97,84.34 30.97,84.39 30.94,84.45 30.87,84.48 30.54,84.48 30.54,84.66 30.87,84.66 30.94,84.68 30.97,84.75 30.97,84.8 31.49,84.8
GND on TOP (solid shape): 40.43,75.83 40.52,75.86 40.59,75.8 40.7,75.65 40.87,75.58 40.88,75.57 41.13,75.33 41.2,75.28 41.28,75.25 41.35,75.21 41.37,75.15 41.37,75.11 41.35,75.04 41.28,75 41.13,74.93 41.05,74.77 41.01,74.71 40.94,74.68 40.91,74.68 40.84,74.71 40.8,74.77 40.71,74.94 40.53,75.01 40.44,74.99 40.36,74.96 40.26,74.95 40.2,75.04 40.2,75.45 40.12,75.53
GND on TOP (solid shape): 94.17,42.63 94.21,42.55 94.21,42.52 94.23,42.49 94.24,42.44 94.25,42.39 94.24,42.34 94.23,42.3 94.21,42.26 94.21,40.41 94.29,40.24 94.48,40.19 94.71,40.08 94.69,39.82 94.68,39.8 94.65,39.73 94.66,39.65 94.7,39.58 95.84,38.44 95.86,38.44 95.95,38.38 95.94,38.27 95.91,38.24 95.89,38.2 95.81,38.15 95.73,38.18 95.34,38.57 95.34,38.74 93.71,40.37 93.71,42.46 93.9,42.64 93.96,42.63 93.99,42.63 94.04,42.64 94.08,42.64
GND on TOP (solid shape): 116.06,102.73 116.29,102.5 116.75,102.5 116.82,102.43 116.85,102.4 116.9,102.35 116.91,102.31 116.93,102.22 116.91,102.13 116.9,102.11 116.9,100.23 115.85,99.17 113.35,99.17 112.84,99.68 112.84,99.91 112.84,99.99 113.28,99.99 113.32,100.02 114.13,100.02 114.18,99.99 114.49,99.99 114.53,99.99 114.93,99.99 114.97,100.02 115.74,100.02 116.08,100.35 116.08,102.19 115.74,102.53 113.75,102.53 113.7,102.47 113.69,102.47 113.63,102.42 113.61,102.35 113.61,102.15 113.61,102.12 113.62,102.09 113.62,101.99 113.57,101.94 112.97,101.94 112.84,102.07 112.84,102.71 112.8,102.8 112.71,102.83 111.09,102.83 111,102.8 110.96,102.71 110.96,102.12 110.78,101.94 110.64,101.94 110.56,101.93 110.45,101.81 107.73,101.81 107.71,101.84 107.71,103.49 107.76,103.54 115.19,103.54 115.3,103.66 115.3,104.09 115.46,104.25 116.06,104.25
GND on TOP (solid shape): 62.61,58.68 62.75,58.55 62.93,58.51 63,58.51 63.09,58.42 63.71,58.42 63.79,58.37 63.79,58.27 63.76,58.18 63.75,58.09 64.13,57.71 64.51,58.09 64.5,58.18 64.46,58.27 64.46,58.37 64.55,58.42 65.42,58.42 65.52,58.36 65.49,58.25 65.4,58.16 65.4,57.64 65.36,57.6 63.37,57.6 62.47,58.51 62.44,58.62 62.54,58.68
