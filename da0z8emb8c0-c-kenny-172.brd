# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN1 (solid shape): 39.68,49.68 39.74,49.59 39.74,49.11 38.42,47.79 38.42,47.18 38.69,46.91 38.96,46.91 39.02,46.86 39.01,46.83 39,46.78 38.99,46.73 39.09,46.49 39.32,46.39 39.41,46.33 39.39,46.22 39.38,46.21 39.38,38.58 39.33,38.49 39.23,38.49 39.14,38.53 39.05,38.55 39.02,38.54 38.98,38.54 38.91,38.55 38.86,38.62 38.8,38.76 38.68,38.86 38.63,38.95 38.69,39.04 38.83,39.17 38.89,39.36 38.84,39.54 38.7,39.67 38.65,39.76 38.7,39.84 38.83,39.97 38.88,40.15 38.78,40.4 38.46,40.54 38.44,40.61 38.44,43.32 38.48,43.32 38.71,43.44 38.8,43.67 38.76,43.82 38.67,43.95 38.63,44.02 38.66,44.1 38.71,44.15 38.71,46.12 37.95,46.89 37.95,47.95 39.07,49.07 39.07,49.49 39.11,49.58 39.21,49.59 39.27,49.57 39.33,49.57 39.46,49.59 39.57,49.67
GND on IN1 (solid shape): 83.27,84.15 83.33,84.25 83.44,84.23 84.26,83.4 84.29,83.31 84.24,83.24 84.09,83.11 84.03,82.92 84.14,82.67 84.39,82.56 84.58,82.62 84.71,82.76 84.79,82.82 84.87,82.79 85.18,82.49 85.21,82.4 85.15,82.32 85,82.19 84.95,82 85.05,81.75 85.38,81.62 85.51,81.29 85.76,81.19 85.95,81.24 86.08,81.39 86.16,81.45 86.25,81.42 86.55,81.12 86.58,81.03 86.52,80.95 86.37,80.82 86.32,80.63 86.42,80.38 86.68,80.27 86.87,80.33 87,80.48 87.07,80.53 87.16,80.51 87.45,80.22 87.45,79.24 89.45,77.23 90.63,77.23 91.77,76.09 91.77,75.99 91.71,75.89 91.6,75.92 90.85,76.66 89.74,76.66 86.7,79.71 86.7,79.93 83.27,83.36
GND on IN1 (solid shape): 35.9,41.36 35.96,41.46 36.07,41.44 36.18,41.36 36.31,41.34 36.4,41.35 36.47,41.37 36.57,41.37 36.62,41.28 36.62,40.95 36.83,40.73 36.93,40.73 37.02,40.67 37,40.56 36.87,40.43 36.87,37 35.6,35.73 35.6,35.67 35.57,35.63 35.52,35.63 35.42,35.69 35.3,35.71 35.25,35.71 35.2,35.7 35.17,35.69 34.75,36.11 34.75,36.46 34.81,36.55 34.92,36.54 35.02,36.48 35.14,36.46 35.5,36.82 35.14,37.17 35.02,37.15 34.92,37.09 34.81,37.08 34.75,37.17 34.75,37.35 34.81,37.44 34.92,37.43 35.02,37.37 35.14,37.35 35.19,37.35 35.24,37.36 35.27,37.37 35.48,37.16 35.59,37.16 35.68,37.11 35.67,37 35.64,36.91 35.62,36.82 35.98,36.46 36.33,36.82 36.31,36.94 36.25,37.05 36.23,37.12 36.25,37.18 36.66,37.59 36.66,40.31 35.9,41.07
GND on IN1 (solid shape): 99.49,44.08 99.52,43.98 99.45,43.91 99.29,43.79 99.22,43.6 99.32,43.36 99.55,43.27 99.61,43.27 99.66,43.28 99.75,43.27 99.79,43.19 99.79,43.06 99.47,42.74 99.38,42.71 99.3,42.78 99.18,42.93 98.99,42.99 98.76,42.89 98.66,42.66 98.72,42.47 98.88,42.35 98.94,42.28 98.91,42.18 98.56,41.83 97.94,41.83 97.86,41.86 97.84,41.95 97.84,42.01 97.51,42.34 97.18,42.01 97.23,41.83 97.37,41.71 97.42,41.64 97.4,41.55 97.08,41.23 96.44,41.23 94.02,38.82 94.02,38.8 94,38.75 93.94,38.76 93.87,38.8 93.78,38.82 93.7,38.89 93.73,38.99 94.1,39.37 94.1,39.9 95.92,41.72 96.33,41.72 98.68,44.08 98.68,44.14 98.73,44.23 98.83,44.24 98.89,44.22 98.96,44.21 99.08,44.24 99.19,44.31 99.23,44.34
GND on IN1 (solid shape): outline of 165 points within 64.63,32.59 69.26,34.63
GND on IN1 (solid shape): 25.19,38.27 25.19,37.77 25.4,37.56 25.65,37.56 25.76,37.67 25.78,37.67 25.85,37.68 25.92,37.72 26.03,37.72 26.08,37.63 26.08,37.16 25.81,36.9 25.72,36.87 25.64,36.94 25.51,37.11 25.31,37.17 25.06,37.07 24.95,36.82 25.02,36.61 25.19,36.48 25.25,36.41 25.23,36.31 24.88,35.97 24.88,33.47 26.09,32.26 26.11,32.15 26.01,32.09 25.97,32.09 25.8,32.06 25.67,31.95 25.59,31.92 25.51,31.95 25.39,32.05 25.24,32.09 25.17,32.13 25.15,32.21 25.16,32.25 25.16,32.29 24.75,32.7 24.34,32.29 24.45,32.02 24.72,31.89 24.79,31.85 24.81,31.77 24.8,31.73 24.8,31.69 24.89,31.44 25.11,31.29 25.17,31.24 25.18,31.16 25.16,31.1 25.09,31.02 24.99,31.04 24.21,31.82 24.21,36.59 24.97,37.36 24.97,38.27 25.01,38.31 25.15,38.31
GND on IN1 (solid shape): outline of 86 points within 97.39,28.4 107.26,56.35
GND on IN1 (solid shape): outline of 84 points within 113.12,23.25 166.82,27.42
GND on IN1 (solid shape): 64.91,54.98 64.99,54.93 65,54.84 64.99,54.78 64.98,54.72 65.34,54.37 65.7,54.72 65.69,54.78 65.68,54.84 65.69,54.93 65.77,54.98 66.18,54.98 66.26,54.93 66.27,54.84 66.26,54.78 66.25,54.72 66.61,54.37 66.97,54.72 66.96,54.78 66.95,54.84 66.96,54.93 67.04,54.98 67.45,54.98 67.53,54.93 67.54,54.84 67.53,54.78 67.52,54.72 67.88,54.37 68.24,54.72 68.23,54.78 68.22,54.84 68.23,54.93 68.31,54.98 70.3,54.98 70.85,54.43 70.87,54.32 70.78,54.26 62.74,54.26 62.62,54.38 62.6,54.49 62.69,54.55 63.51,54.55 63.58,54.62 63.67,54.65 63.74,54.59 63.87,54.43 64.07,54.37 64.32,54.47 64.43,54.72 64.42,54.78 64.41,54.84 64.42,54.93 64.5,54.98
GND on IN1 (solid shape): 198.5,26.64 198.64,26.64 198.64,26.56 198.62,26.54 198.55,26.48 198.49,26.39 198.43,26.39 198.06,26.76 196.43,26.76 196.14,26.47 191.62,26.47 190.75,25.6 190.75,24.86 190.73,24.83 190.7,24.81 190.55,24.77 190.43,24.66 190.35,24.62 190.27,24.66 190.2,24.73 190.12,24.78 190.12,25.38 192.07,27.32 192.14,27.32 192.19,27.29 192.19,27.24 192.15,27.16 192.14,27.07 192.5,26.71 192.85,27.07 192.85,27.13 192.83,27.18 192.84,27.28 192.93,27.32 193.06,27.32 193.14,27.27 193.15,27.18 193.13,27.11 193.12,27.04 193.23,26.79 193.48,26.69 193.61,26.71 193.73,26.79 193.8,26.81 193.87,26.78 193.98,26.71 194.12,26.68 194.37,26.79 194.47,27.04 194.47,27.11 194.45,27.18 194.45,27.27 194.54,27.32 194.67,27.32 194.74,27.38 194.77,27.37 194.81,27.36 194.86,27.36 195,27.39 195.12,27.47 195.19,27.5 195.26,27.47 195.38,27.39 195.51,27.37 195.77,27.47 195.87,27.72 195.85,27.83 195.81,27.93 195.8,28.03 195.89,28.08 197.05,28.08
GND on IN1 (solid shape): 73.55,58.36 73.63,58.32 73.64,58.22 73.63,58.16 73.62,58.1 73.98,57.75 74.33,58.1 74.33,58.16 74.31,58.22 74.32,58.32 74.41,58.36 76.16,58.36 76.25,58.31 76.25,58.21 76.22,58.13 76.21,58.05 76.57,57.69 76.92,58.05 76.91,58.13 76.88,58.21 76.89,58.31 76.97,58.36 77.43,58.36 77.52,58.31 77.52,58.21 77.49,58.13 77.48,58.05 77.58,57.8 77.84,57.69 77.97,57.72 78.09,57.8 78.16,57.83 78.23,57.79 78.35,57.71 78.5,57.68 78.69,57.73 78.82,57.88 78.89,57.94 78.98,57.91 80.08,56.81 80.5,56.81 80.59,56.77 80.6,56.68 80.58,56.62 80.58,56.56 80.58,56.5 80.6,56.44 80.59,56.35 80.51,56.31 79.85,56.31 78.85,57.31 72.9,57.31 72.63,57.57 72.61,57.69 72.71,57.75 72.96,57.85 73.06,58.1 73.06,58.17 73.04,58.23 73.05,58.32 73.14,58.36
GND on IN1 (solid shape): 137.18,107.66 137.27,107.61 137.33,107.52 137.42,107.46 137.42,105.12 136.33,104.03 135.95,104.03 135.85,104.09 135.87,104.2 136.49,104.82 136.49,105.67 136.67,105.84 136.74,105.83 136.78,105.83 137.14,106.18 136.78,106.54 136.61,106.49 136.48,106.37 136.39,106.32 136.31,106.37 136.18,106.49 136,106.54 135.75,106.43 135.65,106.18 135.65,106.14 135.67,106.07 135.51,105.91 135.48,105.9 135.48,105.82 135.1,105.44 134.91,105.44 134.56,105.09 134.56,105 134.28,104.72 133.87,104.72 133.78,104.77 133.78,104.87 133.81,104.95 133.82,105.03 133.8,105.17 133.72,105.28 133.71,105.32 133.72,105.35 133.91,105.54 134.55,105.54 134.78,105.77 134.97,105.77 135.04,105.84 135.11,105.83 135.15,105.83 135.29,105.85 135.4,105.92 135.45,105.97 135.46,106.01 135.5,106.09 135.51,106.18 135.41,106.43 135.15,106.54 134.98,106.49 134.85,106.37 134.77,106.32 134.68,106.37 134.55,106.49 134.38,106.54 134.34,106.53 134.27,106.52 133.71,107.08 133.35,107.08 133.31,107.12 133.3,107.18 133.34,107.21 136.43,107.21 136.67,107.44 136.74,107.43 136.78,107.42 136.96,107.47 137.09,107.61
GND on IN1 (solid shape): 177.42,29.32 177.53,29.34 177.59,29.24 177.59,27.51 177.95,27.16 182.51,27.16 182.58,27.15 182.64,27.13 182.67,27.12 184.67,27.12 184.75,27.08 184.77,26.98 184.75,26.92 184.74,26.86 184.75,26.78 184.78,26.7 184.78,26.6 184.69,26.55 183,26.55 182.57,26.98 176.89,26.98 176.76,27.11 176.73,27.19 176.76,27.26 176.84,27.38 176.87,27.52 176.77,27.77 176.52,27.88 176.37,27.84 176.25,27.76 176.17,27.72 176.1,27.76 175.98,27.84 175.83,27.88 175.58,27.77 175.47,27.52 175.48,27.46 175.5,27.4 175.48,27.3 175.4,27.26 175.3,27.26 175.21,27.32 175.22,27.43 175.28,27.53 175.3,27.65 175.2,27.9 174.94,28.01 174.77,27.96 174.64,27.83 174.6,27.8 174.56,27.82 174.54,27.84 174.52,27.87 174.53,27.91 175.46,28.84 175.54,28.84 175.54,28.78 175.54,28.77 175.51,28.69 175.5,28.6 175.85,28.25 176.21,28.6 176.2,28.66 176.19,28.71 176.21,28.8 176.29,28.84 176.72,28.84 176.78,28.85 176.9,28.85 176.97,28.87
GND on IN1 (solid shape): outline of 197 points within 122.93,22.71 167.15,26.38
GND on IN1 (solid shape): 120.29,88.29 120.29,83.5 120.36,83.34 120.52,83.3 120.56,83.3 120.81,83.04 120.56,82.79 120.52,82.79 120.36,82.75 120.29,82.59 120.29,80.62 120.25,80.54 120.16,80.52 120.12,80.53 120.08,80.53 119.91,80.49 119.77,80.39 119.7,80.36 119.62,80.39 119.48,80.49 119.31,80.53 119.08,80.46 118.93,80.26 118.87,80.2 118.78,80.21 118.67,80.26 118.55,80.28 118.27,80.16 118.15,79.87 118.15,79.81 118.12,79.72 118.02,79.7 117.97,79.71 117.92,79.72 117.79,79.69 117.68,79.63 117.57,79.61 117.51,79.7 117.51,80.88 117.18,81.21 117.18,81.87 117.25,81.96 117.36,81.93 117.49,81.83 117.64,81.8 117.99,82.16 117.64,82.51 117.49,82.48 117.36,82.38 117.25,82.35 117.18,82.44 117.18,83.46 120.05,86.33 120.05,87.77 120.05,87.83 120.03,87.9 120.03,88.35 118.52,89.85 117.81,89.85 114.61,93.05 114.59,93.16 114.69,93.22 115.36,93.22
GND on IN1 (solid shape): outline of 198 points within 167.73,16.47 176.91,20.12
GND on IN1 (solid shape): 14.5,90.01 14.61,90.03 14.67,89.94 14.67,84.84 14.94,84.57 16.92,84.57 17.24,84.89 17.24,88.25 17.23,88.28 17.21,88.33 17.21,88.38 17.21,88.43 17.23,88.48 17.24,88.51 17.24,88.7 17.28,88.78 17.37,88.8 17.41,88.79 17.46,88.78 17.51,88.79 17.56,88.8 17.59,88.81 17.82,88.57 17.82,85.65 18.87,84.6 18.9,84.51 18.84,84.44 18.79,84.41 18.74,84.37 18.67,84.34 18.6,84.37 18.48,84.44 18.35,84.47 18.1,84.37 17.99,84.11 18,84.06 18.01,84.02 18.02,83.99 17.83,83.8 14.17,83.8 14.17,88.56 14.32,88.69 14.38,88.89 14.02,89.24 13.67,88.89 13.72,88.69 13.88,88.56 13.88,83.94 11.97,82.04 11.18,82.04 10.29,81.15 10.26,81.16 10.16,81.2 10.05,81.21 9.9,81.19 9.76,81.12 9.65,81.11 9.6,81.2 9.6,83.9 8.45,85.28 6.89,84.4 2.21,84.4 2,84.61 2,87.4 0.5,87.4 0.5,88.29 0.71,88.5 4.5,88.5 4.5,88 4.7,87.5 5.2,87.3 6.6,87.3 7.1,87.5 7.3,88 7.3,88.5 11.2,88.5 11.5,88.57 11.74,88.76 13.24,88.76
GND on IN1 (solid shape): 127.73,88.6 127.93,88.6 128.33,88.21 130.44,88.21 132.74,85.9 132.74,83.87 133.57,83.04 136.25,83.04 136.34,82.98 136.33,82.87 136.26,82.76 136.24,82.64 136.6,82.29 136.96,82.64 136.93,82.76 136.87,82.87 136.86,82.98 136.95,83.04 137.67,83.04 137.76,82.98 137.75,82.87 137.69,82.77 137.67,82.65 137.78,82.4 138.03,82.3 138.22,82.35 138.35,82.49 138.44,82.55 138.53,82.5 138.66,82.36 138.84,82.31 139.09,82.41 139.2,82.66 139.18,82.78 139.13,82.88 139.12,82.98 139.21,83.04 141.07,83.04 141.87,82.24 142.59,82.24 143.39,83.04 143.71,83.04 143.8,82.98 143.79,82.88 143.74,82.77 143.72,82.66 143.74,82.56 143.78,82.47 143.78,82.37 143.69,82.31 143.14,82.31 142.73,81.91 142.72,81.91 142.32,81.51 141.82,81.51 141.74,81.56 141.73,81.65 141.74,81.71 141.75,81.77 141.39,82.12 141.03,81.77 141.04,81.71 141.06,81.65 141.04,81.56 140.96,81.51 134.63,81.51 132.42,83.73 132.42,85.76 130.3,87.88 128.19,87.88 127.8,88.27 127.14,88.27 126.12,89.29 126.1,89.39 126.17,89.46 126.3,89.53 126.39,89.64 126.69,89.64
GND on IN1 (solid shape): outline of 90 points within 107.78,20.28 166.54,27.06
GND on IN1 (solid shape): outline of 92 points within 172.35,15.31 207.87,26.07
GND on IN1 (solid shape): outline of 89 points within 154.78,19.82 185.21,24.87
GND on IN1 (solid shape): 122.5,62.9 122.53,62.95 122.58,62.94 122.64,62.88 122.64,60.6 124.7,58.54 124.7,47.24 125.97,45.97 125.97,43.05 128.98,40.04 132.28,40.04 134.1,38.22 134.1,37.33 134.83,36.59 134.86,36.49 134.78,36.42 134.69,36.39 134.6,36.33 134.53,36.3 134.46,36.33 134.37,36.4 134.26,36.43 134.25,36.43 133.89,36.79 133.32,36.79 130.62,39.49 129.03,39.49 125.77,42.75 125.77,45.67 124.37,47.07 124.37,52.28 122.19,54.46 122.19,55.22 122.25,55.32 122.36,55.29 122.5,55.19 122.67,55.15 122.83,55.19 122.96,55.28 123.04,55.31 123.4,55.15 123.77,55.31 123.85,55.28 123.98,55.19 124.14,55.15 124.43,55.27 124.55,55.56 124.51,55.72 124.42,55.86 124.39,55.93 124.55,56.3 124.39,56.67 124.55,57.03 124.39,57.4 124.42,57.48 124.52,57.61 124.55,57.77 124.43,58.06 124.14,58.18 123.98,58.15 123.85,58.05 123.77,58.02 123.4,58.18 123.04,58.02 122.96,58.05 122.83,58.15 122.67,58.18 122.5,58.14 122.36,58.04 122.25,58.01 122.19,58.11 122.19,58.54 122.5,58.86
GND on IN1 (solid shape): outline of 88 points within 125.09,83.36 137.37,91.15
GND on IN1 (solid shape): outline of 94 points within 135.34,19.29 167.48,23.18
GND on IN1 (solid shape): outline of 230 points within 96.44,47.44 98.26,51.24
GND on IN1 (solid shape): outline of 250 points within 67.17,90 84.33,99.71
GND on IN1 (solid shape): outline of 91 points within 91.16,34.88 99.03,47.37
GND on IN1 (solid shape): outline of 82 points within 136.86,89.69 143.91,92.37
GND on IN1 (solid shape): outline of 85 points within 115.4,112.85 122.24,117.94
GND on IN1 (solid shape): outline of 103 points within 55.05,91.58 65.76,98.43
GND on IN1 (solid shape): outline of 293 points within 180.41,14.35 197.59,23.39
GND on IN1 (solid shape): outline of 138 points within 93.76,81.17 103.14,112.92
GND on IN1 (solid shape): outline of 321 points within 193.65,12.07 213.09,23.21
GND on IN1 (solid shape): outline of 325 points within 174.1,17 186.29,20.57
GND on IN1 (solid shape): outline of 371 points within 2.1,57.74 22,83.78
GND on IN1 (solid shape): outline of 107 points within 103.59,96.54 108.42,106.24
GND on IN1 (solid shape): outline of 434 points within 51.37,72.27 57.15,82.7
GND on IN1 (solid shape): outline of 425 points within 141.53,46.92 152.41,50.45
GND on IN1 (solid shape): outline of 145 points within 110.49,108.81 116.08,113.67
GND on IN1 (solid shape): outline of 139 points within 11.01,71.63 15.71,82.26
GND on IN1 (solid shape): outline of 430 points within 98.67,30.23 104.94,37.17
GND on IN1 (solid shape): outline of 481 points within 148.98,15.81 159.98,20.07
GND on IN1 (solid shape): outline of 454 points within 158.55,13.92 168.39,20.56
GND on IN1 (solid shape): outline of 471 points within 93.03,43.53 97.53,52.36
GND on IN1 (solid shape): outline of 512 points within 101.08,74.84 111.68,115.26
GND on IN1 (solid shape): outline of 570 points within 199.12,16.01 212.64,34.82
GND on IN1 (solid shape): outline of 569 points within 185.41,16.74 198.8,28.91
GND on IN1 (solid shape): outline of 583 points within 145.99,28.84 157.56,43.4
GND on IN1 (solid shape): outline of 770 points within 28.66,33.17 35.35,87.72
GND on IN1 (solid shape): outline of 823 points within 25.38,24.87 90.39,40.01
GND on IN1 (solid shape): outline of 893 points within 105.96,32.67 113.12,57.36
GND on IN1 (solid shape): outline of 460 points within 86.37,70.41 103.41,93.17
GND on IN1 (solid shape): outline of 1621 points within 96.71,36.66 115.24,119.49
GND on IN1 (solid shape): outline of 2005 points within 88.46,24.26 113.83,76.03
GND on IN1 (solid shape): outline of 2009 points within 13.94,10.14 94.38,46.45
GND on IN1 (solid shape): outline of 2234 points within 122.56,79.94 148.63,100.54
GND on IN1 (solid shape): outline of 2787 points within 116.67,102.16 146.62,118.47
GND on IN1 (solid shape): outline of 4112 points within 102.01,26.93 147.45,104.32
GND on IN1 (solid shape): outline of 46362 points within 0.5,0.5 224.67,127.5
GND on IN2 (solid shape): 36.05,77.32 36.08,77.36 36.13,77.35 36.49,77 36.49,75.99 35.98,75.48 35.98,74.11 36.58,73.52 36.58,73.41 36.44,73.41 35.64,74.21 35.64,76.89 36.05,77.29
GND on IN2 (solid shape): 79.51,88.15 79.54,88.04 79.44,87.98 73.09,87.98 72.54,88.53 72.51,88.64 72.61,88.71 78.96,88.71
GND on IN2 (solid shape): 131.43,28.83 131.45,28.72 131.36,28.66 121.67,28.66 120.73,29.59 120.71,29.7 120.81,29.76 130.5,29.76
GND on IN2 (solid shape): 59.74,25.63 64.24,25.63 64.34,25.57 64.32,25.46 64.01,25.15 54.09,25.15 53.52,25.72 53.5,25.83 53.6,25.89 59.48,25.89
GND on IN2 (solid shape): 96.34,92.34 96.36,92.23 96.26,92.16 96.02,92.16 95.6,92.59 91.99,92.59 91.62,92.95 91.6,93.06 91.69,93.13 95.55,93.13
GND on IN2 (solid shape): 106.14,37.48 106.14,37.13 106.08,37.03 105.97,37.06 105.94,37.09 105.83,37.09 104.63,38.29 104.63,38.73 103.48,39.88 103.47,39.94 103.52,39.97 103.65,39.97
GND on IN2 (solid shape): 116.47,84.22 116.47,83.97 116.41,83.88 116.3,83.9 115.14,85.05 112.6,85.05 111.94,85.72 111.92,85.83 112.01,85.89 114.8,85.89
GND on IN2 (solid shape): 89.44,77.24 91.45,77.24 91.54,77.17 91.52,77.06 91.17,76.71 89.69,76.71 88.74,77.65 88.72,77.76 88.81,77.82 88.85,77.82
GND on IN2 (solid shape): 185.7,29.77 185.72,29.66 185.63,29.6 184.91,29.6 184.66,29.34 184.15,29.34 183.77,29.72 182.93,29.72 182.84,29.78 182.86,29.89 183.01,30.05 185.42,30.05
GND on IN2 (solid shape): 104.4,82.92 104.49,82.85 104.47,82.74 102.99,81.26 102.2,81.26 102.04,81.1 102.04,80.5 98.08,80.5 97.99,80.57 98.01,80.68 98.84,81.5 102.87,81.5 104.28,82.92
GND on IN2 (solid shape): 35.77,56.92 35.83,57.01 35.94,56.99 36.89,56.05 36.89,54.53 36.84,54.49 36.73,54.49 36.63,54.55 36.66,54.66 36.66,55.04 36.44,55.25 35.81,55.25 35.77,55.29
GND on IN2 (solid shape): 174.98,24.07 174.98,23.38 175.07,23.29 175.09,23.18 175,23.12 172.82,23.12 172.76,23.17 172.75,23.23 172.8,23.26 173.63,23.26 173.97,23.6 173.97,23.75 174.07,23.85 174.36,23.85 174.59,24.08 174.98,24.08
GND on IN2 (solid shape): 160.78,28.31 160.87,28.26 160.88,28.17 160.87,28.11 160.86,28.05 160.87,27.99 160.88,27.93 160.87,27.84 160.78,27.8 157.21,27.8 157.07,27.94 157.05,28.05 157.14,28.11 159.22,28.11 159.42,28.31
GND on IN2 (solid shape): 36.8,53.18 36.89,53.12 36.87,53.01 36.87,52.62 36.45,52.2 35.05,52.2 34.83,51.98 34.83,51.95 34.79,51.87 34.7,51.85 34.65,51.87 34.61,51.88 34.53,51.95 34.55,52.05 35.68,53.18
GND on IN2 (solid shape): 166.93,25.99 167.01,25.95 167.03,25.85 167.01,25.8 167.01,25.74 167.01,25.67 167.03,25.61 167.02,25.52 166.93,25.48 166.34,25.48 165.71,24.84 161.4,24.84 160.89,24.33 156.08,24.33 156,24.41 155.99,24.47 156.04,24.5 158.79,24.5 159.9,25.6 165.61,25.6 166,25.99
GND on IN2 (solid shape): 60.69,22.95 70.57,22.95 70.66,22.89 70.64,22.78 70.38,22.52 55.79,22.52 54.57,23.75 54.54,23.82 54.56,23.89 54.63,23.99 54.65,24.12 54.63,24.22 54.58,24.32 54.58,24.42 54.67,24.48 59.17,24.48
GND on IN2 (solid shape): 52.94,24.24 52.93,24.21 52.92,24.17 52.92,24.12 53.02,23.86 53.27,23.76 53.33,23.76 55.16,21.93 55.18,21.82 55.09,21.76 53.78,21.76 51.98,23.56 51.98,24.42 51.72,24.69 51.69,24.8 51.79,24.86 52.33,24.86
GND on IN2 (solid shape): 65.33,95.34 66.55,95.34 67.23,94.67 67.23,93.26 67.16,93.17 67.05,93.19 62.7,97.54 61.75,97.54 61.66,97.6 61.67,97.7 61.73,97.9 61.67,98.11 61.66,98.21 61.75,98.26 62.41,98.26
GND on IN2 (solid shape): 155.71,27.06 155.8,27.03 156.46,26.36 159.19,26.36 159.29,26.3 159.26,26.19 158.82,25.74 157.92,25.74 157.49,26.17 155.7,26.17 155.24,26.62 155.22,26.74 155.31,26.8 155.31,26.8 155.5,26.85 155.64,27
GND on IN2 (solid shape): 164.04,23 164.13,22.94 164.11,22.82 164.02,22.7 163.98,22.56 163.99,22.5 164.01,22.44 163.99,22.35 163.91,22.3 163.87,22.3 163.68,22.49 162.94,22.49 162.68,22.23 161.3,22.23 161.23,22.3 161.22,22.36 161.27,22.39 161.65,22.39 162.26,23
GND on IN2 (solid shape): 119.53,52.04 119.65,51.95 119.79,51.92 119.94,51.95 120.06,52.04 120.17,52.04 120.27,51.97 120.24,51.86 120.14,51.76 120.14,51.16 120.09,51.07 119.98,51.08 119.88,51.13 119.77,51.14 117.05,51.14 116.41,51.78 112,51.78 111.9,51.84 111.92,51.95 112.01,52.04
GND on IN2 (solid shape): 51.49,22.55 51.55,22.65 51.66,22.63 53.39,20.9 67.65,20.9 68.16,20.39 68.2,20.39 68.28,20.34 68.29,20.25 68.28,20.19 68.27,20.13 68.28,20.07 68.29,20.02 68.28,19.92 68.2,19.88 62.97,19.88 62.19,20.66 52.06,20.66 51.73,20.33 51.7,20.3 51.66,20.28 51.62,20.3 51.56,20.36 51.49,20.4
GND on IN2 (solid shape): 106.34,78.75 106.36,78.64 106.27,78.58 102.35,78.58 102.25,78.64 102.28,78.75 102.89,79.37 104.13,79.37 104.26,79.21 104.46,79.16 104.71,79.26 104.81,79.51 104.81,79.58 104.78,79.65 104.79,79.75 104.88,79.79 105.3,79.79
GND on IN2 (solid shape): 124.27,22.08 124.46,22.08 124.55,22.03 124.55,21.93 124.53,21.88 124.52,21.83 124.45,21.65 124.27,21.58 124.09,21.65 124.01,21.83 124.02,21.86 124.02,21.89 123.98,22.07 123.82,22.15 121.71,22.15 121.61,22.21 121.64,22.32 122.19,22.87 123.49,22.87
GND on IN2 (solid shape): 185.19,31.02 184.89,30.72 182.74,30.72 182.57,30.55 182.46,30.53 182.39,30.6 182.27,30.82 182.04,30.9 181.79,30.79 181.69,30.54 181.69,30.48 181.71,30.42 181.69,30.33 181.61,30.29 181.49,30.29 181.02,29.81 180.45,29.81 180.36,29.87 180.38,29.99 181.62,31.23 184.98,31.23
GND on IN2 (solid shape): 34.88,57.33 34.94,57.34 34.97,57.29 34.97,57.2 35.22,56.95 35.22,55.83 35.16,55.74 35.05,55.76 33.4,55.76 33.36,55.8 33.36,56.69 33.55,56.89 33.73,56.89 33.81,56.85 33.83,56.76 33.82,56.71 33.81,56.66 34.14,56.33 34.47,56.66 34.46,56.76 34.41,56.86
GND on IN2 (solid shape): 177.61,29.14 177.7,29.08 177.68,28.97 177.04,28.33 176.27,28.33 176.19,28.37 176.18,28.47 176.2,28.53 176.21,28.6 175.85,28.96 175.5,28.6 175.5,28.53 175.52,28.47 175.51,28.37 175.43,28.33 174.7,28.33 174.61,28.39 174.63,28.5 175.27,29.14
GND on IN2 (solid shape): 56.89,16.73 56.98,16.7 56.99,16.61 56.98,16.53 54.11,16.53 53.95,16.46 53.91,16.29 53.91,16.24 53.66,15.99 53.4,16.24 53.41,16.29 53.36,16.46 53.21,16.53 49.49,16.53 48.5,15.54 48.45,15.54 48.36,15.6 48.38,15.71 49.4,16.73
GND on IN2 (solid shape): 93.32,47.82 93.43,47.84 93.49,47.75 93.49,46.96 93.09,46.56 90.56,46.56 90.55,46.55 90.44,46.53 90.38,46.62 90.38,46.66 90.78,47.06 91.16,47.06 91.82,47.72 92.63,47.72 92.71,47.67 92.72,47.58 92.7,47.51 92.7,47.45 93.03,47.12 93.36,47.45 93.34,47.56 93.28,47.66 93.26,47.73 93.29,47.79
GND on IN2 (solid shape): 171.01,21.42 171.13,21.42 171.22,21.35 171.2,21.24 169.99,20.03 168.94,20.03 168.84,20.1 168.87,20.21 168.97,20.33 169,20.48 168.92,20.71 168.72,20.83 168.64,20.9 168.67,21 169.12,21.45 169.19,21.57 169.22,21.7 169.15,21.91 168.97,22.04 168.91,22.11 168.93,22.21 168.98,22.26 170.17,22.26
GND on IN2 (solid shape): 38.95,23.63 38.97,23.52 38.88,23.46 38.52,23.46 37.9,24.08 34.83,24.08 34.7,24.03 34.55,23.73 34.38,23.66 34.28,23.68 34.2,23.73 34.06,23.79 33.92,23.73 33.84,23.68 33.74,23.66 33.57,23.73 33.42,24.03 33.29,24.08 31.43,24.08 31.38,24.14 31.37,24.19 31.41,24.22 38.36,24.22
GND on IN2 (solid shape): 64.38,114.45 64.45,114.42 64.5,114.38 64.55,114.35 64.55,113.59 66.62,111.52 66.62,110.65 65.84,109.87 65.73,109.85 65.67,109.95 65.67,110.05 65.04,110.69 65.04,111.96 63.77,113.23 63.77,113.3 63.83,113.39 63.94,113.37 65.52,111.79 65.52,111.15 65.41,111.02 65.36,110.86 65.72,110.5 66.08,110.86 66.04,111.02 65.92,111.15 65.92,111.96 64.26,113.63 64.26,114.37 64.31,114.42
GND on IN2 (solid shape): 40.94,26.36 41.08,26.15 41.11,26.15 41.2,26.1 41.19,25.99 41.13,25.88 41.11,25.77 41.21,25.52 41.46,25.41 41.51,25.41 41.57,25.36 41.46,25.26 40.04,25.26 39.32,25.98 39.3,26.09 39.39,26.15 39.87,26.15 40,26.36 40.14,26.4 40.24,26.38 40.33,26.32 40.47,26.26 40.62,26.32 40.7,26.38 40.8,26.4
GND on IN2 (solid shape): 186.12,18.58 186.2,18.53 186.21,18.44 186.19,18.37 186.19,18.3 186.2,18.2 186.25,18.1 186.27,18.07 185.59,17.38 185.5,17.36 185.42,17.41 185.29,17.56 185.1,17.61 184.85,17.51 184.74,17.26 184.8,17.07 184.95,16.94 185,16.86 184.98,16.77 184.72,16.52 183.29,16.52 181.41,14.64 180.71,14.64 180.61,14.72 180.66,14.83 180.73,14.88 180.8,14.95 184.43,18.58
GND on IN2 (solid shape): 35.77,42.91 35.8,42.96 35.86,42.95 35.91,42.89 36.7,42.89 36.75,42.85 36.75,42.63 36.68,42.54 36.57,42.57 36.45,42.65 36.3,42.69 36.05,42.58 35.95,42.33 35.97,42.19 36.05,42.08 36.08,42.01 36.05,41.94 35.98,41.82 35.96,41.69 36.06,41.44 36.31,41.34 36.45,41.37 36.57,41.45 36.68,41.47 36.75,41.38 36.75,40.34 36.68,40.24 36.57,40.26 35.77,41.07
GND on IN2 (solid shape): 201.23,22.82 201.23,22.21 201.49,21.95 201.49,21.73 201.33,21.73 201.17,21.56 201.17,20.77 201.11,20.71 201.11,20.71 200.96,20.56 200.62,20.56 200.06,20.01 200.06,19.58 200.24,19.4 200.24,19.16 199.71,18.63 198.92,18.63 198.83,18.68 198.84,18.79 198.88,18.89 198.9,18.99 198.89,19.07 198.87,19.14 198.87,19.24 198.96,19.28 199.15,19.28 200.55,20.68 200.87,20.68 201.06,20.87 201.06,21.88 200.96,21.98 200.93,22.06 200.97,22.13 201.07,22.26 201.1,22.41 201,22.67 200.75,22.77 200.71,22.77 200.68,22.76 200.61,22.78 200.56,22.84 200.54,22.91 200.51,22.97 200.51,23.07 200.59,23.12 200.93,23.12
GND on IN2 (solid shape): 143.97,16.6 144.06,16.57 145.76,14.87 147.32,14.87 147.72,14.47 147.75,14.37 147.68,14.3 147.48,14.18 147.41,13.96 147.51,13.7 147.76,13.6 147.98,13.68 148.11,13.87 148.18,13.94 148.28,13.92 148.49,13.7 156.12,13.7 156.2,13.66 156.22,13.56 156.2,13.51 156.2,13.45 156.2,13.39 156.22,13.33 156.2,13.24 156.12,13.19 147.74,13.19 146.24,14.69 145.31,14.69 143.76,16.25 143.73,16.33 143.77,16.4 143.84,16.47 143.89,16.55
GND on IN2 (solid shape): 213.41,14.68 213.46,14.59 213.46,14.43 213.21,14.18 213.15,14.03 213.21,13.89 213.27,13.8 213.29,13.7 213.22,13.52 213.04,13.45 212.93,13.47 212.79,13.59 212.72,13.6 210.65,13.6 210.55,13.56 210.5,13.45 210.25,13.19 209.99,13.45 209.95,13.56 209.84,13.6 209.14,13.6 209.05,13.67 209.07,13.78 209.23,13.94 212.42,13.94 213.13,14.64 213.15,14.64 213.23,14.65 213.31,14.68
GND on IN2 (solid shape): outline of 102 points within 103.64,19.06 120.25,22.95
GND on IN2 (solid shape): 157.99,29.05 164,29.05 164.1,28.99 164.07,28.88 163.99,28.79 159.21,28.79 159.02,28.6 156.95,28.6 156.3,29.25 153.75,29.25 152.73,30.27 152.71,30.38 152.81,30.44 153.47,30.44 153.77,30.73 153.86,30.76 153.94,30.69 154.06,30.5 154.28,30.43 154.4,30.45 154.51,30.51 154.58,30.53 154.65,30.5 154.77,30.42 154.91,30.39 155.05,30.42 155.17,30.5 155.24,30.53 155.31,30.5 155.42,30.44 155.55,30.41 155.8,30.52 155.9,30.77 155.9,30.83 155.88,30.9 155.89,30.99 155.98,31.03 156,31.03
GND on IN2 (solid shape): 198.16,22.52 199.43,22.52 199.69,22.78 199.79,22.8 199.86,22.72 199.98,22.5 200.21,22.41 200.25,22.42 200.28,22.42 200.36,22.4 200.4,22.34 200.42,22.28 200.41,22.18 200.32,22.14 199.03,22.14 199,22.09 198.79,21.98 198.58,22.09 198.55,22.14 197.45,22.14 197.37,22.19 197.36,22.29 197.4,22.37 197.41,22.47 197.31,22.72 197.05,22.82 196.94,22.8 196.83,22.74 196.74,22.73 196.67,22.79 196.66,22.82 196.65,22.85 196.65,22.95 196.73,23 197.67,23
GND on IN2 (solid shape): 20.86,24.37 20.94,24.37 21,24.3 21.12,24.1 21.35,24.01 21.41,24.02 21.48,24.04 21.57,24.03 21.62,23.77 22.66,22.72 22.73,22.72 22.9,22.64 22.97,22.47 22.97,22.41 23.87,21.52 25.41,21.52 25.52,21.6 25.53,21.65 25.78,21.85 26.03,21.64 26.05,21.52 29.09,21.52 29.11,21.5 29.13,21.44 29.08,21.41 25.96,21.41 25.93,21.39 25.78,21.34 25.62,21.39 25.59,21.41 23.59,21.41 22.79,22.21 22.72,22.21 22.54,22.29 22.46,22.47 22.45,22.53 22.42,22.58 20.8,24.2 20.78,24.29 20.84,24.37
GND on IN2 (solid shape): 101.75,23.21 101.85,23.14 101.82,23.03 101.58,22.79 101.55,22.78 101.51,22.79 101.4,22.85 101.28,22.87 101.03,22.77 100.92,22.52 100.98,22.33 101.13,22.19 101.18,22.12 101.16,22.03 99.88,20.76 97.61,20.76 97.52,20.82 97.54,20.93 98.74,22.13 98.77,22.12 98.82,22.11 98.87,22.11 99.12,22.72 98.51,22.47 98.52,22.42 98.53,22.37 98.54,22.34 97.14,20.95 95.03,20.95 94.93,21.01 94.96,21.12 95.58,21.74 96.64,21.74 98.11,23.21
GND on IN2 (solid shape): 160.06,30.62 160.14,30.57 160.15,30.47 160.12,30.39 160.11,30.31 160.46,29.95 160.82,30.31 160.81,30.39 160.78,30.47 160.78,30.57 160.87,30.62 161.97,30.62 162.6,29.98 165.59,29.98 165.63,29.95 165.63,29.9 165.59,29.86 165.57,29.81 164.74,29.81 164.27,29.34 158.11,29.34 157.87,29.58 157.85,29.68 157.91,29.75 157.98,29.78 158.05,29.83 158.52,30.3 158.62,30.33 158.69,30.25 158.81,30.03 159.04,29.95 159.29,30.05 159.4,30.31 159.39,30.39 159.36,30.47 159.36,30.57 159.45,30.62
GND on IN2 (solid shape): 105.94,72.34 109.02,72.34 109.11,72.29 109.11,72.18 109.07,72.11 109.05,72.02 109.05,71.98 105.6,71.98 105.04,71.42 103.54,71.42 103.37,71.32 103.38,71.11 103.4,71.05 103.41,70.98 103.35,70.82 103.19,70.75 103.09,70.77 103.02,70.82 102.97,70.86 102.92,70.88 102.89,70.9 102.88,70.94 102.89,70.98 102.84,71.15 102.71,71.27 102.66,71.36 102.71,71.45 102.84,71.57 102.88,71.74 102.85,71.87 102.78,71.98 102.74,72.06 102.78,72.13 102.85,72.24 102.88,72.38 102.86,72.48 102.82,72.57 102.81,72.68 102.9,72.74 105.54,72.74
GND on IN2 (solid shape): 140.41,36.61 140.5,36.64 140.58,36.58 140.72,36.42 140.93,36.36 141.06,36.38 141.18,36.45 141.25,36.47 141.31,36.45 141.43,36.38 141.57,36.36 141.7,36.38 141.82,36.45 141.88,36.47 141.95,36.45 142.07,36.38 142.2,36.36 142.33,36.38 142.45,36.45 142.52,36.47 142.58,36.45 142.7,36.38 142.84,36.36 143.02,36.4 143.16,36.54 143.73,36.54 143.79,36.52 143.85,36.52 143.9,36.52 143.98,36.54 144,36.52 145.05,36.52 145.14,36.45 145.12,36.34 144.76,35.98 142.41,35.98 139.9,33.48 138.79,33.48 138.67,33.63 138.48,33.69 138.39,33.76 138.41,33.86 138.77,34.22 138.77,34.96
GND on IN2 (solid shape): 37.33,46.93 37.44,46.95 37.51,46.86 37.51,46.66 37.73,46.44 37.76,46.34 37.68,46.27 37.46,46.14 37.38,45.92 37.48,45.66 37.74,45.56 37.86,45.58 37.97,45.65 38.08,45.67 38.14,45.57 38.14,44.75 37.72,44.33 37.61,44.31 37.55,44.4 37.55,44.5 37.33,44.71 36.57,44.71 36.53,44.75 36.53,45.58 36.59,45.67 36.7,45.66 36.8,45.6 36.92,45.58 37.17,45.68 37.27,45.93 37.23,46.11 37.1,46.24 37.05,46.33 37.1,46.42 37.23,46.55 37.27,46.72 37.27,46.77 37.26,46.82 37.25,46.85
GND on IN2 (solid shape): 37.68,71.82 37.72,71.9 37.82,71.91 37.87,71.9 37.92,71.89 37.99,71.86 38.02,71.79 38.02,69.94 37.97,69.85 37.87,69.85 37.81,69.87 37.74,69.87 37.38,69.52 37.74,69.16 37.81,69.17 37.87,69.19 37.97,69.18 38.02,69.1 38.02,68.75 37.21,67.95 37.1,67.93 37.04,68.02 37.04,68.12 36.53,68.63 36.53,69.18 36.59,69.27 36.7,69.26 36.8,69.2 36.92,69.18 37.17,69.28 37.27,69.54 37.23,69.71 37.1,69.84 37.05,69.93 37.1,70.02 37.21,70.11 37.26,70.24 37.27,70.26 37.57,70.56 37.57,71.66 37.68,71.77
GND on IN2 (solid shape): outline of 118 points within 57.84,96.11 63.21,98.9
GND on IN2 (solid shape): 100.27,35.43 100.36,35.38 100.36,35.28 100.33,35.21 100.32,35.14 100.28,35.07 100.21,35.05 98.57,35.05 97.94,34.42 97.93,34.37 97.91,34.3 97.86,34.24 97.82,34.19 97.8,34.13 97.78,34.1 97.75,34.1 97.71,34.1 97.48,34.01 97.38,33.79 97.36,33.75 97.33,33.74 97.26,33.72 97.2,33.68 96.34,32.82 96.27,32.89 96.25,32.93 96.27,32.97 96.37,33.08 96.4,33.23 96.4,33.29 96.42,33.38 96.5,33.42 96.59,33.42 97.43,34.26 97.47,34.31 97.48,34.38 97.48,34.4 97.54,34.56 97.71,34.63 97.73,34.63 97.8,34.64 97.85,34.67 98.52,35.34 98.59,35.37 98.67,35.33 98.78,35.25 98.92,35.22 99.09,35.27 99.22,35.4 99.23,35.43
GND on IN2 (solid shape): 78.67,92.38 78.77,92.32 78.74,92.21 78.04,91.51 78.01,91.51 77.96,91.52 77.91,91.53 77.66,90.92 78.27,91.17 78.27,91.22 78.26,91.27 78.25,91.3 78.81,91.86 78.92,91.88 78.98,91.78 78.98,91.76 79.34,91.4 79.69,91.76 79.68,91.83 79.66,91.9 79.67,92 79.75,92.04 79.87,92.04 79.96,92 79.96,91.9 79.94,91.83 79.93,91.76 79.95,91.65 80,91.55 80,88.92 79.93,88.83 79.82,88.85 79.25,89.42 76.1,89.42 76,89.48 76.02,89.59 76.77,90.34 76.77,91.28 77.88,92.38
GND on IN2 (solid shape): 193.07,27.35 193.16,27.3 193.16,27.2 193.13,27.13 193.12,27.04 193.23,26.79 193.48,26.69 193.61,26.71 193.73,26.79 193.8,26.81 193.87,26.78 193.98,26.71 194.12,26.68 194.18,26.69 194.24,26.7 194.33,26.69 194.37,26.61 194.37,24.49 193.36,23.47 193.36,22.39 193.31,22.31 193.22,22.29 193.22,22.29 193.15,22.37 193.18,22.46 193.25,22.53 193.25,24.06 192.35,24.96 191.88,24.96 191.33,25.51 188.88,25.51 188.79,25.56 188.79,25.67 188.82,25.75 188.84,25.84 188.78,26.04 188.63,26.17 188.63,26.87 188.69,26.96 188.8,26.94 189.23,26.51 192.15,26.51 192.37,26.73 192.4,26.72 192.45,26.71 192.5,26.71 192.75,26.81 192.85,27.07 192.84,27.14 192.82,27.21 192.83,27.3 192.92,27.35
GND on IN2 (solid shape): 23.56,85.7 26.26,83 26.27,82.99 26.34,82.89 26.45,82.88 26.49,82.89 26.55,82.91 26.6,82.92 26.86,82.66 26.6,82.41 26.57,82.41 26.53,82.42 26.35,82.39 26.26,82.23 26.26,81.7 26.35,81.54 26.53,81.51 26.57,81.52 26.6,81.52 26.86,81.27 26.6,81.01 26.57,81.02 26.53,81.02 26.38,81.02 26.28,80.91 26.28,80.9 25.84,80.46 25.82,80.43 25.8,80.39 25.77,80.35 25.75,80.33 25.72,80.25 25.72,80.04 25.63,80.04 25.62,80.08 25.53,80.22 25.39,80.3 25.33,80.36 25.34,80.45 25.33,80.53 25.41,80.71 25.59,80.78 25.66,80.78 26.02,81.14 26.02,83.05 23.4,85.68 23.48,85.78 23.56,85.78
GND on IN2 (solid shape): 82.42,83.05 82.48,83.14 82.59,83.12 86.4,79.3 86.4,78.75 88.53,76.62 88.56,76.52 88.49,76.45 88.43,76.43 88.38,76.4 88.27,76.4 88.22,76.49 88.22,76.63 85.59,79.26 85.56,79.34 85.59,79.41 85.68,79.53 85.71,79.67 85.61,79.9 85.38,80 85.18,79.93 85.06,79.75 84.99,79.68 84.89,79.71 84.56,80.04 84.53,80.14 84.6,80.21 84.78,80.33 84.85,80.53 84.75,80.76 84.52,80.86 84.5,80.86 84.42,80.89 84.39,80.97 84.39,80.99 84.29,81.22 84.06,81.32 83.86,81.25 83.74,81.07 83.67,81 83.57,81.03 82.42,82.18
GND on IN2 (solid shape): 117.01,77.94 117.12,77.96 117.19,77.87 117.19,76.15 117.2,76.09 117.21,76.05 117.2,76.02 117.19,75.95 117.19,73.38 117.54,73.03 117.56,72.92 117.46,72.86 114.89,72.86 113.95,73.8 113.92,73.89 113.99,73.96 114.15,74.09 114.21,74.29 114.18,74.43 114.11,74.54 114.08,74.61 114.11,74.68 114.18,74.8 114.21,74.93 114.1,75.18 113.85,75.28 113.8,75.28 113.75,75.27 113.72,75.26 113.05,75.94 113.02,76.05 113.12,76.11 113.5,76.11 113.5,76.06 113.85,75.7 114.21,76.06 114.21,76.11 114.91,76.11 115.04,76.24 115.07,76.23 115.13,76.22 115.18,76.22 115.44,76.32 115.54,76.57 115.54,76.59 115.57,76.67 115.64,76.7 115.77,76.7
GND on IN2 (solid shape): 68.86,112.3 68.9,112.3 68.99,112.25 68.98,112.14 68.93,112.04 68.91,111.93 69.02,111.68 69.27,111.57 69.31,111.58 69.39,111.59 70.26,110.72 70.26,110.16 70.21,110.08 70.12,110.06 70.06,110.08 70,110.08 69.75,109.98 69.65,109.73 69.65,109.68 69.67,109.61 69.44,109.38 69.44,108.1 69.38,108.01 69.27,108.03 68.21,109.09 66.65,109.09 66.52,109.23 66.33,109.29 66.24,109.28 66.17,109.25 66.07,109.26 66.02,109.34 66.02,109.62 66.92,110.52 66.92,111.65 64.86,113.71 64.86,114.35 65.01,114.48 65.06,114.67 64.96,114.92 64.7,115.02 64.57,115 64.45,114.92 64.38,114.89 64.31,114.92 64.2,114.99 64.07,115.02 63.98,115.09 64,115.2 64.03,115.23 65.94,115.23
GND on IN2 (solid shape): 63.6,96.15 63.7,96.13 72.74,87.09 72.75,87.03 72.71,87 72.64,87 70.73,88.91 69.09,88.91 68.97,89.04 68.79,89.09 68.71,89.08 68.62,89.04 68.52,89.04 68.47,89.13 68.47,90.05 65.87,92.65 65.23,92.65 64.72,93.16 64.69,93.25 64.76,93.33 64.96,93.47 65.04,93.71 64.96,93.94 64.78,94.09 64.72,94.15 64.72,94.23 64.75,94.31 64.76,94.4 64.64,94.69 64.35,94.8 64.28,94.8 64.21,94.78 64.13,94.78 64.08,94.85 63.93,95.05 63.69,95.13 63.43,95.04 63.29,94.81 63.22,94.73 63.12,94.76 63.07,94.8 63.07,95.67 63.1,95.74 63.18,95.77 63.18,95.77 63.41,95.85 63.53,96.07
GND on IN2 (solid shape): 177.2,19.97 177.63,19.97 177.73,19.91 177.7,19.8 177.63,19.68 177.6,19.54 177.7,19.29 177.95,19.19 178.2,19.29 178.31,19.53 178.37,19.63 178.48,19.6 179.3,18.79 179.32,18.68 179.23,18.62 179.22,18.62 178.98,18.37 178.86,18.37 178.86,18.44 178.88,18.46 178.95,18.57 178.98,18.71 178.62,19.06 178.27,18.71 178.28,18.61 178.32,18.52 178.32,18.42 178.23,18.37 177.89,18.37 176.28,19.98 174.19,19.98 174.11,20.03 174.11,20.13 174.14,20.21 174.15,20.31 174.05,20.56 173.8,20.66 173.64,20.63 173.52,20.53 173.44,20.49 173.36,20.53 173.34,20.56 173.23,20.67 171.29,20.67 171.19,20.73 171.21,20.84 171.6,21.23 175.95,21.23
GND on IN2 (solid shape): 10.57,114.19 10.61,114.18 13.03,114.18 13.04,114.18 25.29,114.18 25.39,114.12 25.36,114.01 23.07,111.72 20.99,111.72 20.46,112.25 19.39,112.25 17.84,110.7 17.84,108.29 17.14,107.59 13.19,103.64 11.74,103.64 11.5,103.83 11.2,103.9 7.3,103.9 7.3,104.4 7.1,104.9 6.6,105.1 5.2,105.1 4.7,104.9 4.5,104.4 4.5,103.9 0.71,103.9 0.5,104.11 0.5,105.19 0.51,105.2 2.1,105.2 2.1,111.2 0.51,111.2 0.5,111.21 0.5,112.59 0.71,112.8 3.3,112.8 3.6,112.58 3.97,112.5 5.93,112.5 6.3,112.58 6.6,112.8 6.62,112.82 7.29,112.83 7.3,112.81 8.48,112.52 8.88,113.66 8.89,113.76 8.97,113.8 9.86,113.8 10.19,113.89 10.43,114.14 10.48,114.19 10.54,114.2
GND on IN2 (solid shape): 197.1,31.17 197.21,31.19 197.27,31.1 197.27,30.72 197.22,30.63 197.11,30.63 197.02,30.68 196.91,30.7 196.66,30.59 196.56,30.34 196.62,30.13 196.8,30 196.86,29.93 196.84,29.83 196.26,29.26 196.26,28.32 196.03,28.09 196.03,25.88 194.84,24.69 194.73,24.67 194.66,24.76 194.66,27.27 194.7,27.35 194.79,27.37 194.83,27.36 194.86,27.36 195,27.39 195.12,27.47 195.19,27.5 195.26,27.47 195.38,27.39 195.51,27.37 195.87,27.72 195.51,28.08 195.38,28.05 195.26,27.97 195.19,27.94 195.11,27.97 195.07,28.01 195.01,28.04 194.96,28.11 194.98,28.2 196.42,29.64 196.42,30.42 196.17,30.67 196.18,30.7 196.19,30.76 196.2,30.82 196.19,30.9 196.16,30.98 196.16,31.08 196.25,31.13 196.59,31.13 196.59,31.13 197.06,31.13
GND on IN2 (solid shape): 106.43,33.28 106.53,33.26 107.36,32.43 107.36,31.55 107.87,31.04 109.42,31.04 110.01,30.45 110.04,30.35 109.96,30.28 109.88,30.24 109.81,30.19 109.73,30.16 109.66,30.19 109.24,30.61 107.19,30.61 106.51,31.29 106.51,32.05 106.26,32.3 105.74,32.3 105.25,31.81 105.25,30.92 103.12,28.8 102.11,28.8 102.02,28.84 102.02,28.94 102.04,29 102.04,29.07 101.71,29.4 101.38,29.07 101.39,29 101.41,28.94 101.4,28.84 101.32,28.8 99.16,28.8 97.74,27.37 97.28,27.37 95.9,26 95.81,25.97 95.74,26.03 95.7,26.1 95.65,26.15 95.61,26.23 95.64,26.3 95.64,26.31 95.65,26.35 95.71,26.46 95.82,26.52 95.86,26.53 97.69,28.35 97.69,28.74 97.8,28.85 97.86,28.79 97.85,28.76 97.83,28.7 97.83,28.64 98.18,28.28 98.54,28.64 98.54,28.67 99.39,29.53 103.43,29.53 105.14,31.23 105.14,32.05 106.02,32.93 106.04,32.93 106.25,33.01 106.36,33.2
GND on IN2 (solid shape): 102.53,37.26 102.56,37.16 102.48,37.08 102.29,36.97 102.22,36.76 102.32,36.53 102.55,36.43 102.76,36.5 102.87,36.69 102.94,36.77 103.05,36.74 106.03,33.76 106.05,33.66 105.97,33.59 105.78,33.48 105.7,33.27 105.7,33.25 105.38,32.93 105.26,32.91 105.2,33 105.2,33.98 104.13,35.05 101.08,35.05 101.01,35.07 100.98,35.14 100.95,35.25 100.88,35.34 100.87,35.4 100.92,35.43 101,35.43 101.38,35.81 101.38,36.86 100.95,37.29 99.13,37.29 98.66,36.83 98.48,36.7 98.25,36.66 96.9,36.66 96.82,36.64 96.68,36.48 96.56,36.45 96.53,36.45 96.47,36.44 96.41,36.41 95.78,35.77 95.72,35.72 95.66,35.68 95.64,35.67 95.5,35.52 93.69,35.52 91.24,33.07 91.24,32.85 91.21,32.78 91.13,32.75 91.12,32.75 91.02,32.74 90.92,32.69 90.82,32.68 90.76,32.77 90.76,33.2 93.59,36.03 95.43,36.03 96.65,37.25 98.48,37.25 98.95,37.72 102.06,37.72
GND on IN2 (solid shape): 148.28,29.1 152.67,29.1 153.11,28.66 153.14,28.55 153.04,28.49 147.94,28.49 147.85,28.54 147.85,28.64 147.88,28.72 147.89,28.82 147.48,29.22 147.08,28.82 147.09,28.72 147.12,28.64 147.11,28.54 147.03,28.49 146.91,28.49 146.82,28.56 146.85,28.67 146.94,28.79 146.98,28.94 146.87,29.19 146.62,29.3 146.49,29.27 146.38,29.21 146.31,29.18 146.24,29.21 146.12,29.29 145.98,29.32 145.83,29.29 145.71,29.19 145.63,29.15 145.55,29.19 145.43,29.29 145.27,29.32 145.13,29.29 145.01,29.2 144.93,29.17 144.85,29.2 144.73,29.29 144.59,29.32 144.4,29.27 144.27,29.12 144.19,29.06 144.1,29.09 143.74,29.45 139.96,29.45 139.64,29.14 138.53,29.14 138.44,29.2 138.46,29.31 138.77,29.63 147.76,29.63
GND on IN2 (solid shape): 190.33,20.44 190.35,20.33 190.26,20.27 189.29,20.27 189.16,20.42 188.97,20.48 188.72,20.37 188.61,20.12 188.62,20.03 188.66,19.95 188.66,19.85 188.57,19.8 187.47,19.8 187.38,19.86 187.39,19.96 187.45,20.06 187.47,20.18 187.47,20.79 186.96,21.3 186.82,21.3 186.82,21.38 186.88,21.42 186.92,21.45 186.99,21.47 187.06,21.45 187.17,21.37 187.3,21.35 187.66,21.7 187.3,22.06 187.17,22.03 187.06,21.96 186.99,21.93 186.92,21.96 186.8,22.03 186.67,22.06 186.52,22.03 186.4,21.93 186.32,21.89 186.24,21.93 186.12,22.03 185.96,22.06 185.71,21.95 185.61,21.7 185.63,21.58 185.7,21.47 185.72,21.36 185.62,21.3 184.16,21.3 181.48,18.62 180.56,18.62 180.47,18.68 180.49,18.79 184.07,22.37 187.29,22.37 187.46,22.55 188.23,22.55
GND on IN2 (solid shape): 190.91,32.64 190.99,32.67 191.06,32.64 191.11,32.59 191.17,32.56 191.23,32.48 191.2,32.39 190.47,31.67 190.47,27.87 191,27.35 192.08,27.35 192.16,27.3 192.17,27.21 192.15,27.14 192.14,27.07 192.14,27.02 192.15,26.97 192.16,26.94 192.03,26.8 189.35,26.8 185.63,30.53 185.24,30.53 185.19,30.56 185.2,30.62 185.29,30.7 186.83,30.7 186.91,30.66 186.93,30.56 186.91,30.5 186.9,30.44 187.01,30.19 187.26,30.08 187.31,30.09 187.36,30.1 187.44,30.09 187.49,30.02 187.5,30 187.49,29.92 187.42,29.87 187.2,29.73 187.11,29.48 187.51,29.07 187.92,29.48 187.92,29.53 187.91,29.59 187.92,29.67 187.98,29.71 188.21,29.86 188.29,30.11 188.18,30.4 187.89,30.52 187.81,30.51 187.73,30.49 187.65,30.49 187.6,30.55 187.59,30.56 187.61,30.66 187.69,30.7 188.97,30.7
GND on IN2 (solid shape): 150.03,19.73 158.62,19.73 160.72,17.64 160.74,17.53 160.65,17.46 151.89,17.46 150.78,18.58 150.75,18.67 150.81,18.74 150.86,18.77 150.9,18.81 150.97,18.84 151.04,18.81 151.16,18.73 151.29,18.71 151.43,18.73 151.54,18.8 151.61,18.83 151.68,18.8 151.8,18.73 151.93,18.71 151.97,18.71 152.04,18.69 152.08,18.62 152.2,18.39 152.44,18.3 152.79,18.66 152.44,19.01 152.4,19.01 152.32,19.03 152.28,19.1 152.17,19.33 151.93,19.42 151.8,19.39 151.68,19.32 151.61,19.29 151.54,19.32 151.43,19.39 151.29,19.42 151.16,19.39 151.05,19.32 150.97,19.29 150.9,19.32 150.79,19.39 150.65,19.42 150.46,19.37 150.33,19.22 150.26,19.16 150.17,19.19 148.82,20.54 146.13,20.54 146.09,20.58 146.08,20.64 146.12,20.67 149.1,20.67
GND on IN2 (solid shape): outline of 204 points within 59.74,23.44 77.09,24.86
GND on IN2 (solid shape): 38.82,83.21 38.88,83.3 38.99,83.28 39.63,83.28 39.67,83.24 39.67,82.9 39.61,82.81 39.51,82.81 39.42,82.85 39.33,82.86 38.97,82.51 39.33,82.15 39.42,82.16 39.51,82.2 39.61,82.2 39.67,82.12 39.67,82.07 39.61,81.98 39.51,81.98 39.42,82.02 39.33,82.04 39.07,81.93 38.97,81.68 39.02,81.51 39.14,81.38 39.19,81.29 39.14,81.2 39.01,81.07 38.96,80.9 39.07,80.65 39.32,80.54 39.42,80.56 39.51,80.6 39.61,80.6 39.67,80.51 39.67,79.27 39.61,79.18 39.5,79.19 39.4,79.25 39.28,79.27 39.03,79.17 38.92,78.92 38.95,78.78 39.02,78.67 39.05,78.6 39.02,78.53 38.95,78.41 38.92,78.28 39.03,78.03 39.28,77.93 39.4,77.95 39.5,78 39.61,78.02 39.67,77.92 39.67,76.88 39.37,76.59 39.14,76.59 39.05,76.65 39.07,76.76 39.07,77.14 38.86,77.35 38.48,77.35 38.42,77.41 38.42,78.77 38.82,79.17
GND on IN2 (solid shape): 60.59,28.72 70.16,28.72 70.33,28.55 70.36,28.46 70.29,28.39 70.13,28.26 70.06,28.05 70.1,27.91 70.18,27.79 70.21,27.67 70.12,27.61 69.86,27.61 69.76,27.67 69.79,27.79 69.88,27.91 69.91,28.05 69.56,28.41 69.2,28.05 69.23,27.91 69.32,27.79 69.35,27.67 69.25,27.61 69,27.61 68.9,27.67 68.93,27.79 69.02,27.91 69.05,28.05 68.94,28.3 68.69,28.41 68.56,28.38 68.45,28.31 68.38,28.28 68.3,28.31 68.19,28.38 68.06,28.41 67.81,28.3 67.7,28.05 67.73,27.91 67.82,27.79 67.85,27.67 67.75,27.61 67.09,27.61 67,27.67 67.02,27.79 67.11,27.91 67.14,28.05 67.04,28.3 66.79,28.41 66.74,28.41 66.69,28.4 66.66,28.39 66.45,28.6 62.25,28.6 62.13,28.48 57.99,28.48 57.9,28.53 57.9,28.63 57.94,28.72 57.95,28.82 57.94,28.88 57.93,28.93 57.94,29.03 58.02,29.07 60.24,29.07
GND on IN2 (solid shape): 25.65,79.11 25.72,79.02 25.72,78.61 25.82,78.5 25.88,78.5 26.12,78.24 25.88,77.99 25.82,77.99 25.72,77.88 25.72,74.59 25.67,74.5 25.58,74.49 25.52,74.51 25.46,74.51 25.33,74.48 25.21,74.41 25.14,74.38 25.07,74.41 25,74.47 24.92,74.5 24.88,74.51 24.88,74.63 24.84,74.67 24.79,74.75 24.78,74.84 24.79,74.94 24.85,75.02 24.88,75.05 24.91,75.12 24.99,75.14 25.03,75.14 25.28,75.24 25.38,75.49 25.36,75.63 25.28,75.74 25.25,75.81 25.28,75.88 25.36,76 25.38,76.13 25.28,76.38 25.03,76.48 24.98,76.48 24.88,76.47 24.88,76.53 24.84,76.61 24.75,76.71 24.75,76.93 24.84,77.04 24.88,77.11 24.88,77.19 24.95,77.19 24.97,77.17 25.09,77.08 25.23,77.05 25.49,77.15 25.59,77.41 25.56,77.54 25.49,77.65 25.46,77.72 25.49,77.79 25.56,77.91 25.59,78.04 25.49,78.29 25.23,78.4 25.13,78.38 25.04,78.34 24.93,78.33 24.88,78.42 24.88,78.98 24.94,79.08 25.05,79.06 25.15,79 25.28,78.97 25.42,79 25.54,79.09
GND on IN2 (solid shape): outline of 216 points within 87.9,78.56 95.34,81.75
GND on IN2 (solid shape): outline of 84 points within 154.94,17.66 166.14,20.82
GND on IN2 (solid shape): outline of 97 points within 90.05,70.8 102.36,74.24
GND on IN2 (solid shape): outline of 251 points within 61.3,109.51 73.11,118.29
GND on IN2 (solid shape): outline of 247 points within 176.81,25.87 187.75,29.42
GND on IN2 (solid shape): outline of 247 points within 168.51,17.53 177.64,19.96
GND on IN2 (solid shape): outline of 94 points within 102.94,79.69 118.16,86.74
GND on IN2 (solid shape): outline of 87 points within 175.5,19.29 185.51,23.36
GND on IN2 (solid shape): outline of 105 points within 174.61,23.12 189.69,26.15
GND on IN2 (solid shape): outline of 306 points within 121.31,16.25 151.7,20.84
GND on IN2 (solid shape): outline of 109 points within 95.02,47.12 109.73,50.57
GND on IN2 (solid shape): outline of 111 points within 59.97,11.78 90.09,19.22
GND on IN2 (solid shape): outline of 131 points within 106.41,50.53 130.9,74.84
GND on IN2 (solid shape): outline of 426 points within 82.79,80.56 100.75,92.31
GND on IN2 (solid shape): outline of 426 points within 164.6,15.48 184.89,20.58
GND on IN2 (solid shape): outline of 139 points within 19.34,36.2 26.26,74.15
GND on IN2 (solid shape): outline of 452 points within 24.29,32.54 27.51,42.55
GND on IN2 (solid shape): outline of 495 points within 182.51,11.38 201.07,17.41
GND on IN2 (solid shape): outline of 177 points within 88.72,31.87 103.96,43.91
GND on IN2 (solid shape): outline of 586 points within 98.18,26.99 111.21,31.97
GND on IN2 (solid shape): outline of 151 points within 3.24,38.39 15.78,57.99
GND on IN2 (solid shape): outline of 584 points within 103.01,112.96 116.59,125.47
GND on IN2 (solid shape): outline of 598 points within 85.48,94.74 103.46,112.53
GND on IN2 (solid shape): outline of 635 points within 91.04,72.95 105.98,77.69
GND on IN2 (solid shape): outline of 695 points within 91.24,37.84 106.34,46.74
GND on IN2 (solid shape): outline of 825 points within 0.5,18.35 15.94,37.99
GND on IN2 (solid shape): outline of 944 points within 100.27,34.01 116.75,51.06
GND on IN2 (solid shape): outline of 933 points within 113.18,29.14 164.33,36.44
GND on IN2 (solid shape): outline of 1177 points within 51.98,92.75 71.33,118.02
GND on IN2 (solid shape): outline of 1357 points within 32.18,96.56 56.97,111.52
GND on IN2 (solid shape): outline of 1326 points within 38.05,48.7 42.78,84.81
GND on IN2 (solid shape): outline of 2280 points within 126.42,48.25 150.42,78.25
GND on IN2 (solid shape): outline of 6706 points within 38.02,61.9 93.01,98.52
GND on IN2 (solid shape): outline of 12335 points within 23.94,28.57 92.83,98.11
GND on IN2 (solid shape): outline of 26733 points within 0.5,0.5 224.67,127.5
GND on SVCC (solid shape): 110.4,43.1 110.4,41.01 110.41,40.95 110.44,40.9 111.54,39.8 111.54,36.37 111.38,36.21 108.08,36.21 107.91,36.37 107.91,41.45 108.12,41.66 108.15,41.71 108.16,41.77 108.16,43.61 108.33,43.78 109.73,43.78
GND on SVCC (solid shape): 223.17,52.31 224.23,51.88 224.66,50.82 224.66,46.32 224.23,45.27 223.17,44.83 220.8,44.83 219.73,44.39 219.29,43.32 219.29,18.72 218.7,18.46 218.21,18.02 213.45,18.02 213.38,18.08 213.29,18.13 213.04,18.38 213.04,19.29 213.11,19.41 213.14,19.55 213.11,19.68 213.04,19.8 213.04,20 213.1,20.11 213.12,20.23 213.1,20.35 213.04,20.46 213.04,23.2 213.14,23.33 213.17,23.48 213.14,23.64 213.04,23.77 213.04,32.37 213.02,32.47 212.97,32.55 211.9,33.62 211.9,36.31 211.9,36.34 212.09,36.54 214.36,36.54 214.45,36.46 214.56,36.43 215.07,36.43 215.17,36.45 215.25,36.51 215.89,37.14 215.94,37.23 215.96,37.32 215.96,42.91 215.94,43.01 215.89,43.09 215.58,43.4 215.58,45.01 216.47,45.94 217.32,46.89 217.7,47.51 217.83,48.22 217.73,48.85 217.44,49.42 218.26,50.53 219.04,51.67 219.58,52.14 220.27,52.31
GND on SVCC (solid shape): outline of 95 points within 119.06,35.67 147.13,76.44
GND on SVCC (solid shape): outline of 159 points within 57.85,81.52 151.49,127.49
GND on SVCC (solid shape): outline of 555 points within 0.51,41.75 28.64,104
GND on SVCC (solid shape): outline of 219 points within 26.1,28.94 88.62,93.2
GND on SVCC (solid shape): outline of 690 points within 0.51,0.51 41.61,27.13
GND on IN3 (solid shape): 89.49,62.58 89.55,62.67 89.66,62.65 89.96,62.36 89.96,59.35 89.9,59.26 89.79,59.28 89.49,59.58
GND on IN3 (solid shape): 101.58,83.22 101.64,83.31 101.75,83.29 103.29,81.75 103.3,81.7 103.25,81.67 103.22,81.67 102.89,82 102.29,82 101.58,82.72
GND on IN3 (solid shape): 130.79,115.51 130.81,115.4 130.72,115.34 128.22,115.34 127.71,115.85 127.69,115.96 127.79,116.02 130.29,116.02
GND on IN3 (solid shape): 158.47,28.93 158.48,28.88 158.43,28.85 158.42,28.85 158.13,28.55 156.58,28.55 156.21,28.93 156.19,29.04 156.28,29.1 158.3,29.1
GND on IN3 (solid shape): 79.76,117.3 79.79,117.19 79.69,117.13 74.48,117.13 74.05,117.57 74.03,117.68 74.12,117.74 77.75,117.74 78.45,118.44 78.63,118.44
GND on IN3 (solid shape): 83,97.56 83.02,97.44 82.93,97.38 81.51,97.38 81.22,97.09 75.81,97.09 75.46,97.44 75.44,97.55 75.53,97.61 82.94,97.61
GND on IN3 (solid shape): 97.6,102.21 97.66,102.3 97.77,102.28 98.83,101.22 98.83,100.58 100.02,99.39 100.65,99.39 100.73,99.31 100.74,99.25 100.7,99.22 100.03,99.22 97.6,101.66
GND on IN3 (solid shape): 106.15,97.87 106.21,97.96 106.32,97.94 106.37,97.89 106.37,94.71 106.3,94.62 106.19,94.64 105.86,94.97 105.86,95.99 106.15,96.28
GND on IN3 (solid shape): 120.67,39.89 120.73,39.98 120.84,39.96 123.45,37.35 123.84,37.35 124.24,36.95 124.27,36.83 124.17,36.77 123.7,36.77 120.67,39.8
GND on IN3 (solid shape): 139.87,116.46 139.89,116.35 139.8,116.29 139.13,116.29 138.78,116.64 138.78,116.74 137.38,118.14 137.36,118.25 137.45,118.31 138.02,118.31
GND on IN3 (solid shape): 164.8,28.11 167.33,28.11 167.37,28.08 167.39,27.97 167.3,27.9 164.2,27.9 163.15,28.95 163.13,29.06 163.23,29.12 163.79,29.12
GND on IN3 (solid shape): 41.56,41.68 41.6,41.65 41.59,41.6 41.18,41.18 41.18,40.02 40.88,39.71 40.81,39.7 40.72,39.72 40.69,39.8 40.69,40.23 41.02,40.55 41.02,41.26 41.44,41.68
