# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 134.77,116.89 134.85,116.84 134.87,116.75 134.85,116.69 134.85,116.63 135.23,116.25 135.61,116.63 135.61,116.69 135.59,116.75 135.61,116.84 135.69,116.89 136.43,116.89 136.51,116.84 136.52,116.75 136.51,116.69 136.5,116.63 136.88,116.25 137.27,116.63 137.26,116.69 137.25,116.75 137.26,116.84 137.34,116.89 137.78,116.89 137.92,116.75 137.92,116.49 139.12,115.29 141.03,115.29 141.24,115.09 141.23,115.01 141.33,114.75 141.58,114.65 141.73,114.68 141.85,114.77 141.96,114.8 142.03,114.7 142.03,114.65 142.11,114.56 142.14,114.49 142.12,114.42 142.09,114.39 142.07,114.35 141.98,114.3 141.89,114.35 141.76,114.49 141.58,114.54 141.41,114.49 141.28,114.37 141.19,114.33 141.11,114.38 140.97,114.51 140.78,114.56 140.76,114.56 140.68,114.59 140.65,114.66 140.65,114.73 140.34,115.04 138.77,115.04 137.96,115.85 132.28,115.85 128.65,112.22 127.89,112.22 127.8,112.27 127.81,112.38 127.86,112.48 127.88,112.59 127.81,112.81 127.62,112.95 127.56,113.02 127.59,113.12 128.7,114.23 129.8,114.23 132.45,116.89
GND on TOP (solid shape): outline of 83 points within 143.35,89.01 147.15,92.4
GND on TOP (solid shape): outline of 92 points within 0.5,116.64 38.02,123.42
GND on TOP (solid shape): outline of 109 points within 182.1,15.79 185.14,19.26
GND on TOP (solid shape): outline of 97 points within 21.16,46.44 24.9,51.91
GND on TOP (solid shape): outline of 232 points within 108.01,118.36 112.96,123.15
GND on TOP (solid shape): outline of 88 points within 124.17,83.53 140.02,93.85
GND on TOP (solid shape): outline of 90 points within 29.38,73.82 37.05,77.34
GND on TOP (solid shape): outline of 111 points within 116.49,35.2 122.91,50.35
GND on TOP (solid shape): 46.14,73.41 46.23,73.35 46.36,73.22 46.54,73.17 46.65,73.19 46.75,73.24 46.85,73.25 46.91,73.16 46.91,72.29 46.95,72.21 46.97,72.18 47.05,72 46.97,71.81 46.95,71.78 46.91,71.7 46.91,70.77 46.84,70.71 46.84,69.13 46.8,69.04 46.7,69.04 46.62,69.07 46.55,69.08 46.53,69.08 46.39,69.22 46.38,69.23 46.3,69.35 46.17,69.4 46.11,69.44 46.08,69.51 46.08,69.53 45.98,69.78 45.73,69.88 45.71,69.88 45.64,69.91 45.6,69.97 45.52,70.13 45.37,70.2 45.31,70.24 45.28,70.31 45.28,70.33 45.31,70.39 45.56,70.53 45.63,70.73 45.63,70.78 45.73,70.88 45.82,70.78 45.82,70.73 46.34,70.51 46.13,71.03 46.08,71.03 46,71.11 46,71.52 46.03,71.59 46.11,71.62 46.16,71.61 46.54,72 46.16,72.38 45.92,72.29 45.79,72.07 45.79,72.06 45.72,71.99 45.65,72.06 45.65,72.07 45.52,72.29 45.29,72.38 45.21,72.43 45.21,72.53 45.22,72.55 45.31,72.61 45.4,72.55 45.53,72.42 45.71,72.37 45.97,72.48 46.07,72.73 46.02,72.9 45.9,73.03 45.85,73.12 45.9,73.21 45.99,73.27 46.05,73.35
GND on TOP (solid shape): outline of 164 points within 43.1,103.86 46.18,106.93
GND on TOP (solid shape): outline of 92 points within 125.8,86.84 139.54,94.14
GND on TOP (solid shape): outline of 121 points within 58.66,106.65 63.45,111.45
GND on TOP (solid shape): outline of 120 points within 150.59,49.79 154.15,52.34
GND on TOP (solid shape): outline of 92 points within 34.1,43.4 37.24,47.55
GND on TOP (solid shape): 53.26,66.85 53.34,66.8 53.48,66.68 53.66,66.64 53.8,66.67 53.93,66.75 54,66.78 54.07,66.75 54.37,66.46 57,66.46 57.34,66.25 57.68,66.46 58.04,66.46 64.08,60.41 68.78,60.41 68.86,60.37 68.88,60.28 68.86,60.22 68.86,60.16 69.24,59.78 69.62,60.16 69.62,60.22 69.6,60.28 69.62,60.37 69.7,60.41 72.07,60.41 72.15,60.37 72.17,60.28 72.15,60.22 72.15,60.16 72.53,59.78 72.91,60.16 72.9,60.22 72.89,60.28 72.9,60.37 72.99,60.41 75.91,60.41 76,60.37 76.01,60.27 75.99,60.2 75.98,60.13 76.36,59.75 76.75,60.13 76.74,60.2 76.72,60.27 76.73,60.37 76.81,60.41 77.96,60.41 78.04,60.37 78.06,60.28 78.04,60.22 78.04,60.15 78.42,59.77 78.8,60.15 78.8,60.22 78.78,60.28 78.79,60.37 78.88,60.41 80.18,60.41 80.28,60.35 80.26,60.25 80.2,60.14 80.18,60.01 80.2,59.9 80.25,59.79 80.26,59.69 80.17,59.63 64.36,59.63 58.64,65.35 58.65,65.43 58.54,65.7 58.27,65.81 58.19,65.8 57.91,66.08 53.39,66.08 52.96,66.52 52.93,66.61 53,66.68 53.1,66.73 53.18,66.81
GND on TOP (solid shape): outline of 124 points within 38.31,24.25 51.18,28.99
GND on TOP (solid shape): outline of 142 points within 159.63,16.72 166.48,19.59
GND on TOP (solid shape): outline of 112 points within 40.13,51.08 45.63,53.09
GND on TOP (solid shape): outline of 112 points within 172.36,19.21 180.42,26.98
GND on TOP (solid shape): outline of 137 points within 64.77,32.23 68.96,34.75
GND on TOP (solid shape): outline of 315 points within 130.99,103.55 138.27,106.63
GND on TOP (solid shape): outline of 130 points within 93.24,18.83 116.35,26.08
GND on TOP (solid shape): outline of 328 points within 78.83,69.03 85.96,72.32
GND on TOP (solid shape): outline of 93 points within 83.19,53.27 87.56,55.45
GND on TOP (solid shape): outline of 315 points within 64.74,30.53 67.25,33.27
GND on TOP (solid shape): outline of 162 points within 69.58,18 83.84,33.88
GND on TOP (solid shape): outline of 425 points within 123.17,35.45 138.28,39.25
GND on TOP (solid shape): outline of 168 points within 94.11,31.65 104.83,35.2
GND on TOP (solid shape): outline of 168 points within 20.43,10.28 27.86,15.2
GND on TOP (solid shape): outline of 458 points within 101.37,51.3 109.5,59.36
GND on TOP (solid shape): outline of 163 points within 120.86,81.96 142.15,95.72
GND on TOP (solid shape): outline of 178 points within 139.24,85.51 143.65,92.42
GND on TOP (solid shape): outline of 189 points within 102.57,52.53 122.91,74.17
GND on TOP (solid shape): outline of 234 points within 48.29,100.97 54.56,109.32
GND on TOP (solid shape): outline of 233 points within 52.68,100.08 60.5,107.22
GND on TOP (solid shape): outline of 499 points within 51.66,106.41 58.55,114.75
GND on TOP (solid shape): outline of 578 points within 93.28,73.52 100.73,79.34
GND on TOP (solid shape): outline of 618 points within 45.3,13.71 59.8,30.03
GND on TOP (solid shape): outline of 661 points within 38.8,104.95 51.93,115.47
GND on TOP (solid shape): outline of 200 points within 40.82,68.44 45.45,74.77
GND on TOP (solid shape): outline of 677 points within 198.2,17.79 205.4,28.92
GND on TOP (solid shape): outline of 700 points within 103.88,36.54 117.49,50.69
GND on TOP (solid shape): outline of 703 points within 125.84,92.76 144.23,112.75
GND on TOP (solid shape): outline of 335 points within 130.28,28.43 144.21,36.79
GND on TOP (solid shape): outline of 795 points within 127.53,39.81 143.2,65.14
GND on TOP (solid shape): outline of 389 points within 140.83,25.25 163.09,35.14
GND on TOP (solid shape): outline of 988 points within 47.45,54.46 80.57,62.66
GND on TOP (solid shape): outline of 562 points within 147.57,12.8 165.36,21
GND on TOP (solid shape): outline of 1570 points within 60.9,15.21 73.21,36.77
GND on TOP (solid shape): outline of 5753 points within 48.32,15.5 98.53,66.78
GND on TOP (solid shape): outline of 5601 points within 28.26,30.01 47.38,55.63
GND on TOP (solid shape): outline of 7495 points within 28.65,50.83 94.69,106.39
GND on TOP (solid shape): outline of 12603 points within 0.5,14.62 63.76,104
GND on TOP (solid shape): outline of 19890 points within 0.5,0.5 224.67,127.5
GND on BOTTOM (solid shape): 107.56,51.99 105.53,51.99 104.45,50.9 103.56,50.9 102.44,49.78 101.86,49.78 101.63,50.01 101.81,50.19 102.24,50.19 103.09,51.04 104.32,51.04 105.39,52.11 107.56,52.11
GND on BOTTOM (solid shape): 115.95,37.99 115.81,37.85 115.12,37.85 114.68,37.4 114.68,37.31 114.53,37.31 114.53,37.45 114.08,37.89 114.09,37.95 114.1,38.03 115.32,38.03 115.64,38.35 115.86,38.35 115.95,38.35
GND on BOTTOM (solid shape): 79.45,66.02 78.82,65.39 77.75,65.39 77.59,65.55 77.6,65.62 77.6,65.65 77.6,65.7 77.59,65.75 77.6,65.84 77.68,65.88 77.96,66.16 79.45,66.16
GND on BOTTOM (solid shape): 107.65,62.41 107.7,62.41 107.7,62.35 107.69,62.31 107.68,62.28 107.69,61.89 107.66,61.82 107.58,61.78 107.53,61.78 105.63,59.88 101.73,59.88 101.61,60 101.88,60.27 102.16,60.27 102.4,60.51 102.86,60.51 103.29,60.08 105.62,60.08 107.39,61.85 107.39,62.56 107.41,62.58 107.47,62.58
GND on BOTTOM (solid shape): 121.3,116.92 121.3,116.15 120.97,115.82 120.97,114.97 120.79,114.79 120.64,114.94 120.64,115.85 120.79,116 120.79,116.56 120.93,116.69 120.98,116.87 120.98,116.91 120.97,116.95 120.99,117.03 121.06,117.07 121.12,117.09
GND on BOTTOM (solid shape): 28.13,68.47 28.19,68.56 28.3,68.54 28.99,67.85 29.72,67.85 29.98,67.6 29.98,67.23 29.93,67.14 29.83,67.14 29.75,67.17 29.65,67.19 29.54,67.17 29.44,67.12 28.13,67.12
GND on BOTTOM (solid shape): 142.87,46.57 142.87,45.91 142.46,45.5 142.46,45.13 142.35,45.13 142.35,44.34 142.46,44.34 142.48,44.28 142.48,44.22 142.15,44.22 142.09,44.28 142.09,45.13 141.97,45.13 141.97,45.26 141.84,45.39 141.6,45.39 141.4,45.59 141.37,45.66 141.41,45.74 141.44,45.78 141.46,45.83 141.46,46.02 142.08,46.64 142.8,46.64
GND on BOTTOM (solid shape): 67.65,104.81 67.7,104.9 67.8,104.9 67.87,104.88 67.95,104.87 68,104.88 68.13,104.75 68.13,104.63 68.2,104.47 68.36,104.4 68.52,104.4 68.52,103.75 68.52,103.67 67.86,103.67 67.65,103.87
GND on BOTTOM (solid shape): 105.82,66.35 105.92,66.38 105.99,66.31 106,66.28 105.99,66.18 105.91,66.14 105.79,66.14 104.46,64.81 103.57,64.81 102.88,64.12 102.82,64.05 102.82,64.03 102.67,63.88 101.73,63.88 101.62,64 101.92,64.3 102.91,64.3 103.57,64.96 104.43,64.96
GND on BOTTOM (solid shape): 51.75,39.3 51.83,39.26 51.84,39.16 51.82,39.09 51.81,39.01 51.81,38.97 51.83,38.89 51.54,38.61 51.23,38.61 51.21,38.63 51.19,38.66 51.16,38.68 51.13,38.69 51.13,38.83 49.33,38.83 49.33,39.08 51.13,39.08 51.13,39.22 51.16,39.23 51.19,39.25 51.21,39.28 51.23,39.3
GND on BOTTOM (solid shape): 88.53,34.89 88.37,34.73 87.64,34.73 87.52,34.61 87.48,34.61 87.46,34.62 87.42,34.65 87.37,34.66 86.99,34.66 86.9,34.62 86.87,34.53 86.87,34.33 86.89,34.25 86.97,34.21 87.01,34.2 87.01,34.1 86.9,34.06 86.3,34.67 86.3,34.99 87.38,34.99 87.59,35.19 88.53,35.19
GND on BOTTOM (solid shape): 51.81,84.85 51.9,84.81 51.91,84.71 51.89,84.64 51.88,84.57 51.88,84.51 51.9,84.45 51.91,84.42 51.6,84.11 51.23,84.11 51.21,84.13 51.19,84.16 51.16,84.18 51.13,84.19 51.13,84.33 49.33,84.33 49.33,84.58 51.13,84.58 51.13,84.72 51.16,84.73 51.19,84.75 51.21,84.78 51.23,84.8 51.31,84.8 51.36,84.85
GND on BOTTOM (solid shape): 51.87,81.8 51.96,81.75 51.95,81.64 51.91,81.55 51.89,81.44 51.89,81.39 51.91,81.32 51.7,81.11 51.23,81.11 51.21,81.13 51.19,81.16 51.16,81.18 51.13,81.19 51.13,81.33 49.33,81.33 49.33,81.58 51.13,81.58 51.13,81.72 51.16,81.73 51.19,81.75 51.21,81.78 51.23,81.8
GND on BOTTOM (solid shape): 51.88,36.3 51.97,36.25 51.96,36.14 51.9,36.04 51.89,35.93 51.89,35.88 51.91,35.81 51.71,35.61 51.23,35.61 51.21,35.63 51.19,35.66 51.16,35.68 51.13,35.69 51.13,35.83 49.33,35.83 49.33,36.08 51.13,36.08 51.13,36.22 51.16,36.23 51.19,36.25 51.21,36.28 51.23,36.3
GND on BOTTOM (solid shape): 51.96,41.3 52.05,41.25 52.04,41.15 52,41.05 51.99,40.95 51.99,40.91 52.01,40.83 51.78,40.61 51.23,40.61 51.21,40.63 51.19,40.66 51.16,40.68 51.13,40.69 51.13,40.83 49.33,40.83 49.33,41.08 51.13,41.08 51.13,41.22 51.16,41.23 51.19,41.25 51.21,41.28 51.23,41.3
GND on BOTTOM (solid shape): 52.11,46.8 52.2,46.75 52.2,46.65 52.16,46.56 52.14,46.46 52.15,46.42 52.16,46.34 51.93,46.11 51.23,46.11 51.21,46.13 51.19,46.16 51.16,46.18 51.13,46.19 51.13,46.33 49.33,46.33 49.33,46.58 51.13,46.58 51.13,46.72 51.16,46.73 51.19,46.75 51.21,46.78 51.23,46.8
GND on BOTTOM (solid shape): 123.94,103.49 124.55,103.49 124.63,103.45 124.64,103.36 124.63,103.3 124.62,103.24 124.63,103.18 124.64,103.12 124.63,103.03 124.55,102.98 124.23,102.98 123.64,103.57 123.21,103.57 123.14,103.64 122.85,103.64 122.85,103.76 122.89,103.8 123.14,103.8 123.21,103.87 123.56,103.87
GND on BOTTOM (solid shape): 126.72,110.17 126.7,110.07 126.51,109.89 124.96,109.89 124.59,109.51 124.22,109.51 124.13,109.55 124.12,109.65 124.14,109.7 124.14,109.76 124.14,109.82 124.12,109.88 124.13,109.98 124.22,110.02 126.39,110.02 126.62,110.25
GND on BOTTOM (solid shape): 21.3,40.03 21.3,40.02 21.3,39.45 21.21,39.45 21.17,39.42 21.1,39.38 21.02,39.36 20.85,39.43 20.77,39.59 20.76,39.65 20.46,39.94 19.85,39.94 19.78,39.97 19.75,40.05 19.75,40.09 19.77,40.16 19.85,40.19 21.13,40.19
GND on BOTTOM (solid shape): 52.2,82.63 52.19,82.6 52.16,82.53 52.16,82.46 52.17,82.36 52.21,82.27 52.22,82.16 52.13,82.11 51.23,82.11 51.21,82.13 51.19,82.16 51.16,82.18 51.13,82.19 51.13,82.33 49.33,82.33 49.33,82.58 51.13,82.58 51.13,82.72 51.16,82.73 51.19,82.75 51.21,82.78 51.23,82.8 52.03,82.8
GND on BOTTOM (solid shape): 99.71,75.53 99.9,75.33 100.03,75.2 100.21,75.15 100.35,75.18 100.46,75.25 100.57,75.27 100.63,75.18 100.63,75.08 100.23,74.68 99.77,74.68 99.54,74.44 99.42,74.42 99.36,74.51 99.36,75.54 99.56,75.74 99.71,75.74
GND on BOTTOM (solid shape): 148.54,66.91 148.65,66.94 148.71,66.84 148.71,66.8 148.75,66.71 148.84,66.68 149.45,66.68 149.62,66.5 149.62,66.1 149.62,66.1 149.62,65.48 148.81,65.48 148.81,65.66 148.45,66.03 148.18,66.03 148.11,66.05 148.11,66.16 147.32,66.16 147.32,66.05 147.26,66.03 147.2,66.03 147.2,66.36 147.26,66.42 148.11,66.42 148.11,66.54 148.16,66.54
GND on BOTTOM (solid shape): 52.02,86.7 52,86.62 52,86.58 52.11,86.33 52.36,86.22 52.4,86.22 52.46,86.24 52.52,86.18 52.45,86.11 51.23,86.11 51.21,86.13 51.19,86.16 51.16,86.18 51.13,86.19 51.13,86.33 49.33,86.33 49.33,86.58 51.13,86.58 51.13,86.72 51.16,86.73 51.19,86.75 51.21,86.78 51.23,86.8 51.33,86.8 51.43,86.9 51.82,86.9
GND on BOTTOM (solid shape): 52.1,48.8 52.19,48.74 52.16,48.62 52.07,48.5 52.04,48.35 52.04,48.31 52.06,48.23 51.84,48.01 51.44,48.01 51.35,48.11 51.23,48.11 51.21,48.13 51.19,48.16 51.16,48.18 51.13,48.19 51.13,48.33 49.33,48.33 49.33,48.58 51.13,48.58 51.13,48.72 51.16,48.73 51.19,48.75 51.21,48.78 51.23,48.8
GND on BOTTOM (solid shape): 111.46,46.71 111.54,46.67 111.56,46.58 111.55,46.52 111.54,46.47 111.63,46.23 111.85,46.11 111.9,46.11 111.9,45.98 111.85,45.89 111.75,45.89 111.68,45.92 111.61,45.93 111.59,45.93 111.3,46.23 110.56,46.23 110.56,46.65 110.56,46.71
GND on BOTTOM (solid shape): 77.64,52.29 77.68,52.27 77.67,52.22 77.64,52.14 77.63,52.05 77.7,51.84 77.89,51.71 77.92,51.7 77.92,51.61 77.81,51.61 77.75,51.64 77.7,51.64 76.19,51.64 74.52,49.98 74.47,49.98 74.38,50.04 74.4,50.15 76.56,52.31 77.6,52.31
GND on BOTTOM (solid shape): 107.31,77.95 109.59,77.95 110.17,77.37 110.17,76.86 110.62,76.41 110.65,76.3 110.55,76.24 109.31,76.24 108.71,76.84 108.71,77.44 108.39,77.76 107.3,77.76 107.05,77.51 106.57,77.51 106.48,77.55 106.47,77.64 106.48,77.68 106.48,78.24 106.47,78.29 106.48,78.38 106.57,78.42 106.84,78.42
GND on BOTTOM (solid shape): 158.78,18.21 158.79,18.16 158.74,18.12 158.69,18.12 158.6,18.09 158.57,18 158.57,16.87 158.5,16.85 158.45,16.86 158.43,16.91 158.43,18 158.39,18.09 158.3,18.12 158.1,18.12 157.04,19.19 157.01,19.3 157.11,19.37 157.62,19.37
GND on BOTTOM (solid shape): 207.54,22.4 207.75,22.4 207.85,22.35 207.96,22.34 208.05,22.35 208.13,22.38 208.18,22.37 208.2,22.31 208.19,22.27 208.19,21.58 208.23,21.49 208.32,21.45 208.48,21.45 208.53,21.42 208.52,21.37 208.42,21.27 207.53,21.27 207.15,20.89 206.94,20.89 206.79,21.04 206.79,22.49 206.94,22.64 207.3,22.64
GND on BOTTOM (solid shape): 77.63,63.6 77.63,63.1 77.57,63 77.46,63.03 77.14,63.35 77.15,63.42 77.15,63.46 77.04,63.73 76.77,63.84 76.71,63.84 76.65,63.82 76.56,63.83 76.52,63.91 75.93,64.5 75.9,64.61 76,64.67 76.56,64.67
GND on BOTTOM (solid shape): 52.42,77.37 52.36,77.31 52.32,77.32 52.07,77.21 51.96,76.96 51.98,76.86 52.02,76.77 52.02,76.66 51.93,76.61 51.23,76.61 51.21,76.63 51.19,76.66 51.16,76.68 51.13,76.69 51.13,76.83 49.33,76.83 49.33,77.08 51.13,77.08 51.13,77.22 51.16,77.23 51.2,77.26 51.23,77.31 51.23,77.33 51.33,77.43 52.36,77.43
GND on BOTTOM (solid shape): 47.33,17.56 47.33,17.23 47.33,17.23 47.33,17.07 47.56,16.84 47.56,16.48 47.68,16.36 47.68,15.93 47.41,15.67 47.24,15.67 47.21,15.67 47.13,15.69 47.09,15.77 47.09,16.26 46.85,16.5 46.67,16.5 46.29,16.88 46.28,16.94 46.32,16.97 46.41,16.97 46.58,17.04 46.64,17.2 46.64,17.5 46.64,17.51 46.67,17.59 46.74,17.62 47.26,17.62
GND on BOTTOM (solid shape): 75.43,46.21 75.46,46.26 75.52,46.24 75.55,46.21 76.51,46.21 76.6,46.15 76.58,46.04 76.44,45.9 76.37,45.92 76.32,45.92 76.07,45.81 75.96,45.56 75.98,45.47 76.02,45.38 76.02,45.27 75.93,45.22 75.45,45.22 75.43,45.24
GND on BOTTOM (solid shape): 96.38,79.31 96.38,79.09 96.35,79.01 96.27,78.98 95.88,78.98 95.79,78.95 95.76,78.86 95.76,78.84 95.73,78.8 95.68,78.8 95.59,78.84 95.49,78.85 95.43,78.85 95.37,78.83 95.29,78.84 95.24,78.9 95.2,78.96 95.12,78.98 94.75,78.98 94.55,79.18 94.55,79.36 94.75,79.56 96.13,79.56
GND on BOTTOM (solid shape): 130.97,38.35 138,38.35 138.11,38.45 138.18,38.48 138.25,38.45 138.29,38.43 138.33,38.41 138.37,38.41 138.37,38.07 138.33,38.06 138.25,38.02 138.22,37.94 138.22,37.12 130.86,37.12 130.8,37.18 130.68,37.18 130.6,37.21 130.58,37.3 130.58,37.32 130.58,37.52 130.56,37.6 130.5,37.64 130.47,37.65 130.47,37.76 130.22,38.01 130.22,38.42 130.31,38.51 130.81,38.51
GND on BOTTOM (solid shape): 188.49,19.82 188.56,19.91 188.67,19.88 188.8,19.78 188.97,19.74 188.97,19.74 189.07,19.68 189.05,19.57 188.12,18.64 188.12,18.18 187.84,17.89 187.55,17.89 187.46,17.95 187.47,18.06 187.54,18.17 187.56,18.3 187.56,18.34 187.54,18.41 188.49,19.36
GND on BOTTOM (solid shape): 107.6,49.38 107.58,49.31 107.42,49.31 107.04,48.93 106.93,49.03 106.64,49.03 106.39,48.78 106.39,48.56 106.36,48.49 106.29,48.46 106.14,48.46 106.07,48.44 106.01,48.41 105.82,48.21 105.82,47.99 105.83,47.92 105.87,47.87 105.92,47.82 105.87,47.76 105.33,47.76 105.12,47.97 104.57,47.97 104.35,47.76 101.87,47.76 101.68,47.95 101.65,48.04 101.72,48.12 101.8,48.15 102.29,48.15 102.36,48.22 103.92,48.22 104.4,48.7 105.55,48.7 106.28,49.44 107.6,49.44
GND on BOTTOM (solid shape): 110.53,52.34 110.68,52.19 110.74,52.15 110.81,52.13 111.49,52.13 111.49,52.04 111.47,52.02 110.85,52.02 110.49,51.66 110.49,51.35 110.28,51.15 110.28,50.52 110.17,50.4 110.12,50.45 110.12,50.49 110.1,50.62 110.03,50.73 110.01,50.79 110.03,50.86 110.1,50.97 110.12,51.09 110.08,51.25 109.98,51.37 109.94,51.45 109.97,51.53 110.32,51.87 110.32,52.41 110.32,52.41 110.53,52.41
GND on BOTTOM (solid shape): 54.17,17 55.97,17 56.07,16.94 56.04,16.83 55.05,15.84 52.77,15.84 52.64,15.97 52.64,16.41 52.68,16.49 52.77,16.5 52.81,16.5 52.85,16.49 53.15,16.49 53.31,16.56 53.37,16.72 53.37,17 53.33,17.14 53.21,17.22 53.17,17.23 53.17,17.37 53.45,17.37 53.53,17.4 53.57,17.47 53.58,17.51 53.66,17.51
GND on BOTTOM (solid shape): 196.42,32.77 196.49,32.86 196.6,32.84 196.78,32.66 196.76,32.59 196.76,32.55 196.77,32.48 196.79,32.41 196.78,32.31 196.69,32.27 196.51,32.27 196.42,32.23 196.39,32.14 196.39,31.48 196.08,31.48 195.66,31.89 195.66,32.01 195.66,32.03 195.64,32.12 195.66,32.2 195.66,32.22 195.66,32.6 195.74,32.6 196.3,32.6 196.39,32.64 196.42,32.73
GND on BOTTOM (solid shape): 126.45,109.58 126.54,109.53 126.54,109.42 126.5,109.33 126.48,109.23 126.49,109.18 126.5,109.11 125.95,108.56 125.92,108.56 125.84,108.6 125.82,108.7 125.84,108.75 125.85,108.81 125.74,109.07 125.49,109.17 125.44,109.17 125.37,109.15 125.21,109.31 125.06,109.31 124.97,109.37 124.99,109.48 125.09,109.58
GND on BOTTOM (solid shape): 207.16,17.77 207.48,17.77 207.8,17.45 207.78,17.38 207.78,17.33 207.89,17.06 208.16,16.95 208.21,16.95 208.28,16.97 208.3,16.95 208.33,16.87 208.3,16.8 208.29,16.79 208.21,16.76 208.14,16.79 208.06,16.85 207.97,16.87 207.7,16.87 207.57,17 207.37,17 206.75,17.63 206.72,17.74 206.82,17.81 207.11,17.81
GND on BOTTOM (solid shape): 112.47,77.89 112.56,77.78 112.69,77.73 112.99,77.73 113.08,77.75 113.16,77.81 113.24,77.85 113.31,77.82 113.38,77.76 113.42,77.76 113.5,77.72 113.52,77.62 113.51,77.59 113.51,77.38 113.52,77.34 113.54,77.3 113.57,77.27 113.38,77.08 112.46,77.08 112.32,76.94 111.91,76.94 111.91,77.65 111.9,77.7 111.87,77.74 111.84,77.81 111.87,77.89 111.9,77.92 112.46,77.92
GND on BOTTOM (solid shape): 124.33,105.57 125.3,105.57 125.69,105.19 125.67,105.11 125.67,105.07 125.68,105.01 125.69,104.95 125.68,104.86 125.6,104.81 125.13,104.81 125.05,104.86 125.04,104.95 125.05,105.01 125.06,105.07 124.95,105.32 124.7,105.42 124.58,105.4 124.47,105.34 124.4,105.31 124.33,105.34 123.92,105.75 123.24,105.75 123.08,105.91 123.1,105.98 123.12,105.98 123.26,106.11 123.79,106.11
GND on BOTTOM (solid shape): 162.13,19.35 162.16,19.26 162.1,19.18 162.04,19.15 161.99,19.12 161.93,19.1 161.86,19.12 161.74,19.19 161.61,19.22 161.34,19.11 161.22,18.84 161.23,18.78 161.24,18.72 161.23,18.63 161.15,18.58 161.05,18.58 160.83,18.81 159.97,18.81 159.54,19.24 159.52,19.35 159.61,19.42 162.07,19.42
GND on BOTTOM (solid shape): 68.07,120.49 68.18,120.52 68.24,120.42 68.24,119.39 68.19,119.35 68.16,119.33 68.08,119.29 68.01,119.33 67.93,119.38 67.83,119.41 67.55,119.41 67.44,119.37 67.35,119.28 67.34,119.26 67.11,119.26 67.09,119.28 67.01,119.37 66.89,119.41 66.62,119.41 66.62,119.53 66.7,119.61 66.89,119.61 67.05,119.68 67.12,119.84 67.12,120.03 67.5,120.41 67.98,120.41
GND on BOTTOM (solid shape): 110.35,57.25 110.46,56.98 110.73,56.87 110.85,56.89 110.96,56.94 111.05,56.96 111.11,56.89 111.11,53.34 111.1,53.33 110.93,53.33 110.84,53.29 110.8,53.2 110.8,52.87 110.76,52.83 110.71,52.82 110.68,52.81 110.62,52.81 110.62,53.2 110.58,53.29 110.49,53.33 110.11,53.33 110.11,57.2 110.24,57.34 110.35,57.34
GND on BOTTOM (solid shape): 112.44,119.5 112.48,119.48 112.5,119.45 112.5,119.28 112.47,119.23 112.45,119.18 112.45,118.79 112.47,118.74 112.5,118.69 112.5,118.29 112.34,118.13 111.85,118.13 111.72,117.99 111.66,117.98 111.63,118.03 111.63,118.16 111.82,118.35 111.82,118.52 111.97,118.66 112.03,118.86 112,118.99 111.93,119.11 111.9,119.19 111.94,119.26 111.96,119.28 111.99,119.31 112.09,119.31 112.23,119.45 112.33,119.45 112.37,119.46 112.4,119.48
GND on BOTTOM (solid shape): 84.66,40.79 84.66,40.51 84.65,40.5 84.65,39.85 84.64,39.81 84.64,39.46 84.63,39.42 84.37,39.29 84.28,39.05 84.38,38.8 84.62,38.7 84.71,38.63 84.69,38.52 84.33,38.16 84.2,38.16 84.13,38.27 84.02,38.34 83.96,38.41 83.99,38.5 84.03,38.54 84.03,39.7 84.38,40.05 84.38,40.76 84.53,40.92
GND on BOTTOM (solid shape): 117.57,119.48 117.64,119.46 117.67,119.44 117.72,119.43 118.09,119.43 118.09,119.28 118.05,119.23 118.04,119.18 118.04,118.77 116.2,116.93 116.09,116.91 116.03,117.01 116.03,117.74 116.47,118.18 116.47,118.69 116.51,118.74 116.53,118.79 116.53,119.18 116.51,119.23 116.47,119.28 116.47,119.43 116.85,119.43 116.89,119.44 116.93,119.46 116.99,119.48 117.06,119.46 117.16,119.41 117.28,119.39 117.4,119.41 117.51,119.46
GND on BOTTOM (solid shape): 79.47,72.34 79.5,72.24 79.44,72.17 79.29,72.05 79.24,71.86 79.24,71.86 79.21,71.79 79.16,71.76 79.13,71.75 79.1,71.74 79,71.74 78.95,71.83 78.95,71.93 78.47,72.41 77.6,72.41 77.48,72.53 77.45,72.63 77.52,72.7 77.68,72.82 77.74,73.01 77.73,73.06 77.72,73.11 77.74,73.2 77.82,73.24 78.57,73.24
GND on BOTTOM (solid shape): 105.55,80.84 105.55,80.18 106.39,79.33 106.41,79.22 106.32,79.16 104.91,79.16 104.77,79.3 104.79,79.33 104.83,79.42 104.84,79.51 104.73,79.78 104.46,79.89 104.43,79.89 104.13,80.2 104.13,80.43 104.17,80.43 104.24,80.48 104.27,80.56 104.27,80.76 104.26,80.8 104.28,80.89 104.36,80.93 104.42,80.93 104.46,80.89 104.52,80.88 104.9,80.88 104.99,80.92 105.03,81.01 105.03,81.21 105.02,81.25 105.08,81.31
GND on BOTTOM (solid shape): 115.41,34.92 115.5,34.84 115.61,34.81 115.91,34.81 115.98,34.82 116.04,34.85 116.07,34.87 116.5,34.45 116.54,34.45 116.54,34.18 116.51,34.1 116.43,34.07 115.36,34.07 115.01,33.73 114.92,33.7 114.85,33.77 114.81,33.84 114.77,33.9 114.74,33.97 114.76,34.04 114.83,34.15 114.85,34.28 114.77,34.51 114.57,34.65 114.55,34.65 114.51,34.7 114.6,34.79 114.62,34.79 114.78,34.83 114.91,34.92
GND on BOTTOM (solid shape): 91.19,36.76 91.24,36.77 91.27,36.73 91.27,36.67 91.42,36.52 91.42,36.09 91.38,36.05 91.37,35.99 91.37,35.82 91.35,35.8 91.35,35.22 91.31,35.14 91.22,35.13 91.17,35.14 91.12,35.14 90.87,35.04 90.76,34.78 90.77,34.77 90.74,34.69 90.66,34.66 90.37,34.66 90.28,34.62 90.24,34.53 90.24,34.33 90.25,34.3 90.26,34.28 90.27,34.24 90.13,34.11 90.13,34.1 90.1,34.06 89.7,34.06 89.7,34.33 90.35,34.98 90.53,34.98 91.05,35.5 91.05,36.11 90.89,36.27 90.89,36.46
GND on BOTTOM (solid shape): 197.41,28.54 197.44,28.53 197.47,28.52 198.13,28.52 198.15,28.52 198.2,28.51 198.21,28.46 198.2,28.42 198.17,28.31 198.1,28.28 197.92,28.28 197.78,28.22 197.72,28.08 197.72,27.78 197.78,27.63 197.92,27.57 197.99,27.57 198.05,27.51 198.06,27.46 198.02,27.43 196.66,27.43 196.3,27.78 196.3,28.01 196.34,28.06 196.35,28.12 196.35,28.37 196.38,28.41 196.44,28.4 196.46,28.38 197.19,28.38 197.38,28.57
GND on BOTTOM (solid shape): 109.65,121.92 110.65,121.92 110.74,121.88 110.75,121.79 110.73,121.72 110.73,121.65 110.74,121.58 110.75,121.51 110.76,121.48 110.54,121.26 110.44,121.24 110.37,121.32 110.22,121.61 109.92,121.73 109.66,121.65 109.49,121.43 109.43,121.37 109.36,121.37 109.29,121.39 109.22,121.4 109.13,121.39 109.05,121.36 108.95,121.36 108.9,121.45 108.9,121.68 109.24,122.02 109.55,122.02
GND on BOTTOM (solid shape): 174.23,31.81 174.33,31.75 174.3,31.64 173.92,31.26 173.92,30.75 173.77,30.59 173.2,30.59 173.12,30.65 173.12,30.75 173.16,30.84 173.17,30.94 172.82,31.3 172.46,30.94 172.47,30.84 172.52,30.75 172.52,30.65 172.43,30.59 171.24,30.59 171.14,30.66 171.17,30.77 172.21,31.81
GND on BOTTOM (solid shape): 127.91,110.07 128,110.1 128.07,110.04 128.09,110 128.1,109.97 128.08,109.94 128,109.82 127.97,109.67 127.97,109.63 127.99,109.55 126.79,108.36 126.43,108.36 126.33,108.42 126.36,108.53 126.72,108.89 126.79,108.88 126.84,108.88 127.09,108.98 127.2,109.23 127.1,109.47 126.88,109.59 126.79,109.65 126.81,109.76 127.03,109.97 127.81,109.97
GND on BOTTOM (solid shape): 188.89,17.91 188.94,18 189.04,18 189.14,17.96 189.24,17.94 189.28,17.95 189.35,17.96 189.61,17.7 189.87,17.7 189.89,17.66 189.9,17.63 189.89,17.6 189.88,17.57 189.87,17.53 189.87,17.48 189.33,16.94 189.26,16.95 189.22,16.95 189.06,16.92 188.93,16.82 188.86,16.79 188.78,16.82 188.67,16.9 188.53,16.93 188.35,16.88 188.22,16.74 188.21,16.74 187.07,15.59 186.95,15.57 186.89,15.66 186.89,16.76 187.27,17.13 188.15,17.13 188.89,17.86
GND on BOTTOM (solid shape): 100.56,77.03 100.59,76.95 100.55,76.87 100.42,76.75 100.37,76.58 100.34,76.51 100.26,76.48 100.21,76.49 100.03,76.44 99.9,76.31 99.32,76.31 98.79,75.78 98.79,75.66 98.75,75.57 98.66,75.56 98.61,75.57 98.56,75.57 98.49,75.57 98.42,75.54 98.32,75.55 98.28,75.64 98.28,75.67 98.25,75.83 98.15,75.96 98.12,76.07 98.22,76.13 98.87,76.13 100.02,77.29 100.31,77.29
GND on BOTTOM (solid shape): 155.82,18.42 155.82,18.12 155.69,18.12 155.6,18.09 155.57,18 155.57,16.91 155.58,16.84 155.62,16.8 155.67,16.74 155.66,16.67 155.63,16.58 155.62,16.5 155.67,16.3 155.82,16.16 155.82,15.67 155.76,15.57 155.65,15.59 155.18,16.06 155.18,16.16 155.33,16.3 155.38,16.5 155.37,16.58 155.34,16.67 155.33,16.74 155.37,16.8 155.42,16.84 155.43,16.91 155.43,18 155.39,18.09 155.3,18.12 154.99,18.12 154.85,18.27 154.85,18.68 155.56,18.68
GND on BOTTOM (solid shape): 71.56,119.35 71.61,119.3 71.61,117.68 71.46,117.53 71.31,117.53 71.22,117.49 71.18,117.4 71.18,117.12 70.97,116.92 70.86,116.9 70.8,116.99 70.8,117.4 70.65,117.55 70.65,118.18 70.62,118.28 70.53,118.31 70.43,118.31 70.39,118.34 70.4,118.4 70.5,118.5 70.68,118.5 70.84,118.57 70.91,118.73 70.91,119.03 70.88,119.14 70.8,119.23 70.77,119.24 70.77,119.48 70.8,119.49 70.88,119.58 70.91,119.69 70.91,119.99 70.9,120.05 71.02,120.18 71.03,120.18 71.28,120.42 71.46,120.42 71.56,120.43
GND on BOTTOM (solid shape): 127.74,105.14 127.72,105.06 127.72,105.02 127.73,104.96 127.74,104.91 127.72,104.82 127.64,104.77 127.18,104.77 126.81,104.4 126.5,104.4 126.44,104.39 126.37,104.46 126.6,104.69 126.67,104.67 126.72,104.67 127.07,105.02 126.72,105.38 126.58,105.35 126.46,105.27 126.38,105.24 126.31,105.28 126.19,105.39 126.03,105.42 125.98,105.42 125.91,105.4 125.83,105.48 125.81,105.59 125.91,105.65 127.23,105.65
GND on BOTTOM (solid shape): 145.75,41.29 145.97,41.29 145.98,41.26 146,41.23 145.98,41.2 145.95,41.13 145.93,41.06 145.93,40.63 145.96,40.52 146.04,40.44 146.06,40.42 146.06,40.19 146.65,39.6 146.96,39.6 147.01,39.57 147,39.51 146.92,39.43 146.13,39.43 145.89,39.19 145.78,39.17 145.72,39.26 145.72,39.45 145.59,39.57 144.93,39.57 144.84,39.48 144.78,39.47 144.75,39.51 144.75,39.61 144.73,39.7 144.68,39.78 144.65,39.85 144.68,39.92 144.84,40.09 144.84,40.87 144.85,40.88 144.85,41.04 145.05,41.23 145.36,41.23 145.45,41.27 145.49,41.36 145.49,41.47 145.57,41.47
GND on BOTTOM (solid shape): 66.17,16.83 66.19,16.72 66.1,16.66 60.72,16.66 60.26,16.2 60.06,16.2 59.97,16.25 59.97,16.35 60,16.43 60.01,16.52 59.62,16.9 59.24,16.52 59.25,16.43 59.28,16.35 59.28,16.25 59.19,16.2 57.77,16.2 57.68,16.25 57.68,16.35 57.71,16.43 57.72,16.52 57.72,16.58 57.7,16.64 57.72,16.73 57.8,16.77 59.12,16.77 61.51,19.16 63.84,19.16
GND on BOTTOM (solid shape): 185.5,28.59 185.53,28.54 185.53,28.05 187.36,26.22 187.36,25.61 187.69,25.28 187.69,23.36 188.5,22.55 188.5,20.95 187.88,20.33 187.88,19.62 187.23,18.96 187.08,18.96 186.91,19.13 186.54,19.13 186.14,18.73 186.14,18.35 186.16,18.33 186.16,18.3 186.27,18.03 186.54,17.92 186.68,17.94 186.79,18.01 186.86,18.04 186.93,18.01 186.98,17.97 186.98,17.89 186.95,17.89 186.13,17.07 186.13,13.9 186.09,13.82 185.99,13.81 185.91,13.83 185.91,17.59 185.65,17.85 185.65,18.42 186.8,19.57 187.36,19.57 187.76,19.96 187.76,20.55 188.38,21.17 188.38,22.5 187.57,23.31 187.57,25.21 187.22,25.55 187.22,26.19 185.41,28 185.41,28.55 185.45,28.58
GND on BOTTOM (solid shape): 81.07,24.84 81.07,24.8 81.33,24.54 81.27,24.49 81.22,24.49 80.94,24.49 80.8,24.45 80.72,24.33 80.71,24.29 80.63,24.29 80.29,23.95 80.29,23.48 80.26,23.47 80.15,23.38 80.1,23.25 80.1,22.95 80.15,22.82 80.26,22.73 80.29,22.72 80.29,22.59 80.25,22.59 80.03,22.45 79.94,22.21 79.95,22.15 79.96,22.09 79.95,22 79.87,21.96 79.51,21.96 79.43,22 79.42,22.09 79.43,22.15 79.44,22.21 79.38,22.41 79.23,22.55 79.23,23.15 80.99,24.91
GND on BOTTOM (solid shape): 110.68,71.47 110.7,71.36 110.61,71.3 110.1,71.3 110.01,71.26 109.97,71.17 109.97,71 109.8,70.83 108.66,70.83 108.58,70.88 108.58,70.98 108.59,71.01 108.59,71.04 108.59,71.21 108.75,71.37 109.02,71.37 109.03,71.32 109.15,71.08 109.41,70.98 109.68,71.09 109.79,71.36 109.77,71.49 109.7,71.61 109.67,71.68 109.7,71.74 109.77,71.86 109.79,72 109.73,72.2 109.57,72.34 109.54,72.36 109.54,72.44 109.71,72.44
GND on BOTTOM (solid shape): 89.79,32.19 89.86,32.19 89.89,32.15 89.92,32.12 89.91,32.09 89.9,32.05 89.9,31.67 89.94,31.58 90.03,31.55 90.41,31.55 90.41,31.41 90.44,31.38 90.42,31.34 90.42,31.32 90.41,31.29 90.41,30.91 90.45,30.82 90.54,30.78 90.91,30.78 90.91,30.27 91.58,29.61 91.58,29.47 91.55,29.42 91.49,29.43 91.35,29.58 90.89,29.58 90.44,30.02 90.45,30.05 90.42,30.3 90.25,30.48 90.25,30.81 90.29,30.85 90.31,30.91 90.31,31.29 90.27,31.38 90.18,31.42 89.8,31.42 89.8,31.5 89.75,31.56 89.75,31.56 89.77,31.59 89.79,31.63 89.8,31.67 89.8,32.05 89.79,32.09 89.77,32.13
GND on BOTTOM (solid shape): 98.03,114.12 98.03,113.19 97.98,113.1 97.89,113.09 97.82,113.11 97.75,113.12 97.53,113.05 97.39,112.86 97.37,112.84 97.33,112.83 97.28,112.84 96.99,112.84 96.9,112.82 96.82,112.76 96.75,112.72 96.67,112.76 96.62,112.8 96.57,112.83 96.53,112.84 96.53,113.15 96.57,113.16 96.67,113.25 96.71,113.37 96.71,113.67 96.67,113.81 96.56,113.89 96.52,113.9 96.52,114.17 96.55,114.18 96.65,114.27 96.69,114.39 96.69,114.69 96.68,114.74 96.7,114.83 96.78,114.87 97.28,114.87
GND on BOTTOM (solid shape): 106.02,46.54 106.06,46.51 106.05,46.46 106,46.41 104.42,46.41 103.86,45.85 103.78,45.82 103.7,45.87 103.57,46.01 103.39,46.06 103.14,45.96 103.03,45.71 103.04,45.65 103.05,45.6 103.06,45.57 102.6,45.12 102.53,45.12 102.53,45.19 102.54,45.2 102.57,45.27 102.58,45.35 102.48,45.58 102.24,45.68 102.07,45.63 101.95,45.5 101.67,45.5 101.66,45.54 101.62,45.66 101.53,45.73 101.48,45.81 101.5,45.9 101.92,46.31 102.08,46.31 102.14,46.37 103.21,46.37 103.39,46.54
GND on BOTTOM (solid shape): 9.32,17.6 9.32,17.22 9.65,16.9 9.67,16.78 9.58,16.72 9.44,16.7 9.33,16.63 9.26,16.6 9.2,16.63 9.08,16.7 8.95,16.72 8.68,16.61 8.56,16.34 8.58,16.24 8.62,16.14 8.62,16.04 8.53,15.99 8.06,15.99 8.06,16.29 7.96,16.4 7.93,16.51 8.03,16.57 8.26,16.57 8.86,17.17 8.86,17.17 9.02,17.31 9.08,17.51 9.06,17.62 9.02,17.71 9.02,17.76 9.07,17.79 9.13,17.79
GND on BOTTOM (solid shape): 73.5,63.13 73.91,63.13 74.2,63.42 74.3,63.44 74.37,63.38 74.49,63.2 74.68,63.11 74.69,63.11 75.2,62.6 75.23,62.53 75.21,62.46 75.14,62.35 75.12,62.22 75.12,62.16 75.14,62.1 75.12,62 75.04,61.96 74.76,61.96 74.6,62.12 74.61,62.18 74.61,62.22 74.5,62.49 74.23,62.6 73.96,62.49 73.85,62.22 73.85,62.17 73.2,62.17 73.11,62.23 73.13,62.35 73.33,62.55 73.33,62.96 72.81,63.48 72.81,63.54 72.92,63.65 72.98,63.65
GND on BOTTOM (solid shape): 81.31,21.58 81.36,21.55 81.35,21.49 79.45,19.6 79.45,18.99 79.5,18.87 79.63,18.81 79.66,18.81 79.76,18.79 79.84,18.74 80.12,18.45 80.18,18.37 80.2,18.27 80.19,18.23 80.12,18.09 79.99,18.02 79.94,18.02 79.85,18.04 79.77,18.09 79.76,18.1 79.56,18.14 79.45,17.97 79.45,17.71 78.35,16.6 78.35,16.54 78.28,16.44 78.17,16.47 77.98,16.66 76.14,16.66 76.05,16.72 76.07,16.83 77.28,18.04 77.28,19.31 79.09,21.12 80.78,21.12 81.24,21.58
GND on BOTTOM (solid shape): 155.24,30.51 155.28,30.5 155.32,30.46 155.32,30.08 155.8,29.6 155.91,29.6 155.92,29.57 156.01,29.49 156.12,29.45 156.4,29.45 156.56,29.52 156.63,29.68 156.63,29.98 156.62,30.06 156.58,30.13 156.55,30.16 156.87,30.49 156.96,30.49 156.98,30.47 157.02,30.42 157.09,30.4 157.36,30.4 157.45,30.35 157.45,30.26 157.42,30.17 157.41,30.09 157.45,29.91 157.57,29.78 157.57,28.78 157.38,28.6 157.07,28.6 156.49,29.17 156.34,29.17 156.33,29.2 156.28,29.24 156.22,29.26 155.56,29.26 155.5,29.24 155.45,29.2 155.44,29.17 155.27,29.17 155.23,29.22 155.17,29.26 155.15,29.27 155.15,30.44 155.18,30.47 155.2,30.5
GND on BOTTOM (solid shape): 156.82,18.46 156.82,18.12 156.69,18.12 156.6,18.09 156.57,18 156.57,16.91 156.58,16.84 156.62,16.8 156.67,16.74 156.66,16.67 156.63,16.58 156.62,16.5 156.67,16.3 156.82,16.16 156.82,16.08 159.76,13.14 159.78,13.03 159.69,12.97 158.66,12.97 156.18,15.45 156.18,16.16 156.33,16.3 156.38,16.5 156.37,16.58 156.34,16.67 156.33,16.74 156.37,16.8 156.42,16.84 156.43,16.91 156.43,18 156.39,18.09 156.3,18.12 156.18,18.12 156.18,18.57 156.01,18.74 155.99,18.85 156.08,18.91 156.38,18.91
GND on BOTTOM (solid shape): 94.48,36.48 94.59,36.5 94.65,36.41 94.65,34.34 94.6,34.29 94.6,34.25 94.59,34.21 94.49,34.16 94.46,34.09 94.46,33.89 94.47,33.86 94.48,33.83 94.5,33.77 94.48,33.71 94.47,33.68 94.46,33.64 94.46,33.44 94.47,33.41 94.47,33.34 94.42,33.29 94.35,33.22 94.29,33.13 94.28,33.1 94.19,33.1 94.19,33.29 94.21,33.32 94.31,33.37 94.33,33.44 94.33,33.64 94.33,33.68 94.31,33.71 94.29,33.77 94.31,33.83 94.33,33.86 94.33,33.89 94.33,34.09 94.31,34.16 94.21,34.21 94.19,34.25 94.19,34.62 94.37,34.8 94.37,36.37
GND on BOTTOM (solid shape): 142.43,63.68 142.82,63.29 144.21,63.29 144.21,63.15 144.25,63.06 144.34,63.02 144.73,63.02 144.73,62.77 144.62,62.65 144.62,62.39 144.62,62.38 144.25,62.38 144.24,62.4 144.15,62.48 144.04,62.51 143.74,62.51 143.63,62.48 143.54,62.39 143.53,62.36 143.3,62.36 143.28,62.39 143.2,62.48 143.08,62.51 142.8,62.51 142.71,62.49 142.63,62.43 142.55,62.4 142.48,62.43 142.4,62.49 142.3,62.51 142.02,62.51 141.92,62.49 141.83,62.41 141.82,62.39 141.76,62.39 141.68,62.47 141.66,62.59 141.75,62.65 141.95,62.65 142.13,62.83 142.13,63.58 142.16,63.66 142.24,63.68
GND on BOTTOM (solid shape): 95.87,99.38 95.92,99.34 95.91,99.29 95.86,99.24 95.69,99.24 95.6,99.2 95.56,99.11 95.56,98.73 95.58,98.67 95.61,98.63 95.61,98.45 95.58,98.4 95.56,98.35 95.56,97.97 95.58,97.91 95.61,97.86 95.61,97.21 95.24,97.21 95.15,97.17 95.11,97.08 95.11,96.51 95.68,95.94 95.68,95.81 95.64,95.77 95.6,95.73 95.39,95.73 94.64,96.48 94.63,96.54 94.68,96.57 94.75,96.57 94.84,96.61 94.88,96.7 94.88,97.08 94.86,97.13 94.83,97.18 94.83,97.86 94.86,97.91 94.88,97.97 94.88,98.35 94.86,98.4 94.83,98.45 94.83,98.51 94.6,98.74 94.6,99.09 94.72,99.19 94.79,99.34 94.8,99.38
GND on BOTTOM (solid shape): 150.85,38.75 150.85,37.66 150.76,37.66 150.74,37.64 149.74,37.64 149.54,37.44 149.5,37.44 149.49,37.43 149,37.43 148.8,37.23 148.8,35.95 148.76,35.91 148.71,35.92 148.68,35.95 148.61,35.95 148.52,36 148.52,36.1 148.54,36.15 148.54,36.2 148.54,36.48 148.53,36.57 148.47,36.65 148.47,36.92 148.35,37.04 148.34,37.09 148.39,37.12 148.42,37.12 148.51,37.16 148.55,37.25 148.55,38.06 148.51,38.16 148.42,38.19 148.39,38.19 148.34,38.22 148.34,38.27 148.38,38.36 148.4,38.47 148.4,38.55 148.53,38.55 148.54,38.52 148.59,38.46 148.66,38.44 149.31,38.44 149.4,38.47 149.44,38.56 149.44,38.69 149.61,38.87 150.73,38.87
GND on BOTTOM (solid shape): 67.65,28.47 67.66,28.41 67.7,28.37 67.74,28.31 67.73,28.24 67.69,28.15 67.68,28.05 67.79,27.78 68.06,27.67 68.19,27.7 68.31,27.77 68.38,27.79 68.44,27.77 68.49,27.73 68.53,27.71 68.56,27.69 68.56,27.61 68.43,27.61 68.34,27.57 68.3,27.48 68.3,27.31 67.31,27.31 67.31,27.36 67.26,27.54 67.13,27.68 67.08,27.75 67.1,27.83 67.15,27.93 67.17,28.05 67.14,28.21 67.05,28.33 67.01,28.42 67.07,28.5 67.15,28.56 67.21,28.65 67.65,28.65
GND on BOTTOM (solid shape): 19.82,44.49 19.82,43.37 19.19,42.73 19.19,40.63 19.24,40.58 19.27,40.49 19.21,40.41 19.05,40.27 18.98,40.07 18.98,40.05 18.96,39.98 18.9,39.95 18.74,39.78 18.32,39.78 18.22,39.88 18.2,39.88 18.12,39.91 18.1,39.99 18.1,40.02 18.09,40.07 18.08,40.11 18.09,40.15 18.11,40.18 18.15,40.2 18.19,40.22 18.33,40.37 18.33,40.52 18.32,40.53 18.32,40.58 18.32,41.31 18.33,41.32 18.33,42.5 18.44,42.61 18.88,42.61 19.09,42.82 19.09,42.92 19.1,42.97 19.1,43.5 19.08,43.57 19.02,43.62 19,43.64 18.64,43.64 18.64,43.64 17.69,43.64 17.68,43.64 17.68,44.74 17.78,44.74 18.97,44.74 19.06,44.78 19.1,44.87 19.1,44.95 19.36,44.95
GND on BOTTOM (solid shape): 93,17.05 93.05,16.92 93.18,16.87 93.23,16.87 93.27,16.9 93.34,16.92 93.41,16.93 93.53,16.9 93.63,16.81 93.65,16.77 93.69,16.74 93.71,16.71 93.7,16.67 93.67,16.59 93.66,16.5 93.68,16.36 93.75,16.25 93.78,16.18 93.75,16.11 93.68,15.99 93.66,15.86 93.66,15.85 93.65,15.82 93.62,15.8 93.58,15.79 93.54,15.77 93.47,15.74 93.41,15.73 93.34,15.74 93.27,15.77 93.23,15.8 93.18,15.8 93.05,15.75 93,15.62 93,15.4 91.72,15.4 91.72,15.5 91.7,15.97 91.64,16.43 91.69,16.49 91.7,16.57 91.7,17.45 93,17.45
GND on BOTTOM (solid shape): 49.25,89.3 49.28,89.28 49.31,89.25 49.34,89.23 49.37,89.22 49.37,89.08 51.13,89.08 51.13,89.22 51.16,89.23 51.19,89.25 51.21,89.28 51.23,89.3 52.01,89.3 52.1,89.25 52.09,89.14 52.03,89.03 52.01,88.92 52.08,88.71 52.26,88.58 52.27,88.58 52.32,88.53 52.23,88.44 51.4,88.44 51.22,88.61 51.2,88.66 51.16,88.68 51.13,88.69 51.13,88.83 49.37,88.83 49.31,88.77 49.22,88.77 49.13,88.8 49.04,88.8 49,88.79 48.96,88.78 48.7,89.04 48.96,89.29 49,89.29 49.04,89.28 49.13,89.27 49.21,89.3
GND on BOTTOM (solid shape): 51.81,37.3 51.9,37.25 51.9,37.15 51.87,37.07 51.86,36.99 51.88,36.87 51.94,36.77 51.95,36.66 51.86,36.61 51.23,36.61 51.21,36.63 51.19,36.66 51.16,36.68 51.13,36.69 51.13,36.83 49.37,36.83 49.37,36.69 49.34,36.68 49.29,36.64 49.27,36.58 49.27,36.55 49.23,36.47 49.15,36.45 49.09,36.46 49.04,36.45 49,36.44 48.96,36.44 48.7,36.69 48.96,36.94 49,36.94 49.04,36.93 49.2,36.94 49.31,37.05 49.32,37.08 51.13,37.08 51.13,37.22 51.16,37.23 51.19,37.25 51.21,37.28 51.23,37.3
GND on BOTTOM (solid shape): 97.98,112.37 98.03,112.29 98.03,111.95 100.1,109.88 100.13,109.77 100.03,109.7 99.49,109.7 98.67,108.88 96.78,108.88 96.66,109 96.69,109.04 96.72,109.11 96.74,109.18 96.74,109.48 96.69,109.62 96.58,109.7 96.55,109.71 96.55,109.97 96.58,109.98 96.69,110.07 96.74,110.2 96.74,110.5 96.69,110.63 96.58,110.71 96.55,110.73 96.55,110.99 96.58,111 96.64,111.03 96.68,111.07 96.76,111.1 96.84,111.07 96.91,111.01 97.01,110.99 97.29,110.99 97.45,111.05 97.52,111.21 97.52,111.52 97.51,111.58 97.48,111.64 97.47,111.66 97.47,112.14 97.61,112.14 97.83,112.36 97.89,112.38
GND on BOTTOM (solid shape): 117.22,121.02 117.28,121.02 117.35,121.02 117.42,121.04 117.59,121.04 117.61,121.02 117.65,120.97 117.72,120.95 118.09,120.95 118.09,120.8 118.05,120.76 118.04,120.7 118.04,120.32 118.06,120.25 118.12,120.2 118.13,120.2 118.18,120.15 118.19,120.1 118.14,120.07 117.72,120.07 117.67,120.06 117.63,120.03 117.6,120.02 117.56,120.03 117.28,120.15 117.01,120.03 116.97,120.02 116.93,120.03 116.89,120.06 116.85,120.07 116.32,120.07 116.27,120.1 116.28,120.15 116.32,120.19 116.4,120.19 116.49,120.23 116.53,120.32 116.53,120.7 116.51,120.76 116.47,120.8 116.47,120.95 116.85,120.95 116.91,120.97 116.96,121.02 116.97,121.04 117.15,121.04
GND on BOTTOM (solid shape): 89.8,79.91 89.84,79.9 89.89,79.88 89.95,79.87 90.44,79.87 90.57,79.79 90.71,79.77 90.86,79.79 90.99,79.87 92.19,79.87 92.21,79.83 92.23,79.8 92.24,79.75 92.19,79.72 90.97,79.72 90.62,79.37 90.3,79.37 90.21,79.33 90.17,79.24 90.17,79.03 90.2,78.95 90.27,78.91 90.31,78.9 90.31,78.8 90.27,78.8 90.2,78.75 90.17,78.67 90.17,78.63 90.12,78.54 90.02,78.54 89.93,78.57 89.84,78.58 89.76,78.57 89.69,78.55 89.59,78.56 89.54,78.64 89.54,78.92 89.54,78.95 89.52,78.98 89.5,79.02 89.58,79.1 89.58,79.63 89.57,79.71 89.63,79.78 89.71,79.82 89.77,79.89
GND on BOTTOM (solid shape): 113.24,17.54 113.24,15.13 113.35,15.03 113.35,14.97 113.46,14.7 113.73,14.59 113.78,14.59 113.94,14.43 113.96,14.32 113.87,14.26 106.31,14.26 106.22,14.35 106.23,14.42 106.23,14.46 106.21,14.61 106.12,14.73 106.1,14.84 106.2,14.91 110.43,14.91 111.05,15.52 111.05,16.51 111.11,16.61 111.22,16.58 111.34,16.5 111.49,16.47 111.76,16.58 111.87,16.85 111.79,17.09 111.57,17.23 111.49,17.3 111.52,17.4 111.79,17.67 112.68,17.67 112.9,17.89
GND on BOTTOM (solid shape): 110.97,48.77 110.99,48.72 110.99,48.69 110.99,48.31 111,48.25 111.04,48.21 111.04,48.17 111.27,47.94 111.52,47.94 111.54,47.92 111.54,47.62 111.12,47.62 111.09,47.61 111.03,47.62 110.98,47.67 110.85,47.8 110.68,47.85 110.48,47.79 110.36,47.62 110.35,47.59 109.74,47.59 109.67,47.62 109.64,47.7 109.64,47.71 109.64,48.02 109.58,48.16 109.44,48.22 109.4,48.22 109.33,48.29 109.31,48.4 109.4,48.46 109.48,48.46 109.52,48.47 109.56,48.49 109.63,48.53 109.7,48.5 109.78,48.42 110.31,48.42 110.58,48.69 110.64,48.68 110.68,48.68 110.8,48.7 110.91,48.77
GND on BOTTOM (solid shape): 72.99,22.63 73.08,22.55 73.19,22.52 73.49,22.52 73.53,22.52 73.59,22.54 74.07,22.07 74.07,21.93 74.04,21.89 74.04,21.86 74.04,20.52 73.62,20.52 73.45,20.35 73.45,20.26 73.44,20.23 73.44,20.21 73.44,20.17 73.45,20.13 73.37,19.95 73.19,19.88 73.1,19.9 73.02,19.95 72.93,20.03 72.94,20.1 72.94,20.13 72.86,20.37 72.61,20.52 72.6,20.56 72.6,21.86 72.56,21.95 72.47,21.98 72.28,21.98 72.2,22.02 72.19,22.11 72.2,22.16 72.2,22.21 72.19,22.27 72.18,22.33 72.19,22.43 72.27,22.47 72.48,22.47 72.59,22.5 72.67,22.58 72.8,22.58 72.85,22.63
GND on BOTTOM (solid shape): 153.39,51.95 153.93,51.41 153.93,50.63 153.88,50.63 153.77,50.6 153.68,50.53 153.59,50.61 153.59,50.63 153.51,50.74 153.37,50.78 153.09,50.78 153,50.76 152.92,50.7 152.84,50.67 152.77,50.7 152.69,50.76 152.59,50.78 152.31,50.78 152.15,50.72 152.09,50.56 152.09,50.52 152.06,50.47 152.01,50.48 151.91,50.53 151.8,50.54 151.77,50.54 151.55,50.76 151.55,50.79 151.88,51.12 151.95,51.14 152.02,51.11 152.1,51.06 152.19,51.04 152.47,51.04 152.63,51.11 152.69,51.27 152.69,51.57 152.69,51.59 152.72,51.67 152.79,51.7 152.94,51.7 153.27,52.04 153.33,52.05 153.39,52.05
GND on BOTTOM (solid shape): outline of 99 points within 28.13,72.55 30.16,75.7
GND on BOTTOM (solid shape): 70.17,59.42 70.17,58.99 70.46,58.7 71.03,58.7 71.32,58.99 71.32,59.42 71.36,59.47 71.52,59.47 71.56,59.42 71.56,58.99 71.85,58.7 72.35,58.7 72.64,58.99 72.64,59.42 72.68,59.47 72.84,59.47 72.88,59.42 72.88,58.74 73.17,58.45 73.56,58.45 73.65,58.4 73.65,58.3 73.61,58.2 73.59,58.1 73.61,57.99 73.66,57.89 73.67,57.78 73.58,57.73 73.24,57.73 72.95,57.44 72.95,57.13 72.91,57.09 72.75,57.09 72.71,57.13 72.71,57.44 72.6,57.55 72.58,57.66 72.68,57.72 72.71,57.72 73.09,58.1 72.71,58.49 72.53,58.44 72.39,58.31 68.71,58.31 68.7,58.32 68.7,58.7 68.71,58.7 69.64,58.7 69.93,58.99 69.93,59.42 69.97,59.47 70.13,59.47
GND on BOTTOM (solid shape): 29.02,91.73 29.02,79.94 30.16,78.8 30.16,75.75 30.12,75.67 30.03,75.66 29.98,75.67 29.93,75.67 29.86,75.7 29.83,75.77 29.75,75.98 29.57,76.12 29.5,76.19 29.53,76.28 29.65,76.41 29.65,77.51 29.55,77.7 29.34,77.72 29.29,77.71 29.25,77.7 28.99,77.96 29.25,78.21 29.29,78.2 29.34,78.19 29.55,78.22 29.65,78.4 29.65,78.91 29.45,79.11 27.44,79.11 27.15,78.81 27.15,77.12 27.07,77.04 27.02,77.03 26.99,77.08 26.99,78.95 28.89,80.85 28.89,91.83 28.98,91.83
GND on BOTTOM (solid shape): 104.51,35.94 104.55,36.02 104.65,36.03 104.72,36.01 104.79,36 104.82,36 104.88,36.01 104.96,35.93 104.96,35.61 104.97,35.55 105.01,35.51 105.01,35.33 104.97,35.29 104.96,35.23 104.96,34.85 105,34.76 105.09,34.72 105.29,34.72 105.38,34.75 105.42,34.84 105.42,34.86 105.45,34.89 105.5,34.9 105.53,34.85 105.53,34.84 105.54,34.8 105.56,34.76 105.59,34.72 105.42,34.55 105.42,34.35 105.22,34.35 104.97,34.1 104.72,34.1 104.63,34.06 104.6,33.97 104.6,33.85 104.55,33.77 104.46,33.75 104.41,33.76 104.36,33.77 104.25,33.75 104.15,33.7 104.11,33.68 103.87,33.91 103.85,34.02 103.95,34.09 104.02,34.09 104.11,34.12 104.15,34.21 104.15,34.22 104.51,34.58
GND on BOTTOM (solid shape): 79.52,41.73 79.52,41.38 79.32,41.18 79.24,41.19 79.2,41.2 78.94,41.09 78.84,40.84 78.87,40.69 78.97,40.56 79.01,40.48 78.97,40.4 78.86,40.28 78.83,40.12 79.18,39.76 79.54,40.12 79.53,40.21 79.5,40.29 79.48,40.32 80.08,40.93 80.17,40.96 80.24,40.91 80.33,40.81 80.44,40.75 80.51,40.67 80.48,40.58 79.31,39.41 76.65,39.41 76.57,39.45 76.56,39.54 76.57,39.61 76.58,39.67 76.57,39.73 76.56,39.79 76.57,39.88 76.65,39.93 77.32,39.93 79.13,41.74 79.44,41.74 79.46,41.75
GND on BOTTOM (solid shape): outline of 100 points within 121.05,118.4 124.19,120.86
GND on BOTTOM (solid shape): 98.08,54.04 98.18,54.01 98.21,53.99 98.21,53.97 98.28,53.81 98.43,53.72 98.5,53.64 98.47,53.55 98.36,53.44 98.36,53.27 98.25,53.16 98.21,53.01 98.21,52.98 98.21,52.94 98.18,52.85 98.08,52.82 98.03,52.84 97.98,52.84 97.86,52.82 97.76,52.75 97.69,52.73 97.62,52.75 97.52,52.82 97.4,52.84 97.36,52.84 97.33,52.83 97.24,52.86 97.21,52.95 97.21,53.09 97.32,53.21 97.34,53.21 97.51,53.33 97.57,53.53 97.57,53.59 97.59,53.67 97.68,53.71 97.71,53.7 97.91,53.78 98.01,53.96
GND on BOTTOM (solid shape): 71.57,22.71 71.64,22.62 71.64,22.55 71.49,22.41 71.44,22.21 71.44,22.16 71.45,22.11 71.43,22.02 71.35,21.98 71.17,21.98 71.08,21.95 71.04,21.86 71.04,20.56 71.04,20.53 71.06,20.5 71.06,20.46 71.04,20.43 70.94,20.3 70.9,20.13 70.9,20.09 70.91,19.99 70.83,19.99 70.77,19.98 70.63,19.9 70.54,19.88 70.36,19.95 70.28,20.13 70.29,20.19 70.31,20.24 70.33,20.29 70.32,20.31 70.34,20.4 70.42,20.43 70.47,20.43 70.56,20.47 70.6,20.56 70.6,21.86 70.59,21.9 70.57,21.94 70.54,22.01 70.57,22.08 71.07,22.58 71.14,22.57 71.18,22.56 71.34,22.6 71.46,22.69
GND on BOTTOM (solid shape): 102.81,41.64 106.99,41.64 107,41.63 107,41.37 107.04,41.23 107.16,41.15 107.2,41.14 107.2,40.88 107.16,40.86 107.05,40.78 107.01,40.65 107.01,40.35 107.08,40.19 107.24,40.12 107.52,40.12 107.65,40.17 107.74,40.28 107.75,40.32 107.83,40.32 107.89,40.38 107.94,40.39 107.97,40.34 107.97,40.15 108.01,40.06 108.1,40.02 108.98,40.02 109.06,39.99 109.08,39.91 109.08,39.88 109.08,38.49 109.08,38.45 109.1,38.42 109.1,38.32 109.01,38.26 107.58,38.26 107.25,38.6 107.25,38.61 107.17,38.76 107.02,38.83 106.72,38.83 106.66,38.82 106.6,38.79 106.56,38.77 106.34,39 106.27,39 106.23,39.03 106.17,39.05 106.02,39.05 104.35,40.72 103,40.72 102.42,41.3 101.72,41.3 101.43,41.59 101.41,41.7 101.5,41.76 102.68,41.76
GND on BOTTOM (solid shape): outline of 107 points within 138.17,37.12 144.7,43.21
GND on BOTTOM (solid shape): 59.89,98.27 59.88,98.2 59.88,98.16 59.99,97.89 60.26,97.78 60.3,97.78 60.37,97.79 60.77,97.39 60.8,97.28 60.7,97.22 59.56,97.22 59.47,97.26 59.47,97.36 59.49,97.44 59.5,97.52 59.48,97.66 59.41,97.77 59.38,97.84 59.41,97.91 59.48,98.02 59.5,98.16 59.12,98.54 58.74,98.16 58.76,98.02 58.83,97.91 58.86,97.84 58.83,97.77 58.77,97.66 58.74,97.54 58.67,97.45 58.57,97.47 58.26,97.78 58.01,97.78 57.92,97.84 57.94,97.95 58.23,98.24 58.23,98.67 58.3,98.74 59.42,98.74
GND on BOTTOM (solid shape): 108.68,46.24 108.7,46.2 108.73,46.16 108.73,46.14 108.96,45.91 109.33,45.91 109.79,45.45 109.8,45.43 109.87,45.29 110.02,45.24 110.3,45.24 110.42,45.27 110.51,45.37 110.55,45.4 110.6,45.37 110.62,45.32 110.62,44.93 110.6,44.89 110.55,44.86 110.51,44.89 110.42,44.98 110.3,45.02 110.02,45.02 109.92,44.99 109.84,44.93 109.77,44.89 109.69,44.92 109.62,44.99 109.53,44.99 109.52,45.02 109.44,45.13 109.31,45.18 109,45.18 108.87,45.13 108.79,45.02 108.78,44.99 107.03,44.99 106.93,45.05 106.96,45.16 107.31,45.51 107.31,45.71 107.72,46.12 107.78,46.15 107.85,46.13 107.92,46.1 107.99,46.08 108.29,46.08 108.42,46.13 108.51,46.24 108.52,46.28 108.67,46.28
GND on BOTTOM (solid shape): 109.97,70.07 109.97,69.9 109.98,69.85 110.01,69.81 110.02,69.77 110,69.75 109.89,69.43 110.04,69.13 110.08,69.04 110.04,68.97 110.01,68.93 110,68.88 110,68.74 109.85,68.59 109.33,68.59 109.23,68.66 109.26,68.77 109.41,69.04 109.32,69.32 109.29,69.39 109.32,69.46 109.22,70.04 108.67,69.83 108.65,69.8 108.57,69.8 108.57,70.03 108.54,70.1 108.47,70.13 107.81,70.13 107.74,70.1 107.71,70.03 107.71,69.66 106.06,69.66 102.3,65.9 101.8,65.9 101.72,65.91 101.69,65.94 101.43,66 101.29,66 101.27,66.01 101.26,66.02 101.26,66.25 101.41,66.25 101.49,66.27 101.57,66.31 102.12,66.31 102.22,66.41 102.55,66.41 106.4,70.25 109.78,70.25
