# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V3A_BOOT: length 4.3
  BOTTOM w0.356: 147.23,33.77 147.54,34.08 147.54,36.4 v2(147.32,36.62) 146.81,37.13 PR239.2
V3A_BOOT_R: length 1.4
  BOTTOM w0.356: PC229.1 148.17,36.79 148.01,36.95 PR239.1
V3A_EN: length 4.9
  TOP w0.102: PR77.1 145.61,33.89 v2(145.73,33.77)
  TOP w0.203: PR77.1 144.98,33.54 144.75,33.31 144.04,33.31 PR83.2 143.76,34.11 v2(143.65,34.22) 143.93,34.49 PC79.2
  BOTTOM w0.229: v2(143.65,34.22) 143.67,34.19 143.67,33.83 143.79,33.71 PU11.6
V3A_PWRGD: length 1.4
  BOTTOM w0.203: PR244.1 143.6,35.3 143.73,35.3 144.16,34.86 144.17,34.86
  BOTTOM w0.229: PU11.7 144.17,34.86
V3A_VBYP: length 5.8
  TOP w0.305: v2(146.29,35.08) 145.93,34.73 PR70.2
  TOP w0.483: PR68.2 148.72,35.61 v2(147.83,34.72) 147.53,34.43 146.7,34.43 146.34,34.79 146.34,35.03 v2(146.29,35.08)
  BOTTOM w0.229: v2(146.29,35.08) 146.25,35.05 146.25,34.99 145.97,34.71 PU11.11
  BOTTOM w0.356: v2(146.29,35.08) 146.29,35.13 146.31,35.15 PC227.1
V3A_VOUT: length 9.4
  TOP w0.305: PR78.2 144.92,36.77 v2(145.25,37.1) 145.6,37.45 PR72.2
  BOTTOM w0.152: PR236.1 148.49,38.75 148.32,38.92 147.46,38.92 v2(147.25,38.72) 146.21,38.72 145.25,37.76 v2(145.25,37.1)
  BOTTOM w0.229: PU11.10 145.52,34.95 145.73,35.16 145.73,35.98 145.25,36.46 PC71.2 145.25,37.1 v2(145.25,37.1)
V5P5A_BOOT: length 2.5
  BOTTOM w0.279: PR115.2 42.54,16.18 42.4,16.32 42.4,17.95
V5P5A_BOOT_R: length 1.4
  BOTTOM w0.381: PC116.1 41.88,16.4 41.34,15.86 PR115.1
V5P5A_EN: length 5.2
  TOP w0.203: PR276.1 v2(46.92,18.05) 46.45,18.05 46.21,17.81 v2(45.71,17.81) 45.22,17.81 44.41,17.01 PR279.2
  BOTTOM w0.229: PC271.2 46.18,17.35 v2(45.71,17.81) 45.5,18.02 PU15.6
V5P5A_PWRGD: length 4.6
  BOTTOM w0.152: PU15.7 45.42,17.46 46.59,16.29 46.77,16.29 46.89,16.18 46.89,14.63 47.2,14.32 PR273.1
V5P5A_VOUT: length 10.3
  BOTTOM w0.152: PR277.2 v2(42.48,14.21) 43.85,14.21 PR274.2
  BOTTOM w0.203: PU15.10 43.78,16.91 44.22,16.47 44.22,14.4 PR274.2
  BOTTOM w0.229: PR274.2 43.94,13.76 44.13,13.58 45.93,13.58 46.44,14.08 PR278.2 46.43,14.13 PC267.2
VBUS_EN: length 11.5
  TOP w0.102: R6528.1 R6510.2 23.18,23.86 v2(23.05,23.99) ; v2(22.9,15.53) 22.72,15.36 U2034.15
  IN1 w0.089: v2(22.9,15.53) 22.9,18.63 23.5,19.23 23.5,22.52 23.05,22.97 v2(23.05,23.99)
VBUS_EN_EC_R: length 9
  TOP w0.102: Q2039.3 24.83,23.35 25.05,23.58 R6528.2 25.05,24.14 24.57,24.62 v2(24.32,24.62) v2(23.05,24.62)
  BOTTOM w0.102: U2035.4 18.82,25.07 18.88,25.13 22.29,25.13 22.79,24.62 v2(23.05,24.62)
VDD08_PG: length 19.3
  TOP w0.203: PR9104.2 PR9103.2 84.32,115.53 84.24,115.61 v2(83.63,115.61) v1(82.92,115.61)
  IN1 w0.089: v1(76.13,120.71) 76.13,120.89 76.77,121.53 78.8,121.53 80.2,120.13 83.75,120.13 84.39,119.49 84.39,117.08 v1(82.92,115.61)
  BOTTOM w0.102: PR77865.1 75.47,123.06 75.75,122.77 75.75,121.5 76.13,121.12 v1(76.13,120.71)
VDDBT_RTC: length 12.9
  IN3 w0.508: v1(95.95,34.28) 95.95,35.04 95.59,35.39 95.59,39 95.86,39.27 95.86,40.84 95.41,41.29 95.41,45.39 95.79,45.77 v1(96.05,45.77)
  BOTTOM w0.508: v1(96.05,45.77) 95.67,45.77 U2030.AT11
  vias: v1(101.56,27.6) v2(101.03,30.34)
VDDCI_CORE_SENSE: length 35.6
  TOP w0.203: PR77849.1 92.34,124.75 v2(92.39,124.7)
  IN2 w0.254: v2(103.16,99.83) 102.7,99.37 97.25,99.37 95.39,101.23 95.39,105.35 94.22,106.51 94.22,110.98 92.52,112.69 92.52,122.41 91.96,122.97 91.96,124.27 v2(92.39,124.7)
  BOTTOM w0.102: v2(92.39,124.7) v2(92.39,125.34)
  BOTTOM w0.254: v2(103.16,99.83) 103.16,99.73 102.8,99.37 U2029.AV13
VDDP: length 26.9
  TOP w0.381: R2509.2 106.36,58.91 109.79,55.49 112.08,55.49 v2(114.49,53.07)
  TOP w0.508: PR9286.1 129.97,37.48 v3(129.21,36.71)
  IN3 w0.381: v2(114.49,53.07) 114.74,52.82 114.74,49.23 116.56,47.41 116.56,42.88 v2(116.01,42.33)
  BOTTOM w0.203: PR9295.2 v3(128.46,36.71)
  vias: v2(115.38,40.75) v2(116.01,41.7) v2(116.01,41.06) v2(116.01,40.43) v3(126.14,36.71) v3(126.9,36.71) v3(127.69,36.71)
VDDP_S5:
  vias: v2(110.04,34.28) v2(111.42,34.65) v2(111.42,34.01) v2(123.74,40.37) v2(124.38,40.37)
VDDQ_PG: length 2.4
  TOP w0.203: PU1.8 67.6,121.24 v2(67.63,121.27)
  BOTTOM w0.203: PR128.1 66.96,121.93 v2(67.63,121.27)
VDDQ_PVIN:
  vias: v2(70.04,120.51)
VDDQ_SLP_S4: length 3.8
  TOP w0.229: v2(66.43,123.45) 66.4,123.42 66.4,123.41 66.29,123.3 66.29,123.24 66.27,123.22 PU1.11
  BOTTOM w0.203: PR126.2 PR124.1 66.8,124.57 66.67,124.71 PC125.2 66.27,124.24 66.43,124.08 v2(66.43,123.45)
VDDQ_SW: length 1.1
  BOTTOM w0.508: v2(60.15,121.76) 60.15,122.25 PR129.1
  vias: v2(60.51,121.14)
VDDQ_VCC:
  vias: v2(67.88,124.45)
VDDQ_VDDQSNS: length 2.7
  TOP w0.203: PU1.5 66.27,119.48 66.74,119.01 PR9300.2 66.74,118.86 67.12,118.86 67.4,118.58 PR9301.1
VDDQ_VLDOIN: length 1.8
  BOTTOM w0.457: v2(63.59,119.47) 63.59,120.31 64.25,120.97 PC16.1
VDDQ_VTT: length 8.9
  TOP w0.203: PR8.1 66.02,118.14 65.82,117.94 64.61,117.94 64.41,118.14 PC18.1 64.36,118.47 v2(64.36,119.13) 64.41,119.13 64.76,119.48 PU1.2
  BOTTOM w0.102: v2(61.66,118.86) 61.85,119.05 PR130.1
  BOTTOM w0.381: PR130.1 62.75,118.48 63.01,118.22 64,118.22 64.36,118.58 v2(64.36,119.13)
  BOTTOM w0.457: v2(64.36,119.13) 64.25,119.23 PC142.1
VDDQ_VTT_CNTL: length 4.3
  TOP w0.229: v2(67.06,123.45) 67.03,123.42 67.03,123.22 66.76,122.95 PU1.10
  BOTTOM w0.203: PR125.1 69.28,124.95 69.04,124.72 PC126.2 68.65,124.72 68.14,124.21 67.51,124.21 67.06,123.75 v2(67.06,123.45)
VDDQ_VTTREF: length 1
  TOP w0.381: PC15.2 68.12,118.73 PR9.1
VDDQ_VTTSNS: length 1.1
  TOP w0.152: PR8.2 66.02,119.06 65.76,119.32 PU1.4
VSS_GPU_SENSE: length 24.4
  IN2 w0.254: v1(103.16,98.79) 97.81,98.79 95.87,96.85 95.02,96.85 93.5,95.33 91.85,95.33 91.03,94.51 85.45,94.51 83.34,92.4 83.34,92.39 v2(83.08,92.13)
  BOTTOM w0.152: PR9059.1 83.43,91.77 v2(83.08,92.13)
  BOTTOM w0.254: U2029.AU13 103.6,99.23 v1(103.16,98.79)
2ND_MBCLK: length 202
  TOP w0.102: U13.115 172.42,30.58 172.15,30.85 R315.1 172.36,31.36 172.53,31.52 172.53,32.85 v2(172.65,32.98)
  IN1 w0.089: v2(107.22,125.46) 107.22,123.6 105.73,122.1 105.73,120.51 106.11,120.13 106.11,119.59 105.85,119.34 105.12,119.34 104.82,119.64 103.66,119.64 103.34,119.33 100.3,119.33 98.2,117.23 98.2,115.43 96.37,113.61 96.37,111.46 97.26,110.57 97.26,96.55 99.38,94.44 99.38,92.33 102.8,88.9 v2(102.8,86.85)
  IN2 w0.089: v2(113.85,74.93) 112.72,76.06 108.09,76.06 v2(107.71,75.68)
  IN3 w0.089: v2(102.8,86.85) 102.8,88.12 102.93,88.25 103.31,88.25 103.44,88.12 103.44,87.11 103.69,86.85 107.12,86.85 111,82.97 111,81.7 112.75,79.94 112.75,76.03 v2(113.85,74.93) 115.04,74.93 118.86,71.11 119.73,71.11 122.75,68.09 122.75,59.13 121.71,58.1 121.71,54.14 122.75,53.11 122.75,52.26 126.49,48.52 142.43,48.52 142.62,48.71 144.05,48.71 145.65,47.1 146.75,47.1 147.51,46.34 147.51,44.85 148.39,43.97 148.39,43.51 149.19,42.7 149.19,41.67 151.51,39.35 151.51,38.06 152.38,37.19 156.98,35.28 159.95,35.28 160.35,34.88 168.1,34.88 169.47,33.51 170.23,33.51 170.76,32.98 v2(172.65,32.98) 172.99,32.64 172.99,32.17 174.56,30.6 180.03,30.6 180.61,30.02 183.38,30.02 183.75,30.4 185.81,30.4 187.41,28.8 192.26,28.8 193.25,29.78 193.92,29.78 194.9,28.8 196,28.8 196.53,29.32 196.53,29.98 196.89,30.34 v2(196.91,30.34)
  BOTTOM w0.102: v2(107.22,125.46) 107.35,125.59 R8128.1 107.79,124.86 107.57,124.64 Q2038.6 ; R746.2 v2(196.91,30.34) ; Q2031.3 108.02,75.54 107.88,75.68 v2(107.71,75.68)
2ND_MBDATA: length 210.7
  TOP w0.102: v2(100.14,117.97) 100.52,117.59 101.28,117.59 101.66,117.97 102.42,117.97 102.65,117.74 104.26,117.74 105.12,118.61 105.99,118.61 106.77,119.39 107.35,119.39 107.76,118.99 107.76,118.22 109.05,116.93 109.44,116.93 109.84,117.33 109.84,119.11 110.97,120.23 111.73,120.23 113.14,121.65 113.14,122.06 112.12,123.07 v2(111.81,123.07) ; v2(171.27,32.5) R314.1 171.79,32.02 171.78,32 171.78,30.83 172.02,30.6 U13.116
  IN1 w0.089: v2(103.11,89.52) 102.45,89.52 99.63,92.34 99.63,94.46 97.45,96.63 97.45,110.65 96.56,111.54 96.56,113.53 98.4,115.36 98.4,116.23 v2(100.14,117.97)
  IN3 w0.089: v2(103.11,89.52) 102.4,88.82 102.4,86.62 102.57,86.45 107.25,86.45 110.81,82.89 110.81,79.94 111.8,78.94 111.8,76.34 112.71,75.44 112.71,75.44 v2(113.85,74.29) 113.97,74.41 115.29,74.41 118.79,70.92 119.65,70.92 119.8,70.77 119.8,70.64 119.22,70.06 119.22,69.43 119.35,69.3 119.57,69.3 119.7,69.43 119.7,69.87 120.14,70.31 120.26,70.31 122.56,68.01 122.56,59.21 121.52,58.17 121.52,54.06 122.56,53.03 122.56,52.18 126.41,48.33 142.51,48.33 142.7,48.52 143.97,48.52 145.57,46.91 146.67,46.91 147.32,46.27 147.32,44.77 148.2,43.89 148.2,43.43 149,42.62 149,41.59 151.29,39.3 151.29,38 152.95,36.34 152.95,35.07 153.66,34.36 156.84,34.36 156.93,34.45 156.93,34.95 157.07,35.09 159.87,35.09 160.27,34.69 168.02,34.69 169.39,33.32 170.15,33.32 170.97,32.5 v2(171.27,32.5) 172.37,31.4 173.5,31.4 174.48,30.41 179.95,30.41 180.53,29.83 183.46,29.83 183.83,30.21 185.73,30.21 187.33,28.61 192.36,28.61 193.33,29.58 193.81,29.58 194.78,28.61 196.08,28.61 196.55,29.07 v2(196.96,29.07)
  BOTTOM w0.102: v2(111.81,123.07) 109.89,123.07 109.63,123.34 Q2038.3 108.43,123.34 108.27,123.18 108.27,122.92 108.39,122.8 108.52,122.8 108.75,122.57 R8118.1 ; v2(113.85,74.29) 113.33,73.77 112.46,73.77 112.15,73.47 111.49,73.47 111.31,73.65 111.31,73.9 110.97,74.24 Q2031.6 ; v2(196.96,29.07) 196.96,29.2 197.34,29.58 R754.2
32K_X1: length 8.5
  BOTTOM w0.102: U2030.AY1 102.1,42.22 107.31,42.22 R2408.1 107.39,42.29 C2577.1 107.76,43.42 108.03,43.15 Y2003.1
32K_X2: length 9.8
  BOTTOM w0.102: Y2003.2 107.91,40.65 107.76,40.5 107.38,40.5 R2408.2 107.07,41.82 102.88,41.82 102.76,41.94 101.18,41.94 U2030.AY4
48M_X1: length 11.3
  BOTTOM w0.102: Y2002.1 109.8,38.35 109.54,38.09 107.5,38.09 107.13,38.46 C2575.2 106.62,38.46 106.26,38.82 R2404.2 105.98,38.84 104.27,40.55 102.92,40.55 102.35,41.12 101.65,41.12 101.16,41.61 U2030.BB3
48M_X2: length 10.2
  BOTTOM w0.102: Y2002.3 107.59,36.99 107.11,37.46 C2576.2 106.87,37.71 106.57,38.01 106.34,38.01 R2404.1 105.82,38.37 104.05,40.14 102.78,40.14 102.17,40.75 101.61,40.75 101.16,41.2 100.72,41.2 U2030.BA5
80PORT_CLK: length 127.4
  TOP w0.102: v2(161.35,16.5) 161.86,15.99 164.53,15.99 164.7,16.16 U13.31 ; v2(47.18,13.4) 47.61,13.83 47.8,13.83 49.7,15.73 v2(50.48,15.73) 50.86,15.73 v2(54.54,19.42)
  IN1 w0.089: v2(100.52,18.27) 100.52,18.64 98.47,20.69 91.55,20.69 91.1,20.24 76.45,20.24 75.04,18.83 55.14,18.83 v2(54.54,19.42)
  IN3 w0.089: v2(161.35,16.5) 160.57,15.71 147.69,15.71 145.72,17.68 101.11,17.68 v2(100.52,18.27)
  BOTTOM w0.102: v2(47.18,13.4) 47.18,12.94 45.95,11.71 CN17.3
80PORT_DAT: length 179.5
  TOP w0.102: v2(46.54,13.4) 47.23,14.08 47.73,14.08 49.89,16.24 51.05,16.24 53.91,19.11 v2(53.91,19.42) ; v2(180.1,22.87) 180.12,22.9 180.17,22.9 180.23,22.96 U13.83
  IN1 w0.089: v2(99.88,18.27) 99.88,18.78 98.93,19.73 76.21,19.73 75.12,18.64 54.69,18.64 v2(53.91,19.42)
  IN2 w0.089: v2(192.47,20.71) 190.54,20.71 188.37,22.88 187.3,22.88 187.12,22.71 180.26,22.71 v2(180.1,22.87)
  IN3 w0.089: v2(99.88,18.27) 100.71,17.45 145.68,17.45 147.68,15.45 168.38,15.45 168.61,15.22 171.93,15.22 173.3,16.59 175.83,16.59 176.44,15.98 190.85,15.98 191.5,15.33 193.46,15.33 193.91,14.87 v2(193.91,14.31)
  BOTTOM w0.102: CN17.4 45.45,11.69 46.54,12.79 v2(46.54,13.4) ; v2(192.47,20.71) 192.72,20.71 193.23,20.2 193.23,17.41 193.69,16.95 193.69,16.37 194.22,15.84 194.22,14.67 193.91,14.36 v2(193.91,14.31)
3622AC_PVCC: length 7.6
  TOP w0.203: PU6000.34 142.55,54.3 142.46,54.39 PC6002.2 141.46,54.38 140.92,53.84 139.93,53.84 139.6,53.51 139.6,50.71 PR6002.1
3622AM_PVCC_GPU: length 3.1
  BOTTOM w0.203: PC9002.2 77.59,112.37 77.57,112.37 77.47,112.28 PU9000.34
  BOTTOM w0.381: PR9002.1 77.74,112.7 PC9002.2
3662AC_BOOT1: length 4
  TOP w0.203: PR6033.1 140.7,51.81 141.08,52.19 141.79,52.19 141.83,52.23 v2(142.56,52.23) 142.87,52.23 143.35,52.7 PU6000.38
3662AC_BOOT2: length 4.1
  TOP w0.102: v2(142.94,48.63) 142.85,48.71 PR6043.1
  TOP w0.203: PR6043.1 143.37,50.28 144.45,50.28 144.88,50.71 144.89,50.71 144.95,50.77 PU6000.2
3662AC_CPU_HG1: length 1.4
  BOTTOM w0.61: PR6031.2 138.91,60.91 138.45,61.37 PQ6001.1
3662AC_CPU_HG2: length 3.5
  BOTTOM w0.102: PR6042.2 143.83,53.83 v2(143.95,53.83)
  BOTTOM w0.406: PR6042.2 142.83,52.95 142.48,53.29 141.88,53.29 141.37,53.8 PQ6002.1
3662AC_CPU_LG1: length 12.6
  TOP w0.203: PU6000.35 142.89,53.9 v2(142.79,53.81)
  IN2 w0.508: v2(135.39,62.1) 135.39,61.76 140.4,56.75 140.4,56.29 142.2,54.49 142.49,54.49 142.79,54.19 v2(142.79,53.81)
  vias: v2(133.67,62.47)
3662AC_CPU_LG2: length 10.6
  TOP w0.203: v2(142.11,51.74) 142.86,51.74 143.42,52.3 PU6000.39
  IN2 w0.508: v2(142.11,51.74) 141.49,52.36 141.49,52.66 138.83,55.32 138.33,55.32 137.71,54.7 v2(135.42,54.7)
3662AC_CPU_LX1: length 59.5
  TOP w0.203: v2(142.16,53.88) 142.16,53.74 142.57,53.33 142.99,53.33 143.17,53.5 PU6000.36
  TOP w0.305: PC6009.1 141.72,53.44 v2(142.16,53.88)
  IN2 w0.152: v1(149.97,46.54) 149.97,46.8 148.95,47.82 145.29,47.82 144.1,49.02 141.3,49.02 140.27,47.99 136.33,47.99 135.76,48.56 134.26,48.56 132.36,50.46 126.99,50.46 125.98,51.47 125.98,54.64 128.35,57.01 129.36,57.01 v2(129.82,56.54)
  IN2 w0.508: v2(131.88,57.8) 132.64,57.05 138.21,57.05 141.37,53.88 v2(142.16,53.88)
  BOTTOM w0.178: v1(149.97,46.54) 150.16,46.36 150.53,46.36 151.29,46.36 151.68,46.75 151.8,47.03 PR6068.1
  BOTTOM w0.203: v2(129.82,56.54) 128.24,58.12 128.24,59.37 128.88,60.01 PL6001.1
3662AC_CPU_LX2: length 39.7
  TOP w0.203: PU6000.40 143.56,51.9 142.95,51.29 142.3,51.29 v2(142.1,51.09)
  TOP w0.229: v2(142.1,51.09) 142.05,51.09 PC6013.1
  IN1 w0.508: v2(135.12,50.63) 135.12,50.22 136.84,48.5 138.49,48.5 139.25,49.26 139.25,49.77 140.57,51.09 v2(142.1,51.09)
  IN2 w0.152: v2(148.96,45.65) 149.18,45.87 149.18,46.08 148.32,46.95 147.64,46.95 144.96,46.95 143.73,48.18 141.72,48.18 140.65,47.1 135.95,47.1 135.4,47.66 133.58,47.66 132.01,49.23 v2(132.01,49.91)
  BOTTOM w0.178: PR6071.1 148.66,45.03 148.96,45.33 v2(148.96,45.65)
  BOTTOM w0.203: v2(132.01,49.91) 131.1,50.83 131.1,52.19 131.74,52.83 PL6002.1
3662AC_CPUISEN1N: length 11.2
  TOP w0.203: PC6011.1 149.2,49.12 149.28,49.04 v2(149.28,48.6)
  BOTTOM w0.178: 150.22,50.25 150.22,49.8 150.24,49.78 150.24,49.77 150.64,49.38 151.96,49.38 152.09,49.25 152.09,48.49 152.21,48.37 152.21,47.22 151.94,46.58 151.25,45.88 v2(151.09,45.88) 150.76,45.88 150.6,46.04 PR6069.2 149.84,46.04 149.66,46.22 PR6050.2 ; 150.22,50.25 149.83,49.86 149.82,49.86 149.73,49.77 149.59,49.77 149.13,49.31 PR6038.1 149.13,48.75 v2(149.28,48.6) ; 150.22,50.25 PR6040.2
3662AC_CPUISEN1P: length 1
  BOTTOM w0.203: PR6036.2 151.63,48.69 151.35,48.4 PR6068.2
3662AC_CPUISEN2N: length 6.2
  TOP w0.102: v2(148.36,48.59) 148.36,48.03 v2(148.52,47.87)
  TOP w0.203: v2(148.36,48.59) 148.36,48.72 148.24,48.84 PC6014.1
  BOTTOM w0.178: PR6072.2 150.23,47.2 149.98,47.46 149.98,47.69 PR6035.2 149.72,47.94 149.26,47.48 148.47,47.48 PR6047.1 148.21,48.16 148.21,48.42 148.36,48.57 v2(148.36,48.59) 148.19,48.76 PR6046.1
3662AC_CPUISEN2P: length 0.8
  BOTTOM w0.178: PR6045.2 148.45,45.88 148.39,45.83 PR6071.2
3662AC_EN: length 3
  TOP w0.203: v1(144.61,57.02) 144.61,56.99 144.95,56.64 PU6000.29
  TOP w0.254: PR6028.2 144.47,57.16 v1(144.61,57.02)
  BOTTOM w0.203: PC6000.1 144.78,56.85 v1(144.61,57.02)
3662AC_HG1: length 10.4
  TOP w0.203: v2(142.13,52.71) 142.89,52.71 143.28,53.1 PU6000.37
  IN3 w0.508: v2(142.13,52.71) 140.01,54.84 v1(140.01,60.31)
3662AC_HG2: length 2.3
  TOP w0.102: v2(143.51,50.95) 143.05,50.95 v2(142.89,50.79)
  TOP w0.203: PU6000.1 144.55,50.88 144.33,50.66 143.8,50.66 v2(143.51,50.95)
3662AC_IMON_CPU: length 3.2
  TOP w0.203: PU6000.14 149.65,53.1 v2(149.89,52.86)
  BOTTOM w0.178: PR6054.2 150.34,51.94 PC6017.1 149.64,52.61 v2(149.89,52.86)
3662AC_IMON_NB: length 2.9
  TOP w0.203: PU6000.16 149.53,53.9 149.81,54.18 v2(149.99,54.18)
  BOTTOM w0.203: PR6066.2 150.19,54.18 v2(149.99,54.18) 149.7,54.18 PC6020.1
3662AC_ISEN1N_CPU: length 5.6
  TOP w0.203: PU6000.10 148.15,50.53 148.34,50.35 v2(148.34,50.19)
  BOTTOM w0.152: v2(148.34,50.19) 148.66,49.87 148.66,49.01 148.82,48.85 148.82,48.44 148.78,48.4 PR6047.2
  BOTTOM w0.178: 148.78,50.85 148.86,50.85 PR6040.1
  BOTTOM w0.203: v2(148.34,50.19) 148.78,50.63 PC6012.2
3662AC_ISEN1P_CPU: length 8.1
  TOP w0.102: v2(149.91,48.61) v2(149.91,47.98)
  TOP w0.203: v2(149.91,48.61) 149.91,48.76 149.69,48.98 149.69,49.51 149.2,50 PC6011.2 148.9,49.71 148.04,49.71 147.86,49.89 147.86,50.32 147.75,50.42 PU6000.9
  BOTTOM w0.178: v2(149.91,48.61) 149.91,49.3 ; 149.91,49.3 150.3,48.91 PR6036.1 ; 149.91,49.3 PR6038.2
  BOTTOM w0.203: PR6035.1 150.5,48.56 PR6036.1
3662AC_ISEN2P_CPU: length 7.7
  TOP w0.102: v2(147.73,48.58) 147.72,48.58 v2(147.25,48.12)
  TOP w0.203: PU6000.7 146.95,50.38 146.89,50.32 146.89,49.92 147.06,49.75 147.06,49.64 147.46,49.24 PC6014.2 147.46,48.84 v2(147.73,48.58)
  BOTTOM w0.178: PR6046.2 147.41,48.9 v2(147.73,48.58) 147.73,48.55 147.54,48.37 147.54,47.61 147.67,47.48 147.96,47.48 PR6045.1 PR6050.1
3662AC_ISENP_NB: length 4.3
  TOP w0.178: PR6023.1 PC6005.1 147.03,57.84 146.9,57.84 146.63,57.57 146.63,57.05 146.55,56.98 PU6000.25
  TOP w0.203: PR6015.2 147.92,59.69 147.55,59.32 147.54,59.32 147.14,58.92 PR6023.1
3662AC_NB_HG1: length 23.3
  TOP w0.508: PR6008.2 142.48,56.54 142.82,56.19 143.82,56.19 v2(144,56.01)
  IN3 w0.508: v2(134.22,70.21) 134.81,69.62 134.81,63.61 136.05,62.38 136.05,62.26 136.66,61.65 140.39,61.65 141.22,60.81 141.22,57.42 142.64,56.01 v2(144,56.01)
3662AC_NB_LG1: length 15.8
  TOP w0.203: PU6000.33 143.14,54.7 143.05,54.79 v2(143.05,54.79)
  IN2 w0.508: v2(143.05,54.79) 143.06,54.81 143.06,55.58 141.76,56.88 141.34,56.88 136.05,62.18 136.05,62.44 135.55,62.93 135.55,65.83 v2(135.95,66.23)
3662AC_NB_LX1: length 56.6
  TOP w0.178: v2(145.11,59.75) 145.11,59.75 145.12,59.75 145.5,59.37 146,59.37 PR6074.1
  TOP w0.203: PU6000.32 143.42,55.1 143.24,55.28 142.77,55.28 142.59,55.1 v2(142.45,55.1)
  TOP w0.305: PC6004.1 141.71,55.1 v2(142.45,55.1)
  IN2 w0.178: v2(145.11,59.75) 145.11,60.05 144.94,60.21 144.23,60.21 144.02,60 142.61,60 139.44,63.17 139.44,72 137.76,73.68 137.76,76.7 137.38,77.08 134.65,77.08 v2(134.38,76.81)
  IN3 w0.508: v2(132.9,70.22) 134.2,68.92 134.2,62.06 134.91,61.36 136.01,61.36 136.34,61.02 140.15,61.02 140.61,60.56 140.61,56.94 v2(142.45,55.1)
  BOTTOM w0.203: v2(134.38,76.81) 134.11,76.81 133.61,76.32 133.61,75.41 133.86,75.17 PL6000.1
3662AC_PGOOD: length 1.9
  TOP w0.152: PR6049.1 144.44,49.82 145.02,50.4 145.26,50.64 145.35,50.74 PU6000.3
3662AC_PWROK: length 1.9
  TOP w0.203: PR6037.1 149.96,55.38 149.29,54.7 PU6000.18
3662AC_RGND: length 44
  TOP w0.203: PU6000.4 145.75,50.71 145.49,50.44 145.49,50.23 v2(145.36,50.09)
  IN1 w0.127: v2(127.64,49.48) 128.08,49.92 128.47,49.92 128.84,49.56 128.84,49.47 130.46,47.85 133.84,47.85 135,46.7 139.92,46.7 141.08,47.85 142.59,47.85 143.11,48.37 144.14,48.37 145.36,49.59 v2(145.36,50.09)
  BOTTOM w0.127: v2(127.64,49.48) 127.48,49.63 123.69,49.63 120.93,52.39 120.76,52.39 120.44,52.7 119.01,52.7 118.65,52.34 113.83,52.34 113.12,53.05 113.12,53.45 112.71,53.86 PR6061.2
  BOTTOM w0.203: PR6064.1 144.91,50.97 144.56,51.32 PR6032.2 ; PR6064.1 145.62,50.36 v2(145.36,50.09) ; PR6064.1 145.83,50.97 146.16,51.31 146.17,51.31 146.58,51.71 PC6018.2
3662AC_SVC: length 2.4
  TOP w0.102: PU6000.19 149.22,55.1 149.67,55.55 149.67,56.12 150,56.45 PR6039.1
3662AC_SVD: length 3.2
  TOP w0.102: PR6041.1 150.03,57.21 150.01,57.23 149.47,57.23 149.24,57 149.24,56.42 149.41,56.25 149.41,55.74 149.18,55.5 PU6000.20
3662AC_SVT: length 1.8
  TOP w0.102: PR6044.1 149.06,57.39 148.15,56.49 PU6000.21
3662AC_TSEN: length 29.6
  TOP w0.203: v2(149.29,51.32) 149.54,51.57 149.54,52.05 149.29,52.3 PU6000.12
  IN1 w0.127: v2(149.29,51.32) 149.93,51.32 150.18,51.07 150.18,50.65 149.96,50.43 149.23,50.43 148.79,50.87 144.96,50.87 142.4,48.31 140.89,48.31 139.73,47.15 136.2,47.15 135.05,48.31 130.96,48.31 130.15,49.12 130.15,49.39 v2(129.51,50.03)
  BOTTOM w0.203: v2(129.51,50.03) 129.47,50.03 128.97,49.53 128.97,49.41 PR6025.2 PR6022.2
3662AC_TSEN_NB: length 36.5
  TOP w0.178: PU6000.23 147.35,56.76 147.59,56.99 147.59,57.21 147.86,57.48 148.25,57.48 148.6,57.84 v2(148.6,59.1)
  IN2 w0.127: v2(133.03,78.47) 133.41,78.85 134.75,78.85 135.48,78.12 137.75,78.12 138.75,77.11 138.75,74.09 140.43,72.41 140.43,63.7 142.45,61.68 145.61,61.68 148.2,59.1 v2(148.6,59.1)
  BOTTOM w0.305: PR6013.2 PR6018.2 132.42,78.83 132.78,78.47 v2(133.03,78.47)
3662AC_VCC: length 2.9
  TOP w0.203: PR6001.2 PC6001.2 150.53,54.67 150.2,54.67 150.19,54.68 149.79,54.68 149.78,54.67 149.73,54.67 149.36,54.3 PU6000.17
3662AC_VDDIO: length 4.6
  TOP w0.203: PU6000.22 147.75,56.71 v2(148.06,57.01)
  BOTTOM w0.102: PR6034.2 148.26,58.16 v2(148.65,57.77)
  BOTTOM w0.457: PC6010.1 147.99,57.01 v2(148.06,57.01) 148.06,57.22 147.61,57.67 PR6034.2
3662AC_VRHOT: length 2.9
  TOP w0.127: PR6051.1 150.18,50.02 149.88,50.32 149.64,50.32 148.83,51.13 PU6000.11
3662ACCOMP_CPU: length 4
  TOP w0.102: v2(145.91,48.86) 145.91,48.81 v2(145.48,48.37)
  TOP w0.203: v2(145.91,48.86) 145.91,48.99 145.74,49.16 PC6015.1 145.86,49.62 145.86,50.33 146.15,50.62 PU6000.5
  BOTTOM w0.203: PR6052.1 145.61,49.37 145.91,49.08 v2(145.91,48.86)
3662ACCOMP_NB: length 2.9
  TOP w0.178: PC6007.1 145.42,57.48 145.65,57.25 145.65,57.04 145.75,56.94 PU6000.27
  TOP w0.203: PC6007.1 PR6026.1
3662ACFB_CPU: length 4.9
  TOP w0.203: PU6000.6 146.55,50.69 146.51,50.65 146.51,50.31 146.35,50.15 v2(146.35,50.13) 146.52,49.95 PC6015.2
  BOTTOM w0.152: PC6016.2 146.61,48.35 146.37,48.59 146.37,48.99 146.39,49.01 PR6052.2
  BOTTOM w0.203: PR6052.2 146.39,50.08 v2(146.35,50.13) ; PC6016.2 PR6053.2
3662ACFB_NB: length 5.4
  TOP w0.203: PR6026.2 PC6007.2 146.2,57.39 146.18,57.38 146.18,57.34 146.15,57.31 146.15,57.27 v2(146.12,57.24) 146.15,57.21 PU6000.26
  BOTTOM w0.102: v2(146.42,59.73) PR6027.2
  BOTTOM w0.203: PR6027.2 PC6008.2 146.42,57.54 v2(146.12,57.24)
3662ACNBISENN: length 5.8
  TOP w0.178: PU6000.24 146.95,56.95 147.04,57.04 147.04,57.04 147.06,57.07 147.06,57.13 147.1,57.17 v2(147.1,57.32) 147.15,57.37 147.3,57.37 147.88,57.95 PC6005.2 PR6023.2
  TOP w0.203: PR6075.2 148.38,59.58 147.92,59.11 PR6023.2
  BOTTOM w0.203: v2(147.1,57.32) 146.45,56.67 PC6006.1
3662ACNBISENP: length 0.9
  TOP w0.203: PR6074.2 146.87,60.13 PR6015.1
3662ACSET1: length 4.4
  TOP w0.203: PU6000.13 149.36,52.7 149.92,52.15 149.92,51.43 150.55,50.8 PR6010.2 150.55,50.41 151.01,49.95 PR6005.2
3662AM_BOOT1_GPU: length 2.9
  BOTTOM w0.203: PR9031.1 77.96,109.02 77.16,109.82 77.16,110.09 76.58,110.68 PU9000.38
3662AM_BOOT2_GPU: length 3
  BOTTOM w0.203: PR9040.1 75.35,108.24 74.95,108.64 PU9000.2
3662AM_BOOT_VDDCI: length 3.9
  BOTTOM w0.203: PR9010.1 77.29,116.67 76.74,116.12 76.74,115.24 v2(76.39,114.9) 76.19,114.7 75.55,114.7 75.35,114.5 PU9000.30
3662AM_COMP_GPU: length 3.9
  BOTTOM w0.152: PU9000.5 73.75,108.37 73.74,108.37 73.74,108.09 73.59,107.94 73.59,107.07 PC9016.1 PR9049.1
3662AM_COMP_VDDCI: length 3
  BOTTOM w0.203: PR9026.1 PC9007.1 75.05,115.84 74.15,114.94 PU9000.27
3662AM_EN_GPU: length 80.9
  IN3 w0.089: v2(134.3,124.45) 133.56,123.7 123.11,123.7 121.57,122.16 120.36,122.16 119.02,123.5 118.36,123.5 118.27,123.41 115.34,123.41 114.73,124.02 114.23,124.02 113.49,123.28 113.49,122.08 112.68,121.27 111.48,121.27 110.36,120.15 108.79,120.15 108.46,119.81 106.45,119.81 105.93,120.33 103.75,120.33 102.96,119.54 101.14,119.54 101.05,119.63 96.03,119.63 95.56,120.1 95.37,120.1 93.95,121.52 93.95,122.34 93.15,123.14 92.75,123.14 90.81,125.08 89.77,125.08 88.83,124.15 88.5,124.15 87.69,124.95 87.4,124.95 86.01,123.57 77.16,123.57 v2(75.25,121.65)
  BOTTOM w0.102: PR77862.1 134.67,124.82 v2(134.3,124.45)
  BOTTOM w0.127: PU9000.29 74.95,114.76 75.17,114.99 75.84,114.99 76.44,115.6 76.44,116.25 76.64,116.45 76.64,117.39 76.44,117.59 76.44,118.34 PC9009.1
  BOTTOM w0.152: PC9009.1 75.7,119.08 75.7,121.07 75.25,121.53 v2(75.25,121.65)
  BOTTOM w0.203: PR77865.2 v2(75.25,121.65) 74.48,121.65 74.23,121.91 PR9029.2
3662AM_FB_GPU: length 6.1
  BOTTOM w0.152: PU9000.6 73.35,108.12 73.1,107.88 PC9016.2 PR9049.2 71.88,107.36 71.66,107.14 71.66,105.89 PR9050.2 PC9017.2
3662AM_FB_VDDCI: length 5.8
  BOTTOM w0.203: PU9000.26 73.75,115.07 74.27,115.6 PC9007.2 PR9026.2 74.2,116.89 PC9008.2 PR9027.2 PR9304.1
3662AM_GPU_ISEN1N: length 5.3
  BOTTOM w0.203: PR9035.1 PC9012.1 68.92,106.15 PR9037.2 68.17,105.74 68.06,105.85 PR9067.2 67.47,105.52 67.39,105.44 66.38,105.44 PR9047.2
3662AM_GPU_ISEN1P: length 1.1
  BOTTOM w0.203: PR9066.2 66.55,107.02 PR9033.2
3662AM_GPU_ISEN2N: length 4.3
  BOTTOM w0.203: PC9015.2 69.89,106.69 PR9000.2 69.89,106.07 PR9044.2 69.68,105.2 69.68,105.19 69.28,104.79 PR9045.1 69.28,104.36 69.31,104.34 PR9069.2
3662AM_GPU_ISEN2P: length 0.9
  BOTTOM w0.203: PR9070.2 70.78,104.55 PR9042.1
3662AM_IMON_GPU: length 4.6
  BOTTOM w0.203: PU9000.14 69.99,111.08 69.73,110.82 68.14,110.82 67.67,111.29 PC9018.1 PR9051.2
3662AM_IMON_VDDCI: length 15.1
  BOTTOM w0.178: PR9064.2 65.51,119.53 65.51,118.65 63.56,116.7 63.56,114.41 64.29,113.68 67.23,113.68 PC9020.1
  BOTTOM w0.203: PC9020.1 68.17,112.74 69.61,112.74 70.47,111.88 PU9000.16
3662AM_ISEN1N_GPU: length 28
  IN2 w0.203: v2(71.16,108.73) 71.16,110.69 69.34,112.51 68.94,112.51 66.02,115.43 63.94,115.43 63.56,115.05 63.56,113.14 64.83,111.87 64.83,110.6 65.47,109.97 65.47,106.68 66.89,105.25 v2(67.95,105.25)
  BOTTOM w0.203: v2(71.16,108.73) 71.25,108.63 71.54,108.63 71.75,108.84 PU9000.10 ; PR9045.2 68.43,104.78 v2(67.95,105.25) ; PR9045.2 68.9,105.17 68.9,105.35 PR9037.1 ; PR9045.2 68.75,104.53 PC9013.2
3662AM_ISEN1P_GPU: length 6.5
  BOTTOM w0.152: PU9000.9 72.15,108.75 71.67,108.27 70.71,108.27 v2(70.7,108.29) 70.64,108.29 69.89,107.53 PR9000.1
  BOTTOM w0.203: PR9033.1 67.18,106.69 PR9035.2 PC9012.2 PR9000.1
3662AM_ISEN2P_GPU: length 18.5
  BOTTOM w0.152: PR9044.1 71.44,105.29 71.44,104.44 71.51,104.38 72.02,104.38 72.18,104.22 72.18,103.73 71.91,103.46 67.78,103.46 67.45,103.79 67.45,104.99 67.3,105.13 65.9,105.13 PR9047.1 ; PR9044.1 70.69,105.43 70.69,105.25 PR9042.2 ; PR9044.1 71.3,106.04 71.3,107.02 PC9015.1 71.19,107.81 72.63,107.81 73.04,108.22 73.04,108.55 72.95,108.64 PU9000.7
3662AM_ISENP_VDDCI: length 6.2
  BOTTOM w0.203: PR9022.1 71.93,116.04 PC9005.1 ; PR9022.1 73.71,116.39 73.77,116.33 73.77,115.68 73.57,115.48 PR9100.2 73.35,115.45 PU9000.25 ; PR9022.1 73.25,117.36 PR9011.2
3662AM_LG1_GPU: length 14.6
  IN2 w0.559: v2(85.41,106.08) 85.41,110.86 84.86,111.42 78.63,111.42 v2(78.12,111.92)
  BOTTOM w0.203: PU9000.35 76.8,111.88 76.83,111.91 77.63,111.91 77.64,111.92 v2(78.12,111.92)
3662AM_LG1_VDDCI: length 4.9
  IN1 w0.508: v2(77.13,112.89) 78.96,114.72 78.96,115.19 v2(79.4,115.62)
  BOTTOM w0.203: PU9000.33 76.92,112.68 v2(77.13,112.89)
3662AM_LG2_GPU: length 16.5
  IN2 w0.559: v2(82.48,98.79) 83.9,100.2 83.9,103.35 82.53,104.71 81.24,104.71 77.91,108.04 77.91,108.58 77.42,109.07 v2(77.18,109.07)
  BOTTOM w0.203: v2(77.18,109.07) 76.83,109.41 76.83,109.95 76.51,110.28 PU9000.39
3662AM_LX1_GPU: length 62.5
  IN2 w0.152: v2(87.7,105.16) 88,104.85 88.01,104.85 88.17,104.69 88.53,104.69 88.71,104.86 91.04,104.86 91.43,104.47 91.43,99.78 90.45,98.8 90.45,98 88.54,96.09 85.07,96.09 82.99,94.01 75.07,94.01 69.08,100 69.08,105.14 66.86,107.35 66.69,107.35 v2(66.23,107.81)
  IN2 w0.559: v2(77.11,111.42) 77.61,111.42 78.27,110.76 v2(84.49,110.76)
  BOTTOM w0.203: v2(66.23,107.81) 65.85,107.81 65.6,107.56 PR9066.1 ; PU9000.36 77.05,111.48 v2(77.11,111.42) ; PL9001.1 88.7,108.45 89.15,108 89.15,106.45 88.3,105.6 88.15,105.6 88.05,105.5 88.04,105.5 v2(87.7,105.16)
  BOTTOM w0.381: v2(77.11,111.42) 77.26,111.27 77.54,111.27 77.55,111.26 PC9010.1
3662AM_LX1_VDDCI: length 34.7
  TOP w0.508: v2(83.59,118.79) 83.47,118.67 PR9071.1
  IN1 w0.559: v2(83.59,118.79) 81.2,118.79 77.58,115.16 77.58,114.51 v2(76.95,113.88)
  IN2 w0.152: v2(72.93,120.33) 72.93,121.63 74.58,123.27 85.89,123.27 v2(87.73,121.42)
  BOTTOM w0.203: v2(76.95,113.88) 76.95,113.54 76.48,113.08 PU9000.32 ; v2(87.73,121.42) 88.07,121.08 88.07,120.5 87.85,120.28 PL9002.1 ; PR9072.1 72.99,120.28 v2(72.93,120.33)
  BOTTOM w0.381: v2(76.95,113.88) 77.35,113.47 PC9004.1
3662AM_LX2_GPU: length 53
  IN2 w0.152: v2(71.72,103.92) 71.17,104.47 70.04,104.47 69.78,104.22 69.78,100.32 75.38,94.72 82.71,94.72 84.84,96.85 88.14,96.85 89.28,97.99 89.28,99.61 88.91,99.99 88.5,99.99 v2(88.07,99.55)
  IN2 w0.559: v2(76.54,108.2) 76.54,108.56 76.52,108.58 76.52,109.35 76.9,109.73 77.69,109.73 78.57,108.86 78.57,108.32 81.4,105.49 82.77,105.49 84.64,103.62 v2(85.15,103.62)
  BOTTOM w0.203: v2(88.07,99.55) 88.2,99.68 88.2,101.01 87.95,101.26 PL9000.1 ; PU9000.40 76.02,109.33 76.54,108.8 v2(76.54,108.2) ; PR9070.1 71.7,103.94 v2(71.72,103.92)
  BOTTOM w0.381: PC9014.1 76.57,107.79 76.57,108.17 v2(76.54,108.2)
3662AM_PGOOD_GPU: length 1.4
  BOTTOM w0.152: PU9000.3 74.55,108.59 74.92,108.22 PR9046.1
3662AM_PWROK_GPU: length 1.9
  BOTTOM w0.178: PR9034.1 69.83,113.41 70.56,112.68 PU9000.18
3662AM_RGND_GPU: length 27.1
  IN2 w0.102: v2(74.2,108.18) 74.62,107.76 74.62,105.53 74.46,105.38 74.46,98.37 76.54,96.3 81.47,96.3 v2(82,96.83)
  BOTTOM w0.152: PR9059.2 82.98,91.58 82.62,91.94 82.62,92.18 82.07,92.73 82.07,96.75 v2(82,96.83) ; PU9000.4 74.15,108.23 v2(74.2,108.18)
  BOTTOM w0.203: PR9059.2 82.6,91.49 82.58,91.5 PR9062.1 ; v2(74.2,108.18) 74.2,108.11 74.06,107.98 PC9019.2
3662AM_SET1_GPU: length 2.8
  BOTTOM w0.178: PR9016.2 70.25,110.34 70.32,110.41 70.33,110.41 70.49,110.57 70.5,110.57 70.61,110.68 PU9000.13
  BOTTOM w0.203: PR9016.2 PR9005.2
3662AM_SVC_GPU: length 3
  BOTTOM w0.203: PU9000.19 70.61,113.08 69.89,113.79 69.89,114.72 PR9036.1
3662AM_SVD_GPU: length 3.4
  BOTTOM w0.203: PU9000.20 70.68,113.48 70.39,113.76 v2(70.39,114.29) 70.39,114.69 70.17,114.92 70.17,115.92 PR9038.1
3662AM_SVT_GPU: length 2.3
  BOTTOM w0.203: PU9000.21 71.75,114.36 71.62,114.49 71.08,114.49 70.64,114.93 PR9041.1
3662AM_TSEN_GPU: length 33.1
  IN2 w0.102: v2(86.7,98.16) 86.28,97.75 84.48,97.75 82.38,95.65 76.29,95.65 73.84,98.11 73.84,103.55 69.59,107.79 69.59,109.32 v2(70,109.73)
  BOTTOM w0.178: PU9000.12 70.64,110.28 70.63,110.26 70.61,110.26 70.08,109.73 v2(70,109.73)
  BOTTOM w0.203: PR9021.2 PR9025.2 87.79,97.5 87.79,98.18 87.53,98.45 86.98,98.45 v2(86.7,98.16)
3662AM_TSEN_VDDCI: length 27.8
  IN1 w0.089: v2(90.38,123.68) 89.85,123.16 89.85,122.67 89.47,122.29 87.82,122.29 87.44,122.67 75.5,122.67 74.5,121.66 74.5,116.82 74.23,116.56 74.23,115.94 73.29,115 v2(72.45,115)
  BOTTOM w0.203: v2(72.45,115) 72.55,114.9 PU9000.23 ; v2(90.38,123.68) PR9019.2 90.38,124.36 PR9009.2
3662AM_UGATE1_GPU: length 4.3
  IN1 w0.559: v2(77.24,110.69) 77.81,110.13 77.81,108.76 77.47,108.41 v2(77.18,108.41)
  BOTTOM w0.203: PU9000.37 76.69,111.08 77.07,110.69 v2(77.24,110.69)
3662AM_UGATE2_GPU: length 11.2
  IN2 w0.559: v2(75.88,108.29) 75.88,105.21 76.13,104.95 76.13,103.87 75.56,103.3 v2(75.56,98.57)
  BOTTOM w0.203: v2(75.88,108.29) 75.8,108.36 75.71,108.36 75.35,108.73 PU9000.1
3662AM_UGATE_VDDCI: length 7.6
  IN1 w0.559: v2(76.91,120.71) 76.91,116.58 76.52,116.19 76.52,114.46 v2(76.07,114.01)
  BOTTOM w0.203: PU9000.31 76.02,113.96 v2(76.07,114.01)
3662AM_VCC_GPU: length 5.3
  BOTTOM w0.178: PU9000.17 70.52,112.28 69.72,113.08 68.29,113.08 68.15,113.21 68.15,113.58 68.01,113.72 68.01,113.99 PR9001.2
  BOTTOM w0.203: PR9001.2 PC9001.2
3662AM_VDDCI_ISENN: length 4.8
  BOTTOM w0.203: PR9073.2 PC9006.1 72.53,118.78 72.76,118.55 72.76,117.65 PR9022.2 71.41,116.31 PC9005.2 PR9102.1
3662AM_VDDCI_ISENP: length 0.9
  BOTTOM w0.203: PR9011.1 73.25,119.15 73.44,119.34 PR9072.2
3662AM_VDDIO_GPU: length 10.3
  BOTTOM w0.102: v2(73.87,121.02) 73.65,121.24 PR9032.2
  BOTTOM w0.203: PR9032.2 72.22,121.24 71.79,120.81 71.79,119.44 71.84,119.39 71.84,117.59 71.46,117.21 PC9011.1 71.41,117.03 71.06,116.68 71.06,114.99 71.21,114.84 71.92,114.84 72.15,114.62 PU9000.22
3662AM_VRHOT_GPU: length 77.3
  TOP w0.102: PR9048.1 125.44,123.08 v2(125.23,122.87)
  IN1 w0.089: v2(87.56,124.5) 87.56,123.91 86.96,123.3 75.37,123.3 74.12,122.05 74.12,117.08 73.67,116.64 73.67,116.22 73.14,115.68 72.1,115.68 70.4,113.99 70.4,109.5 v2(70,109.09)
  IN3 w0.089: v2(125.23,122.87) 124.78,122.41 122.09,122.41 121.65,121.97 120.28,121.97 118.94,123.31 118.44,123.31 118.35,123.22 115.26,123.22 114.65,123.83 114.32,123.83 113.73,123.23 113.73,122.05 112.76,121.08 111.76,121.08 109.99,119.32 108.81,119.32 108.5,119.62 106.37,119.62 105.85,120.14 103.83,120.14 103.04,119.35 101.06,119.35 100.97,119.44 95.95,119.44 95.48,119.91 95.3,119.91 93.76,121.45 93.76,122.27 93.07,122.95 92.67,122.95 91.32,124.3 89.34,124.3 89,123.96 88.42,123.96 87.88,124.5 v2(87.56,124.5)
  BOTTOM w0.178: PU9000.11 71.07,109.51 70.66,109.09 v2(70,109.09)
3662AM_VSEN_GPU: length 4.9
  IN2 w0.203: v2(73.54,105.9) 73.02,105.9 72.55,106.38 v2(72.55,108.37)
  BOTTOM w0.203: v2(72.55,108.37) PU9000.8 ; v2(73.54,105.9) 73.54,105.61 PR9053.1
3662NBBOOTNB: length 5.9
  TOP w0.203: PU6000.30 144.55,56.41 144.08,56.88 v2(143.44,56.88) 142.94,56.88 142.65,57.17 140.41,57.17 139.77,56.53 PR6014.1
3662NBUGATENB: length 3.5
  TOP w0.203: PU6000.31 143.55,55.5 143.39,55.67 142.3,55.67 142.13,55.84 141.48,55.84 140.92,56.41 PR6008.1
5213EN_1.8V: length 4.4
  TOP w0.102: PU3004.7 38.72,27.09 38.54,26.91 38.54,26.28 38.95,25.87 PC581.1 38.95,25.1 39.04,25.01 PR566.1 39.04,24.11 v2(38.67,23.74)
5213EN_VDD08: length 4.3
  TOP w0.102: v2(88.28,116.45) 88.58,116.45 88.84,116.18 PR9105.2
  TOP w0.203: PU9007.7 90.02,114.54 90.28,114.79 90.28,115.92 PC9192.1 89.57,116.09 89.48,116.18 PR9105.2
5213FB_1.8V: length 3.5
  TOP w0.305: 42.33,26.43 42.16,26.59 PU3004.1
  TOP w0.381: PR567.2 41.58,24.87 v2(42.04,25.32) 42.33,25.61 42.33,26.43
5213FB_1.8V_S: length 6.5
  TOP w0.381: 35.11,24.24 35.11,22.85 35.88,22.08 37.65,22.08 v2(37.97,22.4) 38.41,22.84 PC574.1
5213FB_VDD08: length 5.5
  TOP w0.102: v2(84.53,116.94) PR9107.1
  TOP w0.203: PU9007.1 86.82,115.04 86.69,115.16 86.69,115.47 87.44,116.22 PC9189.2 PR9106.2 PR9107.1
5213PG_1.8V: length 2.1
  TOP w0.203: PU3004.2 42.35,27.09 43.06,26.39 PR9290.1
5213PG_VDD08: length 2.1
  TOP w0.203: PU9007.2 86.48,114.54 85.94,115.08 PR9104.1
5447_CC1_CON: length 22.1
  TOP w0.305: U2034.12 v2(21.12,12.55)
  TOP w0.508: C438.2 v2(10.22,18.4)
  IN3 w0.508: 11.17,15.54 11.17,17.45 v2(10.22,18.4) ; 11.17,15.54 10.5,14.87 9.13,14.87 v2(8.75,14.49) ; 11.17,15.54 11.85,14.87 14.64,14.87 16.06,13.45 18.1,13.45 18.99,12.55 v2(21.12,12.55)
  BOTTOM w0.254: v2(8.75,14.49) 8.09,15.15 CN14.A5
  BOTTOM w0.508: C2769.2 21.02,12.66 v2(21.12,12.55) ; C438.2 v2(10.22,18.4)
5447_CC2_CON: length 35.4
  TOP w0.305: v2(23.18,14.74) 23.06,14.86 U2034.14
  TOP w0.508: C711.2 v2(10.48,13.83)
  IN3 w0.152: 7.3,17.13 6.74,17.69 5.88,17.69 5.74,17.55 5.54,17.07 CN14.B5 5.23,16.35 5.73,15.14 5.73,14.96 5.62,14.71 5.62,14.53 5.7,14.33 6.08,13.96 6.92,13.96 7.3,14.34
  IN3 w0.508: v2(23.18,14.74) 23.18,13.93 23.74,13.37 23.74,12.91 24.17,12.48 24.17,11.93 23.72,11.48 18.99,11.48 17.78,12.69 14.92,12.69 14.41,13.19 11.49,13.19 10.86,13.83 v2(10.48,13.83) 7.81,13.83 7.3,14.34 7.3,17.13
  BOTTOM w0.508: C2768.2 23.06,14.84 23.15,14.74 v2(23.18,14.74) ; C711.2 v2(10.48,13.83)
8801EN: length 35.2
  BOTTOM w0.102: PR77858.1 v2(96.45,94.6) 97.33,94.6 101.26,90.66 110.04,90.66 111.57,89.14 112.71,89.14 113.22,89.65 119.57,89.65 121.6,87.62 121.6,86.6 121.34,86.34 PR77846.2 PR77864.2 PC9182.1 118.67,86.34 118.43,86.09 PU9.2
24780_ACDET: length 8.9
  TOP w0.102: v2(135.32,35.55) 135.54,35.32 v2(135.54,34.93)
  TOP w0.198: v2(135.54,34.93) 135.25,34.64 PR246.2
  TOP w0.305: PQ9.3 137.5,35.82 137.12,35.45 137.12,35.01 136.93,34.81 135.66,34.81 v2(135.54,34.93)
  BOTTOM w0.198: PU12.6 135.02,33.85 135.54,34.37 v2(135.54,34.93) 135.81,34.93 136.06,34.67 PR245.2
24780_ACDRV: length 1.6
  BOTTOM w0.198: PU12.4 134.22,34.32 PR247.2
24780_ACN: length 145.5
  TOP w0.203: PR19.1 53.38,113.93 v2(53.66,113.65)
  TOP w0.254: v2(132.08,35.31) 132.37,35.02 PC74.1
  IN1 w0.254: v2(132.08,35.31) 131.49,35.31 129.22,37.58 128.38,37.58 122.52,43.44 122.52,50.79 120.46,52.84 120.46,58.41 118.62,60.24 117.22,60.24 115.28,62.19 115.28,67.91 113.47,69.71 113.47,71.32 112.83,71.96 112.83,80.51 112.08,81.27 112.08,82.28 112.26,82.46 112.26,83.58 111.44,84.4 111.44,88.12 110.67,88.89 v2(110.63,88.89)
  IN3 w0.254: v2(110.63,88.89) 110.38,88.63 107.11,88.63 104.35,91.39 104.35,91.83 95.06,101.13 95.06,106.85 94.83,107.08 94.83,110.36 91.97,113.22 86.25,113.22 83.28,116.19 73.86,116.19 73.23,116.83 71.56,116.83 70.29,118.1 64.27,118.1 59.83,113.65 v2(53.66,113.65)
  BOTTOM w0.198: v2(132.08,35.31) 132.08,35.08 131.88,34.88 PC237.2 131.88,34.67 132.39,34.16 132.42,34.16 133.02,33.56 PU12.1
24780_ACP: length 147.6
  TOP w0.203: v2(52.89,113.65) 52.67,113.88 PR18.1
  TOP w0.254: v2(132.8,35.31) 132.93,35.19 132.94,35.19 133.13,34.99 133.13,34.51 PC76.2
  IN1 w0.254: v2(110.47,89.5) 110.7,89.5 111.8,88.4 111.8,84.55 113.22,83.12 113.22,72.08 113.92,71.38 113.92,69.77 115.63,68.06 115.63,62.34 117.28,60.69 118.81,60.69 120.81,58.69 120.81,53 122.87,50.94 122.87,43.59 128.43,38.03 129.41,38.03 131.63,35.8 132.32,35.8 v2(132.8,35.31)
  IN3 w0.254: v2(110.47,89.5) 109.98,89.01 107.23,89.01 104.71,91.53 104.71,91.98 95.41,101.27 95.41,107 95.18,107.23 95.18,110.51 92.12,113.57 86.4,113.57 83.42,116.55 74.24,116.55 73.45,117.33 72.07,117.33 71.84,117.56 71.84,118.02 71.41,118.45 64.12,118.45 59.81,114.13 53.37,114.13 52.89,113.66 v2(52.89,113.65)
  BOTTOM w0.198: PU12.2 133.42,33.62 132.66,34.38 PC237.1 132.66,35.16 132.8,35.3 v2(132.8,35.31)
24780_BATDRV: length 4.6
  TOP w0.508: v2(133.56,27.63) 133.47,27.55 132.77,27.55 132.34,27.98 132.34,28.08 131.68,28.74 PR99.1
  BOTTOM w0.198: v2(133.56,27.63) 134.22,28.3 PU12.18
24780_BATSRC: length 5.1
  TOP w0.508: v2(134.57,27.64) 133.84,26.92 v2(133.03,26.92) 132.51,26.92 131.91,27.52 PR108.2
  BOTTOM w0.198: v2(134.57,27.64) 134.62,27.7 PU12.17
24780_BM#: length 7
  BOTTOM w0.198: PR264.1 137.35,29.06 137.22,28.93 137.22,28.18 137.73,27.67 137.73,27.29 137.46,27.02 135.78,27.02 135.35,27.45 v2(135.35,27.89) 135.02,28.22 PU12.16
24780_BST: length 2.2
  BOTTOM w0.198: PR254.1 130.64,31.06 130.84,31.26 131.31,31.26 131.39,31.18 PU12.25
24780_CMPIN: length 2.7
  TOP w0.203: v2(137.97,30.67) 137.42,30.13 PR85.1
  BOTTOM w0.198: PU12.13 136.99,30.38 137.28,30.67 v2(137.97,30.67)
24780_CMPOUT: length 1.6
  BOTTOM w0.198: PU12.14 137.18,29.98 137.22,30.02 PR265.1
24780_CMSRC: length 1.6
  BOTTOM w0.198: PR248.2 133.6,34.66 133.6,34.02 133.82,33.8 PU12.3
24780_DH: length 13.1
  IN1 w0.508: v2(130.79,31.75) 130.79,31.65 129.09,29.96 123.63,29.96 121.44,32.15 v2(121.44,32.74)
  BOTTOM w0.198: v2(130.79,31.75) 130.95,31.58 131.44,31.58 131.45,31.58 PU12.26
24780_DL: length 7.2
  BOTTOM w0.198: 131.31,30.21 131.48,30.38 PU12.23
  BOTTOM w0.381: 131.31,30.21 128.71,30.21 v2(128.27,29.77) 127.72,29.22 126.2,29.22 126.14,29.17 PQ27.4
24780_ILIM: length 5.2
  TOP w0.102: PR98.1 135.03,27.57 v2(135.32,27.29)
  TOP w0.254: PR98.1 134.54,28.18 134.53,28.17 PC96.2 PR97.1 133.05,28.17 132.49,28.73 v2(132.49,29.46)
  BOTTOM w0.198: PU12.21 132.77,29.18 v2(132.49,29.46)
24780_LX: length 10
  IN1 w0.508: v2(129.52,31.87) 128.63,32.75 124.27,32.75 v2(123.51,31.99)
  BOTTOM w0.198: PU12.27 131.24,31.98 130.99,32.23 130.44,32.23 PC243.1
  BOTTOM w0.406: v2(129.52,31.87) 130.12,32.47 PC243.1
24780_PROCHOT: length 7.7
  TOP w0.152: v2(137.9,32.53) 138.24,32.87 139.1,32.87 v2(139.29,32.69) 139.29,32.48 138.64,31.83 138.64,30.7 138.58,30.64 PR9292.2 138.58,29.33
  TOP w0.203: 138.58,29.33 PR252.1
  BOTTOM w0.198: PU12.10 136.73,31.58 137.18,32.03 137.18,32.39 137.31,32.53 v2(137.9,32.53)
24780_SRN: length 18
  BOTTOM w0.152: PR271.2 114.84,25.77 116.15,25.77 116.76,26.37 125.66,26.37 126.68,27.38 128.38,27.38 PC253.1 129.23,28.23 130.57,28.23 130.77,28.03 PC254.2
  BOTTOM w0.198: PR267.1 131.24,27.79 131.23,27.78 PC254.2
24780_SRP: length 17.2
  BOTTOM w0.152: 130.77,28.98 130.32,28.54 128.77,28.54 PC253.2 128.76,28.55 128.27,28.07 128.27,27.83 128.12,27.67 126.51,27.67 125.48,26.65 116.64,26.65 116.15,26.16 PR270.2
  BOTTOM w0.198: PR261.1 131.09,28.5 130.77,28.82 PC248.2
24780_VCC: length 2.8
  TOP w0.457: v2(131.04,32.78) 130.96,32.78 130.18,32 130.18,31.18 PR81.1
  vias: v2(131.13,33.51)
25810_POL#_EC: length 2.2
  TOP w0.102: R6514.1 TP9099.1 16.7,18.91 16.19,19.42 R264.2
+601_VCC:
  vias: v2(203.64,15.73) v2(206.69,10.78) v2(213.17,17.77)
+APU_VDD_33: length 21.1
  TOP w0.305: 89.61,47.53 89.22,47.92 89.22,48.63 89.6,49.01 v1(89.72,49.01) C2531.1
  TOP w0.381: C2532.1 89.61,47.53
  TOP w0.508: R2391.2 89.46,29.97 89.15,30.28 C2533.1 89.15,31.54 89.52,31.92 89.52,32.66 89.74,32.88 89.74,38.85 89.95,39.06 89.95,41.05 89.67,41.33 89.67,41.84 v2(89.67,45.58) 89.67,46.34 89.61,46.41 C2532.1
+APU_VDD_33_S5: length 17
  TOP w0.381: 90.35,44.56 90.35,47.5 89.77,48.08 C2537.1 89.77,48.31 90.46,49.01 v1(90.61,49.01) 90.74,49.14 C2538.1
  TOP w0.508: 90.51,34.13 90.51,37.88 90.71,38.09 90.71,39.1 91.4,39.79 91.4,41.25 90.35,42.3 90.35,44.56
  vias: v2(91.63,33.01)
+APU_VDDIO_AZ: length 13
  TOP w0.508: v1(93.73,37.06) 93.73,36.34 94.52,35.55
  IN3 w0.508: v1(93.73,37.06) 94.51,37.06 94.83,37.37 94.83,39.38 95.1,39.65 95.1,40.53 94.65,40.97 94.65,45.1 94.47,45.27 94.47,46.29 v1(94.03,46.73)
  vias: v2(96.96,35.24)
+AZA_VDD: length 27.3
  TOP w0.203: R780.2 200.43,20.09 199.96,20.56 199.93,20.56 199.61,20.89 R364.2 199.07,21.07 198.31,21.83 198.31,23.51 v2(198.82,24.01)
  IN3 w0.381: v2(207.96,22.72) 207.96,20.94 207.33,20.31 206.82,20.31 205.55,19.04 203.9,19.04 202.75,20.18 200.47,20.18 199.45,21.2 199.45,23.38 v2(198.82,24.01)
  BOTTOM w0.203: C656.1 199.32,24.12 199.29,24.15 199.29,24.33 199.42,24.46 U30.1 ; U30.36 206.69,24.46 206.82,24.33 206.82,23.86 207.2,23.48 C624.1
  BOTTOM w0.381: v2(198.82,24.01) 198.49,24.01 198.23,23.76 C666.1 C656.1 ; v2(207.96,22.72) 207.67,22.72 C624.1
+BAT_RTC: length 111.3
  TOP w0.508: 98.99,28.94 98.99,28.18 98.49,27.67 96.47,27.67 95.78,26.99 95.67,26.99 94.7,26.02 89.24,26.02 v2(88.38,26.88) 87.23,28.03 86.78,28.03 84.77,30.04 84.77,30.74 83.52,31.99 82.3,31.99 80.02,34.26 76.82,34.26 73.98,31.42 v2(73.98,29.32)
  IN1 w0.508: v2(14.92,8.92) 17.54,8.92 17.9,8.56 20.07,8.56 21.27,9.77 25.21,9.77 27.62,12.18 27.62,13.45 28.38,14.21 v2(29.02,14.21)
  IN2 w0.508: v2(36.39,30.26) 37,30.87 39.81,30.87 40.45,30.24 55.46,30.24 56.27,29.42 60.39,29.42 60.73,29.08 70.31,29.08 70.67,28.71 73.62,28.71 73.98,29.07 v2(73.98,29.32)
  IN3 w0.508: v2(36.39,30.26) 36.39,28.57 31.66,23.84 31.66,15.99 29.88,14.21 v2(29.02,14.21)
  BOTTOM w0.508: CN2020.1 v2(14.92,8.92)
+ECVSPI: length 14.5
  TOP w0.203: 162.78,30.97 C370.1 C374.2 v2(162.78,32.88)
  BOTTOM w0.381: R351.2 159.07,24.12 v2(158.61,24.57) 158.61,27.91 159.65,28.94 161.48,28.94 163,30.47 U33.8
  BOTTOM w0.508: v2(162.78,32.88) 163,32.65 U33.8
+G_SEN_PW:
  vias: v2(60.77,16.5) v2(64.45,15.78) v2(66.84,15.73)
+TYPEC_VBUS: length 5.6
  BOTTOM w0.254: v2(8.06,14.46) 7.88,14.65 CN14.A4 6.17,14.65 CN14.B9 ; v2(8.06,17.39) 7.83,17.15 CN14.A9 6.17,17.15 CN14.B4
  BOTTOM w0.381: C426.2 v2(10.09,19.42) ; C462.2 v2(10.48,12.81)
  vias: v2(11.77,23.23) v2(11.77,22.59) v2(13.46,23.86) v2(13.46,23.21) v2(13.47,22.57) v2(14.54,17.51) v2(26.27,16.01)
+USBPWR0: length 0.7
  TOP w0.203: U5.2 v2(19.86,54.49)
  vias: v2(18.48,51.93) v2(18.48,51.17) v2(19.11,51.93) v2(19.11,51.17) v2(19.62,50.15)
+USBPWR1:
  vias: v2(20.59,33.97)
+VGA_CORE: length 106.7
  IN1 w0.381: v2(115.53,109.1) 116.37,109.95 116.37,113.54 117.37,114.54 119.96,114.54 123.04,117.62 124.87,117.62 126.02,118.77 127.23,118.77 128.34,119.88 v2(128.34,120.17)
  IN2 w0.152: v2(88.71,99.55) 89.03,99.23 89.03,98.1 88.05,97.12 84.74,97.12 82.61,94.98 75.5,94.98 70.22,100.27 70.22,103.97 v2(70.29,104.04) ; v2(88.35,105.12) 91.16,105.12 91.7,104.58 91.7,99.69 90.71,98.7 90.71,97.87 88.67,95.83 85.17,95.83 83.09,93.74 74.96,93.74 68.81,99.89 68.81,105 67.38,106.44 v2(66.36,106.44)
  BOTTOM w0.203: v2(70.29,104.04) 70.19,103.94 PR9069.1 ; v2(88.71,99.55) 88.53,99.73 88.53,100.96 88.83,101.26 PL9000.2 ; PR9067.1 66.79,105.85 66.61,106.03 66.61,106.18 v2(66.36,106.44) ; v2(88.35,105.12) 89.48,106.25 89.48,107.96 89.97,108.45 PL9001.2
  BOTTOM w0.381: PR77860.1 128.34,120.12 v2(128.34,120.17)
  vias: v2(96.2,103.24) v2(103.93,108.64) v2(105.52,108.65) v2(107.3,106.22) v2(107.3,105.22) v2(107.3,103.22) v2(107.3,102.22) v2(107.45,107.1) v2(107.35,101.23) v2(107.5,109.1) v2(107.45,104.28) v2(108.47,109.1) v2(108.47,104.28) v2(108.49,101.31) v2(109.49,109.1) v2(109.49,104.28) v2(109.56,101.26) v2(110.5,109.08) v2(110.5,108.22) v2(110.5,104.28) v2(110.5,101.26) v2(111.54,108.22) v2(111.52,101.08) v2(111.49,100.37) v2(112.51,108.24) v2(112.46,105.12) v2(112.48,104.28) v2(112.51,100.37) v2(113.42,108.24) v2(114.34,105.22) v2(114.51,102.09) v2(114.51,101.08) v2(114.51,100.37) v2(114.57,108.24) v2(114.59,104.2) v2(115.58,105.22) v3(90.26,107.43) v3(90.26,106.67) v3(90.26,105.9) v3(90.44,109.82) v3(90.44,109.08) v3(91.02,107.43) v3(91.02,106.67) v3(91.02,105.9) v3(91.17,109.82) v3(91.17,109.08) v3(91.68,106.23) v3(93.79,105.4) v3(93.79,104.66) v3(93.79,103.92) v3(93.79,103.19) v3(93.79,102.45) v3(93.79,101.71) v3(93.79,100.95) v3(93.79,100.19) v3(94.52,105.4) v3(94.52,104.66) v3(94.52,103.92) v3(94.52,103.19) v3(94.52,102.45) v3(94.52,101.71) v3(94.52,100.95)
+VREF_CA0: length 3.7
  TOP w0.102: v2(49.34,55.87) 49.5,56.03 R2682.2
  TOP w0.203: 50.86,54.85 C2369.1 C2368.2
  BOTTOM w0.254: v2(51.62,53.33) 51.5,53.46 CN2019.164
+VREF_CA1: length 154.7
  TOP w0.203: C2694.1 37.36,42.15 37.33,42.18 ; 36.89,77.33 C2690.1 ; C2470.2 36.94,42.91 ; C2693.2 36,77.7
  TOP w0.356: U2017.M1 37.33,76.06 ; 37.33,42.18 U2013.M1
  TOP w0.381: 36.02,54.67 36.36,55 C2689.2 C2469.1 37.3,54.37 37.33,54.34 U2014.M1 ; 37.33,42.18 37.33,42.53 37.23,42.62 ; U2018.M1 38.35,87.93 41.19,87.93 43.1,89.84
  TOP w0.508: 36.02,54.67 34.03,54.67 32.69,56.01 28.38,56.01 28.26,56.12 ; R2389.2 v2(48.64,49.81) ; 37.33,76.06 37.33,76.51 36.89,76.95 36.89,77.33 36.52,77.7 35.61,77.7 34.86,76.95 29.53,76.95 28.76,76.19 v2(28.76,74.03) 28.26,73.53 28.26,56.12 ; 28.26,56.12 28.26,50.37 27.87,49.98 27.87,42.79 ; 27.87,42.79 30.16,42.79 30.39,43.02 36.83,43.02 37.23,42.62 ; 27.87,42.79 27.87,38.72 v2(31.94,34.66)
  IN1 w0.508: v2(43.24,91.55) 43.24,90.54 41.62,88.91 31.84,88.91 29.86,86.93 29.86,77.49 28.51,76.15 28.51,74.28 v2(28.76,74.03)
  IN2 w0.508: v2(31.94,34.66) 32.57,34.66 34.48,32.75 35.75,32.75 36.29,32.21 37.9,32.21 39.57,32.63 46.36,32.63 47.26,33.53 47.26,37.54 47.69,37.96 47.69,48.86 v2(48.64,49.81)
  vias: v2(43.75,90.28)
AC_PRESENT_EC: length 122.8
  TOP w0.102: v2(179.39,22.87) 179.87,23.36 U13.84 ; v1(97.12,46.29) 97.32,46.08 98.16,46.08 98.74,46.67 100.51,46.67 100.87,47.03 102.98,47.03 105.95,50 110.17,50 111.62,51.45 112.31,51.45 113.36,50.41 v2(115.76,50.41)
  IN3 w0.089: v2(115.76,50.41) 117.73,48.44 117.73,39.45 116.91,38.63 116.91,35.43 116.31,34.83 114.21,34.83 113.69,34.3 113.69,32.79 115.12,31.35 115.12,27.11 116.72,25.51 120.64,25.51 121.94,26.81 140.22,26.81 141.48,28.07 152.89,28.07 153.45,28.62 155.77,28.62 156.37,28.03 158.96,28.03 159.45,27.54 163.28,27.54 163.95,26.87 166.16,26.87 166.71,26.32 168.92,26.32 169.77,25.47 172.84,25.47 174.06,24.25 177.1,24.25 177.7,23.65 179.26,23.65 179.39,23.53 v2(179.39,22.87)
  BOTTOM w0.102: R77851.1 178.06,21.55 v2(179.39,22.87) ; U2030.AT10 96.99,46.29 v1(97.12,46.29)
ACCEL_INT1: length 48
  TOP w0.102: v2(62.7,28.05) 62.64,28 v2(62.64,24.75) C395.2 62.64,22.87 62.75,22.77 D14.1
  IN2 w0.089: v1(91.07,42.99) 91.5,42.56 91.5,39.61 90.58,38.69 90.58,35.4 89.15,33.97 89.15,33.24 88.49,32.57 87.95,32.57 87.7,32.82 85.45,32.82 84.15,31.53 83.2,31.53 82.65,30.98 82.65,29.3 80.81,27.46 63.29,27.46 v2(62.7,28.05)
  BOTTOM w0.102: U2030.AW16 90.6,43.31 90.92,42.99 v1(91.07,42.99)
ACCEL_INT2: length 154.2
  TOP w0.102: D15.1 68.57,20.83 68.63,20.77 v2(68.63,20.13)
  IN1 w0.089: v2(68.63,20.13) 69.75,19.02 74.96,19.02 76.37,20.43 91.02,20.43 91.47,20.88 98.54,20.88 v2(101.15,18.27)
  IN3 w0.089: v2(211.8,17.92) 209.05,17.92 207.28,16.15 205.26,16.15 204.23,15.12 194.32,15.12 192.47,16.97 187.36,16.97 186.88,16.5 176.46,16.5 175.98,16.97 173.14,16.97 171.77,15.6 169.17,15.6 168.35,16.42 164.98,16.42 164.27,17.13 159.95,17.13 159.5,16.67 159.5,16.17 159.24,15.91 147.77,15.91 145.8,17.87 101.55,17.87 v2(101.15,18.27)
  BOTTOM w0.102: R835.2 212.02,16.62 211.8,16.85 v2(211.8,17.92)
ACCEL_INT2_R: length 4
  TOP w0.102: v2(67.24,23.23) 66.43,22.41 D15.2 66.43,21.27 66.16,21 U16.9
ACCEL_INTA_R: length 4
  TOP w0.102: U16.11 65.16,20.87 64.89,21.14 D14.2 64.89,22.41 v2(64.07,23.23)
ACIN: length 58.4
  TOP w0.102: v2(169.91,25.89) 170.01,25.79 170.01,23.46 171.66,21.8 174.45,21.8 177.22,19.04 178.06,19.04 178.16,19.14 178.8,19.14 179.29,18.66 180.15,18.66 180.25,18.56 U13.72
  TOP w0.254: v2(134.85,36.07) 134.85,35.97 134.48,35.59 PR75.2 134.29,35.09 PR74.1
  IN3 w0.089: v2(134.85,36.07) 135.43,36.07 137.48,34.02 138.9,34.02 143.55,29.37 147.59,29.37 148.69,28.26 152.81,28.26 153.37,28.82 155.85,28.82 156.44,28.22 158.27,28.22 158.5,28.45 162.64,28.45 164.03,27.06 166.24,27.06 166.79,26.51 169.3,26.51 v2(169.91,25.89)
  BOTTOM w0.203: v2(134.85,36.07) 135.04,35.89 PR80.2
ACZ_BCLK_R: length 7.4
  BOTTOM w0.102: R2426.1 107.5,48.37 107.39,48.26 107.39,47.98 107.28,47.87 106.87,47.87 106,47 103.21,47 103.06,46.85 102.68,46.85 102.55,46.98 102.21,46.98 101.94,46.7 101.61,46.7 U2030.AR2
ACZ_RST#_AUDIO: length 132.4
  IN1 w0.089: v2(197.05,22.47) 197.93,23.34 197.93,23.74 199.32,25.13 199.32,26.53 199.07,26.78 198.56,26.78 197.12,28.23 195.38,28.23 v2(194.86,27.72) 194.61,27.47 192.01,27.47 189.98,25.44 v2(189.98,24.45)
  IN3 w0.089: v2(189.98,24.45) 189.92,24.4 189.06,24.4 186.87,22.21 183.2,22.21 182.94,22.47 178.45,22.47 177.89,23.03 174.11,23.03 172.15,25 167.77,25 167.55,25.22 166.67,25.22 165.49,26.4 163.75,26.4 163.09,27.07 159.26,27.07 158.77,27.56 156.17,27.56 155.74,27.99 153.47,27.99 153.09,27.6 146.11,27.6 144.85,26.34 122.13,26.34 120.84,25.04 116.52,25.04 115.33,26.23 114.46,26.23 114.04,26.65 114.04,30.89 111.95,32.98 111.95,35.42 112.9,36.36 112.9,39.96 113.88,40.94 113.88,47.2 111.69,49.39 110.42,49.39 v1(110.04,49.01)
  BOTTOM w0.102: v2(197.05,22.47) 197.73,21.78 Q45.1 ; R2429.2 109.92,49.14 v1(110.04,49.01) ; v2(194.86,27.72) 194.86,28.29 195.26,28.69 196.4,28.69 196.53,28.56 197.12,28.56 197.37,28.82 R782.1
