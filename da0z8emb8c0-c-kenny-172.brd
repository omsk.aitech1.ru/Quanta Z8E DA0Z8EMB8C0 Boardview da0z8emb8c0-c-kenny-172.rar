# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 90.65,63.64 90.7,63.61 90.7,63.55 90.67,63.53 90.69,63.41 90.65,63.29 90.55,63.21 90.51,63.2 90.18,62.86 90.18,62.41 90.23,62.31 90.28,62.27 90.54,62.02 90.58,62 90.68,61.93 90.72,61.81 90.66,61.67 90.51,61.61 90.46,61.61 90.39,61.62 90.31,61.6 90.28,61.59 90.04,61.82 89.33,61.82 89.28,61.88 89.28,62.49 89.29,62.55 89.29,62.6 89.29,62.65 89.28,62.7 89.28,62.83 89.42,62.97 89.78,62.97 90.26,63.45 90.27,63.48 90.38,63.61 90.54,63.63 90.58,63.62
GND on TOP (solid shape): 91.48,55.55 91.54,55.41 91.5,55.29 91.4,55.22 91.37,55.2 91.23,55.07 91.18,55.04 91.12,55.02 91.05,55.02 90.92,54.97 90.87,54.85 90.87,54.8 90.11,54.8 90.1,54.85 90.05,54.97 89.93,55.02 89.87,55.04 89.81,55.07 89.68,55.2 89.64,55.22 89.55,55.29 89.51,55.41 89.57,55.55 89.71,55.61 89.81,55.59 89.88,55.52 89.91,55.48 89.98,55.44 90.89,55.44 90.89,55.44 91.05,55.43 91.17,55.52 91.24,55.59 91.34,55.61
GND on TOP (solid shape): 107.17,43.88 107.31,43.73 107.51,43.67 107.55,43.68 107.62,43.69 107.95,43.37 107.95,43.04 107.57,43.04 107.48,43.01 107.44,42.92 107.44,42.71 107.47,42.63 107.54,42.59 107.58,42.58 107.58,42.36 107.54,42.35 107.47,42.3 107.44,42.22 107.44,42.02 107.44,41.99 107.45,41.96 107.45,41.9 107.3,41.9 107.3,41.96 107.31,41.99 107.31,42.02 107.31,42.22 107.29,42.3 107.21,42.35 107.17,42.36 107.17,42.58 107.21,42.59 107.29,42.63 107.31,42.71 107.31,42.92 107.28,43.01 107.19,43.04 106.81,43.04 106.75,43.03 106.7,42.99 106.64,42.99 106.33,42.68 106.09,42.68 105.07,43.7 105.05,43.81 105.14,43.88
GND on TOP (solid shape): 119.66,105.21 119.73,105.17 119.86,105.05 120.02,105.01 120.06,105.01 120.12,105.02 120.35,104.79 120.83,104.79 120.88,104.75 120.87,104.7 120.82,104.65 120.76,104.66 120.72,104.66 120.47,104.55 120.37,104.3 120.37,104.25 120.38,104.19 120.37,104.1 120.29,104.06 119.71,104.06 119.66,104.11 119.67,104.17 119.67,104.2 119.57,104.45 119.31,104.56 119.28,104.56 119.2,104.58 119.17,104.66 119.17,104.97 119.2,105.04 119.28,105.07 119.31,105.07 119.46,105.09 119.57,105.18
GND on TOP (solid shape): 113.39,36.28 113.43,36.3 113.46,36.29 113.58,36.21 113.71,36.18 113.8,36.12 113.78,36.01 113.44,35.68 113.44,35.07 113.4,34.99 113.31,34.97 113.27,34.98 113.22,34.99 113.14,34.98 113.05,34.95 112.73,34.95 112.1,34.32 111.99,34.3 111.93,34.39 111.93,34.79 111.7,35.02 111.49,35.02 111.45,35.03 111.42,35.03 111.38,35.03 111.34,35.02 109.34,35.02 109.24,35 109.18,34.92 108.95,34.78 108.72,34.92 108.7,34.97 108.61,35.02 108.08,35.02 107.99,35.12 107.96,35.23 108.06,35.29 112.4,35.29
GND on TOP (solid shape): 134.48,99.06 134.62,98.92 134.81,98.87 134.95,98.9 135.07,98.97 139.63,94.42 139.63,92.71 139.54,92.71 139.52,92.78 139.5,92.81 139.5,93.83 139.12,94.21 139.12,94.62 137.66,96.09 135.55,96.09 135.53,96.1 135.53,96.3 135.55,96.32 136.51,96.32 136.75,96.55 136.75,96.97 136.51,97.21 135.55,97.21 135.53,97.22 135.53,98.11 135.29,98.35 134.54,98.35 134.53,98.36 134.53,98.64 134.29,98.88 133.88,98.88 133.64,98.64 133.64,98.36 133.62,98.35 133.53,98.35 133.51,98.36 133.51,98.64 133.27,98.88 132.86,98.88 132.62,98.64 132.62,98.36 132.61,98.35 132.34,98.35 132.33,98.36 132.33,98.64 132.09,98.88 131.68,98.88 131.44,98.64 131.44,98.36 131.42,98.35 131.33,98.35 131.31,98.36 131.31,98.64 131.07,98.88 130.66,98.88 130.42,98.64 130.42,98.36 130.41,98.35 130.15,98.35 129.96,98.54 129.65,98.54 129.57,98.58 129.55,98.67 129.57,98.72 129.57,98.78 129.56,98.85 129.54,98.92 129.55,99.01 129.64,99.06
GND on TOP (solid shape): 123.51,101.81 123.51,101.81 123.58,101.73 123.68,101.7 125.23,101.7 125.32,101.65 125.32,101.55 125.29,101.47 125.28,101.38 125.31,101.24 125.4,101.12 125.43,101 125.33,100.94 125.2,100.94 125.11,100.98 125.1,101.08 125.13,101.15 125.13,101.22 124.78,101.57 124.42,101.22 124.43,101.15 124.45,101.08 124.44,100.98 124.35,100.94 124.07,100.94 122.94,102.07 122.91,102.18 123.01,102.24 123.08,102.24
GND on TOP (solid shape): 167.05,26.22 167.37,26.22 167.43,26.17 167.38,26.12 167.36,26.12 167.09,26 166.98,25.74 167.04,25.53 167.19,25.39 167.19,25.08 167.15,25 167.06,24.98 167.02,24.99 166.56,24.99 166.53,24.96 166.47,24.95 166.44,25 166.44,25.06 166.44,25.1 166.42,25.13 166.41,25.16 166.42,25.19 166.44,25.22 166.44,25.26 166.44,25.46 166.44,25.5 166.42,25.53 166.41,25.56 166.42,25.59 166.44,25.62 166.44,25.66 166.44,25.86 166.44,25.9 166.42,25.93 166.41,25.96 166.42,25.98 166.44,26.02 166.44,26.06 166.44,26.26 166.44,26.3 166.42,26.33 166.41,26.36 166.42,26.39 166.44,26.42 166.44,26.46 166.44,26.66 166.42,26.73 166.48,26.79
GND on TOP (solid shape): 114.95,108.06 114.98,108.11 115.03,108.1 115.07,108.06 115.68,108.06 115.69,108.06 115.8,108.09 115.86,107.99 115.86,106.31 116.48,105.68 116.48,105.52 116.48,105.51 116.48,105.42 116.03,105.42 115.87,105.57 115.82,105.61 115.75,105.62 115.4,105.62 115.33,105.6 115.16,105.43 114.75,105.43 114.56,105.62 114.2,105.62 113.93,105.35 113.7,105.12 112.99,105.12 112.75,105.37 112.6,105.51 112.33,105.51 112.27,105.45 112.2,105.4 112.16,105.35 112.12,105.3 111.98,105.16 110.77,105.16 110.45,105.48 110.45,106.19 110.45,106.25 110.45,106.56 110.3,106.72 108.44,106.72 108.37,106.79 108.37,106.81 107.75,107.42 107.7,107.46 107.63,107.48 107.53,107.48 107.38,107.48 107.33,107.53 107.33,107.97 107.35,107.99 110.04,107.99 110.54,107.49 114.77,107.49 114.95,107.66
GND on TOP (solid shape): 105.07,113.67 105.07,113.04 105.03,112.96 104.93,112.94 104.87,112.96 104.81,112.97 104.78,112.96 104.72,112.95 104.58,113.1 104.58,113.83 104.11,114.3 102.26,114.3 101.54,113.58 96.91,113.58 96.91,113.71 96.87,113.8 96.78,113.84 96.13,113.84 96.04,113.8 96,113.71 96,113.64 95.92,113.64 95.91,113.66 95.8,113.77 95.66,113.82 95.58,113.89 95.6,113.99 95.67,114.1 95.69,114.23 95.69,114.29 95.98,114.29 96,114.26 96,114.1 96.04,114.01 96.13,113.97 96.33,113.97 96.37,113.98 96.41,114 96.47,114.02 96.53,114.01 96.55,114 96.58,113.99 96.78,113.99 96.85,114.02 96.88,114.1 96.88,114.24 96.92,114.27 99.06,114.27 99.35,113.98 101.35,113.98 101.99,114.62 104.13,114.62
GND on TOP (solid shape): 120.16,99.94 120.16,99.64 120.72,99.08 120.68,99.04 120.65,99 120.62,98.96 120.53,98.91 120.45,98.97 120.31,99.1 120.13,99.15 119.93,99.08 119.8,98.91 119.79,98.9 119.75,98.85 119.68,98.92 119.52,98.92 119.39,99.05 119.21,99.1 119.16,99.09 119.11,99.08 119.02,99.1 118.98,99.18 118.98,99.22 118.94,99.35 118.82,99.42 118.78,99.43 118.78,99.59 118.82,99.62 118.85,99.66 118.93,99.7 119,99.67 119.11,99.6 119.24,99.58 119.5,99.68 119.6,99.93 119.6,99.97 119.59,100.02 119.63,100.06 120.04,100.06
GND on TOP (solid shape): 176.95,30.74 177.01,30.76 177.04,30.71 177.04,30.66 177.01,30.63 176.99,30.59 176.98,30.56 176.92,30.56 176.92,29.06 176.98,29.06 176.99,29.02 177.04,28.96 177.12,28.93 177.91,28.93 178,28.87 177.98,28.76 177.56,28.33 176.39,28.33 175.94,27.88 175.87,27.9 175.83,27.9 175.77,27.9 175.71,27.88 175.62,27.9 175.58,27.98 175.58,28.15 175.62,28.24 175.71,28.25 175.78,28.23 175.85,28.22 176.12,28.33 176.23,28.6 176.22,28.69 176.19,28.78 176.19,28.88 176.28,28.93 176.52,28.93 176.59,28.96 176.64,29.02 176.65,29.06 176.72,29.06 176.72,30.59 176.79,30.67 176.88,30.67
GND on TOP (solid shape): 165.21,29.12 165.27,29.21 165.38,29.19 166.85,27.72 166.85,27.44 166.81,27.42 166.77,27.38 166.73,27.35 166.55,27.54 166.47,27.57 166.44,27.65 166.44,27.66 166.44,27.86 166.42,27.93 166.35,27.98 166.32,27.99 166.32,28.06 164.82,28.06 164.82,27.99 164.78,27.98 164.74,27.96 164.72,27.94 164.66,27.94 164.58,27.85 164.15,27.85 164.14,27.89 164.06,28.04 163.94,28.14 163.88,28.21 163.91,28.3 164.4,28.79 164.55,28.79 164.62,28.76 164.65,28.68 164.65,28.66 165.03,28.28 165.41,28.66 165.36,28.86 165.21,29
GND on TOP (solid shape): 102.26,112.26 102.25,112.24 102.17,112.12 102.14,111.98 102.15,111.9 102.18,111.82 102.17,111.72 102.09,111.67 101.92,111.67 101.04,110.79 97.59,110.79 97.31,110.51 96.89,110.51 96.88,110.52 96.88,110.67 96.85,110.74 96.78,110.77 96.58,110.77 96.55,110.77 96.53,110.75 96.47,110.74 96.41,110.76 96.37,110.79 96.33,110.79 96.13,110.79 96.08,110.78 96.04,110.76 95.97,110.73 95.9,110.75 95.79,110.81 95.67,110.83 95.59,110.82 95.51,110.8 95.41,110.8 95.36,110.89 95.36,111.33 95.39,111.35 95.86,111.35 96,111.22 96,111.05 96.04,110.96 96.13,110.92 96.78,110.92 96.87,110.96 96.91,111.05 96.91,111.22 96.96,111.26 97.04,111.26 97.37,110.93 100.72,110.93 102.12,112.33 102.26,112.33
GND on TOP (solid shape): 112.18,53.2 112.2,53.09 112.11,53.02 110.07,53.02 109.45,52.41 109.37,52.38 109.29,52.44 109.27,52.47 109.25,52.5 109.22,52.57 109.25,52.64 109.31,52.75 109.33,52.87 108.98,53.22 108.62,52.87 108.64,52.75 108.71,52.64 108.73,52.57 108.71,52.5 108.64,52.4 108.62,52.27 108.67,52.09 108.81,51.96 108.87,51.88 108.84,51.79 108.33,51.29 105.87,51.29 105.78,51.35 105.8,51.46 108.22,53.88 111.49,53.88
GND on TOP (solid shape): 164.4,33.26 165.72,33.26 165.8,33.22 165.82,33.13 165.8,33.07 165.8,33.01 165.8,32.25 165.8,32.11 165.82,32.02 165.88,31.94 165.92,31.86 165.88,31.79 165.84,31.74 165.81,31.68 165.78,31.65 165.78,31.1 165.89,30.98 165.9,30.93 165.86,30.9 165.74,30.9 165.47,31.17 165.5,31.2 165.53,31.26 165.54,31.33 165.54,31.61 165.47,31.77 165.31,31.84 165.01,31.84 164.93,31.83 164.86,31.79 164.8,31.76 164.73,31.79 164.61,31.79 164.6,31.83 164.55,31.9 164.47,31.93 164.1,31.93 164.1,32.05 164.47,32.05 164.55,32.08 164.6,32.15 164.6,32.17 164.64,32.21 164.64,32.86 164.12,33.38 164.11,33.43 164.16,33.46 164.2,33.46
GND on TOP (solid shape): 126.45,109.57 126.54,109.52 126.54,109.42 126.5,109.33 126.48,109.23 126.59,108.98 126.84,108.88 127.03,108.93 127.16,109.08 127.24,109.13 127.32,109.11 127.4,109.03 128.48,109.03 128.57,108.97 128.55,108.86 128.2,108.51 127.87,108.51 127.74,108.63 127.57,108.67 127.39,108.62 127.25,108.48 125.88,108.48 125.8,108.53 125.8,108.64 125.83,108.72 125.85,108.81 125.76,109.05 125.54,109.17 125.46,109.24 125.48,109.34 125.71,109.57
GND on TOP (solid shape): 124.01,110.87 124.09,110.82 124.1,110.73 124.08,110.66 124.07,110.6 124.18,110.34 124.43,110.24 124.6,110.28 124.73,110.4 124.81,110.44 124.9,110.4 124.99,110.3 125.12,110.25 125.2,110.18 125.17,110.07 124.6,109.5 124.24,109.5 124.16,109.54 124.14,109.63 124.16,109.7 124.17,109.76 123.79,110.15 123.4,109.76 123.42,109.66 123.46,109.56 123.49,109.52 122.15,108.19 122.1,108.19 122.05,108.22 122.06,108.28 123.21,109.43 123.21,110.5 123.58,110.87
GND on TOP (solid shape): 48.16,17.83 48.2,17.74 48.2,17.65 48.19,17.62 48.06,17.57 48.03,17.48 48.03,17.3 47.86,17.3 47.66,17.1 47.61,17.03 47.6,16.94 47.6,16.71 47.28,16.39 47.06,16.39 46.58,15.91 45.17,15.91 45.11,15.9 45.06,15.86 44.99,15.81 44.91,15.84 44.76,15.99 44.78,16.05 44.78,16.09 44.78,16.37 44.76,16.46 44.7,16.54 44.66,16.62 44.7,16.69 44.76,16.77 44.78,16.87 44.78,17.05 45.31,17.59 45.41,17.59 45.42,17.57 45.55,17.47 45.71,17.43 45.88,17.47 46.02,17.59 46.31,17.59 46.54,17.82 46.62,17.82 46.63,17.8 46.76,17.7 46.92,17.67 47.1,17.71 47.23,17.82 48,17.82 48.03,17.82 48.06,17.83
GND on TOP (solid shape): 106.51,40.02 106.51,38.49 106.45,38.39 106.34,38.41 105.99,38.77 105.3,38.77 105.11,38.67 105.08,38.46 105.09,38.43 105.09,38.39 105.02,38.23 104.86,38.16 104.7,38.23 104.63,38.39 104.64,38.43 104.65,38.46 104.61,38.67 104.43,38.77 103.94,38.77 103.39,38.21 102.64,38.21 102.49,38.37 102.49,39.61 102.48,39.62 102.48,39.76 102.44,39.85 102.35,39.89 102.15,39.89 102.15,39.99 102.19,39.99 102.32,40.02 102.43,40.09 102.47,40.13 102.65,39.94 103.26,39.94 103.5,40.18 103.52,40.18 103.6,40.21 103.64,40.28 103.65,40.32 103.74,40.32 103.75,40.28 103.8,40.21 103.88,40.18 104.53,40.18 104.59,40.2 104.64,40.24 104.65,40.27 104.68,40.27 104.96,40.55 105.98,40.55
GND on TOP (solid shape): 70.62,20.69 70.66,20.64 70.73,20.62 71.1,20.62 71.1,20.47 70.95,20.33 70.9,20.13 70.93,19.99 71.01,19.87 71.02,19.83 71.01,19.8 70.97,19.73 70.95,19.64 70.95,19.34 71.02,19.18 71.18,19.12 71.38,19.12 71.38,18.77 71.35,18.7 71.28,18.67 70.39,18.67 70.31,18.65 70.27,18.58 70.26,18.54 69.93,18.54 69.34,17.95 69.31,17.97 69.22,18.01 69.12,18.02 69.06,18.02 69,18 68.91,18.02 68.87,18.1 68.87,18.5 69.58,19.22 69.58,19.7 69.63,19.79 69.73,19.79 69.81,19.76 69.9,19.75 70.17,19.86 70.28,20.13 70.26,20.25 70.21,20.35 70.19,20.39 70.51,20.71 70.6,20.71
GND on TOP (solid shape): 101.9,44.51 103.76,44.51 104.42,43.85 104.44,43.74 104.35,43.67 101.8,43.67 101.42,44.06 100.25,44.06 99.89,44.41 99.41,44.41 99.34,44.44 99.31,44.52 99.31,44.54 99.29,44.67 99.21,44.79 99.18,44.82 99.55,45.2 99.55,45.51 99.68,45.63 99.73,45.57 99.72,45.51 99.82,45.26 100.07,45.15 100.14,45.12 100.16,45.04 100.16,45.02 100.52,44.66 100.88,45.02 100.78,45.27 100.53,45.38 100.46,45.41 100.44,45.48 100.44,45.51 100.43,45.59 100.4,45.66 100.41,45.76 100.5,45.81 100.61,45.81
GND on TOP (solid shape): 32.18,90.28 32.26,90.25 32.28,90.17 32.28,90.16 32.28,89.96 32.31,89.89 32.41,89.84 32.42,89.8 32.42,88.95 34.18,87.19 34.22,87.19 34.34,87.04 34.53,86.99 34.55,86.99 34.6,86.94 34.53,86.87 34.51,86.87 34.28,86.77 34.17,86.56 34.1,86.47 34,86.5 33.65,86.85 33.64,86.86 33.52,87.07 33.29,87.15 33.25,87.14 33.17,87.13 32.98,87.32 32.98,87.81 32.05,88.73 32.02,88.81 32.06,88.88 32.14,89 32.17,89.14 32.11,89.33 31.96,89.46 31.96,89.8 31.98,89.84 32.08,89.89 32.1,89.96 32.1,90.16 32.1,90.18 32.09,90.22 32.09,90.28
GND on TOP (solid shape): 55.52,106.77 55.57,106.73 55.62,106.72 55.85,106.72 55.94,106.66 55.92,106.55 55.84,106.43 55.81,106.29 55.84,106.14 55.92,106.02 55.95,105.95 55.92,105.88 55.75,105.71 55.75,105.23 55.55,104.89 55.75,104.55 55.75,103.85 55.71,103.84 55.65,103.8 55.62,103.72 55.62,103.68 55.59,103.63 55.54,103.64 55.25,103.92 55.21,103.92 55.21,104.15 55.18,104.24 55.09,104.28 54.53,104.28 54.49,104.28 54.42,104.32 54.4,104.4 54.41,104.45 54.42,104.51 54.38,104.68 54.27,104.81 54.27,105.05 54.77,105.56 54.77,106.72 54.86,106.72 55.24,106.72 55.3,106.73 55.35,106.77
GND on TOP (solid shape): 90.91,125.04 91.1,125.04 91.13,124.97 91.13,124.86 91.04,124.81 90.7,124.81 90.69,124.83 90.22,124.83 90.1,124.7 90.1,124.16 90.11,124.1 90.14,124.04 90.14,124.01 90.13,123.97 90.03,123.84 89.99,123.68 90,123.62 89.99,123.59 89.96,123.56 89.92,123.54 89.88,123.52 89.82,123.48 89.75,123.46 89.69,123.45 89.44,123.2 89.41,123.15 89.38,123.1 89.36,123.08 89.33,123.07 89.29,123.07 89.19,123.07 89.12,123.08 89.08,123.14 89,123.29 88.88,123.39 88.82,123.46 88.85,123.55 89.39,124.09 89.39,124.56 89.93,125.09 90,125.12 90.07,125.08 90.2,124.99 90.36,124.95 90.56,125.01 90.7,125.16 90.79,125.16
GND on TOP (solid shape): 33.59,102.61 34.03,102.17 34.57,102.17 34.67,102.11 34.64,101.99 34.55,101.87 34.52,101.71 34.52,101.65 34.54,101.59 34.52,101.5 34.44,101.46 32.91,101.46 31.82,100.37 31.17,100.37 31.08,100.41 31.07,100.51 31.09,100.57 31.1,100.64 31.08,100.75 31.04,100.85 31.04,101.04 30.82,101.26 30.68,101.26 30.65,101.28 30.65,102.91 30.68,102.93 31.33,102.93 31.33,102.61 31.77,102.17 31.8,102.17 31.8,102.08 31.77,102.07 31.59,101.93 31.52,101.71 31.9,101.33 32.28,101.71 32.25,101.87 32.16,101.99 32.13,102.11 32.23,102.17 32.77,102.17 33.21,102.61 33.21,103.19 33.59,103.19
GND on TOP (solid shape): 100.93,71.93 100.93,71.92 100.96,71.84 101.01,71.77 101.03,71.7 101.01,71.64 100.95,71.55 100.93,71.46 100.92,71.41 100.4,71.41 100.31,71.37 100.29,71.35 100.12,71.28 99.96,71.35 99.94,71.37 99.85,71.41 98.16,71.41 98.1,71.39 98.06,71.39 98.02,71.39 97.96,71.41 97.16,71.41 97.09,71.39 97.05,71.39 97.01,71.39 96.95,71.41 96.83,71.41 96.5,71.08 96.4,71.05 96.33,71.12 96.2,71.29 96,71.36 95.74,71.25 95.64,71 95.65,70.92 95.67,70.85 95.67,70.8 95.63,70.78 94.71,70.78 94.51,70.58 94.43,70.55 94.35,70.61 94.33,70.64 94.32,70.74 94.39,70.8 95.54,71.94 100.85,71.94 100.88,71.98
GND on TOP (solid shape): 187.87,22.68 187.87,20.98 188,20.85 188,20.79 187.94,20.7 187.83,20.72 187.38,21.17 187.35,21.27 187.42,21.34 187.61,21.48 187.69,21.7 187.57,21.97 187.3,22.08 187.17,22.06 187.05,21.99 186.99,21.97 186.92,21.99 186.8,22.06 186.67,22.08 186.52,22.06 186.4,21.97 186.36,21.94 186.23,22.07 186.07,22.07 186.01,22.08 185.96,22.08 185.92,22.08 185.85,22.07 185.76,22.13 185.78,22.24 186.34,22.8 186.4,22.79 186.52,22.82 186.63,22.88 186.69,22.9 186.76,22.88 186.86,22.82 186.98,22.8 187.16,22.85 187.29,22.98 187.57,22.98
GND on TOP (solid shape): 49.85,55.62 49.86,55.57 49.89,55.53 49.94,55.5 50,55.49 50.23,55.44 50.43,55.32 50.46,55.21 50.36,55.14 50.35,55.14 50.28,55.11 50.25,55.04 50.25,53.9 50.25,53.82 50.22,53.75 50.14,53.72 49.96,53.91 49.92,53.92 49.91,53.95 49.5,54.36 49.33,54.43 49.16,54.34 49.07,54.27 48.78,54.31 48.7,54.49 48.74,54.62 48.9,54.78 48.92,54.87 48.92,55.63 49,55.66 49.07,55.63 49.45,55.53 49.69,55.83 49.7,55.88 49.85,55.88
GND on TOP (solid shape): 47.8,103.71 47.8,103.33 48.05,103.07 48.05,102.98 47.93,102.85 47.66,102.85 47.5,102.78 47.44,102.62 47.44,102.34 47.46,102.25 47.52,102.17 47.55,102.09 47.52,102.02 47.46,101.94 47.44,101.84 47.44,101.78 47.36,101.78 47.35,101.79 47.22,101.89 47.06,101.92 46.97,101.91 46.89,101.88 46.8,101.89 46.75,101.98 46.75,101.99 46.15,102.59 46.22,102.66 46.22,102.7 46.24,102.7 46.24,102.82 46.34,102.82 46.34,102.78 46.47,102.54 46.72,102.45 46.99,102.56 47.1,102.83 47.08,102.96 47.01,103.08 46.98,103.15 47.01,103.21 47.08,103.33 47.1,103.47 47.09,103.55 47.07,103.62 47.08,103.72 47.16,103.77 47.36,103.77 47.36,103.8 47.47,103.91 47.6,103.91
GND on TOP (solid shape): 41.38,65.61 41.41,65.53 41.41,65.23 41.55,65.03 41.79,65.06 41.89,65.13 41.96,65.24 41.94,65.33 41.93,65.34 41.93,65.53 41.96,65.59 41.97,65.64 41.98,65.68 42.22,65.68 42.22,65.64 42.23,65.59 42.26,65.53 42.26,65.35 42.2,65.3 42.2,65 42.21,64.97 42.22,64.93 42.23,64.88 42.16,64.71 41.99,64.63 41.97,64.63 41.86,64.65 41.78,64.72 41.76,64.74 41.59,64.81 41.42,64.74 41.41,64.72 41.32,64.65 41.21,64.63 41.19,64.63 41.03,64.71 40.96,64.88 41,65.02 41.1,65.11 41.21,65.16 41.21,65.51 41.22,65.59 41.23,65.64 41.23,65.7 41.38,65.7
GND on TOP (solid shape): 196.61,32.48 196.67,32.45 196.73,32.45 196.76,32.44 196.78,32.41 196.89,32.26 197.05,32.18 197.08,32.16 197.09,32.12 197.1,32.02 197.15,31.94 197.21,31.88 197.21,31.84 197.16,31.79 197.26,31.68 197.29,31.57 197.19,31.51 196.75,31.51 196.71,31.51 196.41,31.51 196.31,31.51 196.25,31.44 196.14,31.34 196.14,31.26 196.1,31.17 196,31.17 195.92,31.19 195.84,31.2 195.78,31.19 195.71,31.18 195.62,31.19 195.58,31.28 195.58,31.49 195.57,31.53 195.54,31.57 195.53,31.61 195.54,31.64 195.57,31.68 195.58,31.73 195.58,31.94 195.57,31.98 195.55,32.01 195.54,32.04 195.55,32.08 195.62,32.19 195.64,32.32 195.64,32.37 195.66,32.45 195.74,32.49 196.6,32.49
GND on TOP (solid shape): 103.58,104.1 103.67,104.07 103.82,103.92 106.81,103.92 106.89,103.83 106.89,101.69 106.86,101.64 106.81,101.65 106.74,101.71 106.57,101.71 106.51,101.74 106.46,101.74 106.16,101.74 106.11,101.74 106.05,101.71 105.37,101.71 105.11,101.98 104.57,101.98 104.19,101.61 104.19,101.39 104.15,101.31 104.07,101.3 104.02,101.3 103.97,101.31 103.93,101.3 103.86,101.29 103.46,101.69 103.36,101.69 103.36,101.77 103.39,101.79 103.49,101.84 103.56,101.91 103.64,101.95 103.72,101.91 103.86,101.8 104.02,101.76 104.41,102.14 104.02,102.53 103.98,102.52 103.91,102.51 103.64,102.78 101.97,102.78 100.95,101.76 100.76,101.76 100.66,101.83 100.68,101.94 102.31,103.57 102.75,103.57 103.07,103.89 103.14,103.87 103.19,103.87 103.37,103.92 103.51,104.05
GND on TOP (solid shape): 41.44,103.73 41.55,103.75 41.62,103.65 41.62,103.46 41.1,102.94 41.1,102.84 41.07,102.82 40.99,102.74 40.96,102.63 40.96,102.32 40.97,102.26 41,102.2 41.01,102.18 41.01,101.95 40.96,101.85 40.95,101.74 41.06,101.47 41.33,101.36 41.49,101.39 41.63,101.5 41.69,101.54 41.76,101.52 41.86,101.47 41.97,101.46 42.05,101.47 42.12,101.49 42.22,101.48 42.26,101.4 42.26,100.65 41.81,100.2 41.73,100.17 41.66,100.2 41.65,100.21 41.62,100.28 41.65,100.34 41.72,100.46 41.74,100.6 41.63,100.87 41.36,100.98 41.22,100.95 41.1,100.87 41.03,100.84 40.96,100.87 40.56,101.27 39.01,101.27 39.01,101.4 40.3,101.4 40.74,101.83 40.74,103.02
GND on TOP (solid shape): 91.68,44.81 91.72,44.89 91.81,44.91 91.86,44.9 91.91,44.89 91.94,44.89 92.01,44.87 92.05,44.79 92.05,44.75 92.09,44.66 92.11,44.64 92.16,44.57 92.19,44.48 92.19,44.41 92.75,43.86 92.73,43.82 92.69,43.74 92.68,43.64 92.78,43.39 93.03,43.29 93.23,43.35 93.36,43.5 93.43,43.56 93.52,43.53 93.78,43.28 93.74,43.24 93.66,43.13 93.64,42.99 93.65,42.9 93.41,42.66 93.34,42.63 93.27,42.66 93.15,42.74 93.01,42.77 92.93,42.76 92.85,42.73 92.75,42.73 92.7,42.82 92.7,43.2 92.35,43.55 92.36,43.61 92.36,43.64 92.25,43.9 92,44 91.91,43.99 91.83,43.96 91.73,43.96 91.68,44.05
GND on TOP (solid shape): 131.34,36.85 131.37,36.83 131.4,36.83 131.53,36.83 131.53,36.78 131.95,36.36 133.13,36.36 133.22,36.31 133.23,36.22 133.2,36.13 131.74,36.13 131.27,35.65 131.27,34.98 131.56,34.68 131.56,34.12 131.5,34.02 131.39,34.04 131.27,34.12 131.13,34.15 130.86,34.04 130.74,33.77 130.75,33.72 130.76,33.65 130.71,33.61 130.58,33.61 130.58,34.04 130.54,34.13 130.45,34.17 129.47,34.17 128.93,34.71 128.91,34.82 129,34.89 129.32,34.89 129.84,35.41 129.94,35.43 130.01,35.35 130.14,35.13 130.39,35.04 130.66,35.15 130.77,35.42 130.68,35.66 130.45,35.79 130.37,35.86 130.4,35.97 131.3,36.87
GND on TOP (solid shape): 151.81,55.69 151.89,55.63 152.24,54.91 152.24,54.69 152.2,54.61 152.1,54.6 152.04,54.61 151.71,54.51 151.6,54.24 151.6,54.2 151.61,54.17 151.59,54.08 151.22,54.04 151.12,54.02 151.05,53.96 150.97,53.93 150.89,53.96 150.87,53.99 150.83,54.01 150.81,54.03 150.81,54.27 150.83,54.28 150.92,54.36 150.95,54.48 150.95,54.78 150.88,54.94 150.72,55 150.44,55 150.34,54.98 150.26,54.91 150.07,54.91 149.97,54.97 149.99,55.09 150.06,55.15 150.59,55.15 150.68,55.18 150.72,55.27 150.72,55.5 150.75,55.57 150.82,55.6 151.24,55.6 151.34,55.55 151.45,55.54 151.6,55.57 151.72,55.65
GND on TOP (solid shape): 168.46,23.8 168.53,23.9 168.64,23.88 171.04,21.47 171.06,21.36 170.97,21.3 170.5,21.3 169.17,19.97 168.5,19.97 168.45,20 168.46,20.05 168.53,20.12 168.6,20.1 168.64,20.1 169.02,20.48 168.64,20.87 168.49,20.83 168.37,20.75 168.3,20.72 168.23,20.74 168.15,20.79 168.06,20.82 167.98,20.89 168.01,20.99 168.46,21.45 168.46,21.5 168.54,21.5 168.56,21.48 168.69,21.36 168.86,21.32 169.25,21.7 168.86,22.08 168.74,22.06 168.63,22 168.52,21.99 168.46,22.08
GND on TOP (solid shape): 161.95,21.11 161.99,21.08 162.05,21.06 162.43,21.06 162.48,21.07 162.52,21.1 162.56,21.11 162.59,21.1 162.79,20.9 162.88,20.9 162.89,20.86 162.97,20.75 163.11,20.71 163.41,20.71 163.54,20.75 163.62,20.86 163.63,20.9 163.85,20.9 163.85,20.9 163.95,20.93 164.02,20.86 164.16,20.66 164.39,20.58 164.47,20.59 164.55,20.62 164.64,20.61 164.69,20.53 164.69,20.44 164.66,20.37 164.59,20.33 164.18,20.33 163.79,19.95 162.66,19.95 162.62,19.99 162.56,20 162.18,20 162.12,19.99 162.08,19.95 161.9,19.95 161.88,19.97 161.86,19.99 161.81,20.05 161.81,20.12 161.85,20.21 161.86,20.31 161.81,20.49 161.68,20.63 161.66,20.66 161.66,20.69 161.67,20.72 161.67,20.74 161.67,20.94 161.66,20.98 161.68,21.07 161.76,21.11
GND on TOP (solid shape): 194.95,31.97 194.94,31.94 194.94,31.73 194.95,31.68 194.98,31.64 194.99,31.61 194.98,31.57 194.95,31.53 194.94,31.49 194.94,31.28 194.97,31.2 195.04,31.16 195.08,31.15 195.08,31.05 195.04,31.04 194.97,31 194.94,30.92 194.94,30.27 194.97,30.19 195.04,30.14 195.08,30.13 195.08,29.44 194.75,29.44 194.75,29.56 194.72,29.66 194.65,29.73 194.5,29.96 194.65,30.19 194.7,30.21 194.75,30.3 194.75,30.49 194.66,30.59 194.6,30.59 194.51,30.62 194.45,30.67 194.39,30.71 194.32,30.72 194.21,30.72 194.18,30.72 193.8,30.72 193.77,30.72 193.05,30.72 193.03,30.71 192.83,30.61 192.73,30.41 192.72,30.4 192.59,30.26 192.59,30.03 192.56,29.99 192.5,29.98 192.47,30.03 192.47,31.05 192.64,31.05 192.66,31.05 192.69,31.06 193.12,31.06 193.34,31.29 193.34,31.88 193.48,32.01 193.6,32.01 193.7,31.99 194.86,31.99 194.89,32.02
GND on TOP (solid shape): 40.98,104.44 41.02,104.41 41.01,104.36 39.99,103.33 39.99,102.15 38.7,102.15 38.26,101.71 38.26,100.96 38.7,100.52 40.25,100.52 40.28,100.48 40.28,98.8 40.23,98.74 40.03,98.74 39.99,98.79 39.99,99.79 39.53,100.25 38.56,100.25 38.1,99.79 38.1,98.78 38.05,98.73 37.73,98.73 37.71,98.75 37.71,99.23 37.24,99.69 36.68,99.69 36.68,99.81 36.7,99.88 37.02,100.03 37.12,100.29 37.01,100.56 36.74,100.67 36.61,100.65 36.49,100.58 36.42,100.55 36.36,100.58 36.24,100.65 36.1,100.67 36.1,100.67 36,100.73 36.02,100.85 36.83,101.65 36.93,101.68 37,101.61 37.14,101.41 37.36,101.33 37.63,101.44 37.75,101.71 37.64,101.97 37.39,102.09 37.37,102.1 37.32,102.14 37.41,102.23 38.63,102.23 40.84,104.44
GND on TOP (solid shape): 24.6,15.47 24.6,15.2 24.66,15.04 24.82,14.98 25.1,14.98 25.17,14.98 25.22,15.01 25.24,15.02 25.56,15.02 25.64,14.98 25.66,14.89 25.65,14.85 25.65,14.75 25.36,14.46 25.36,14.13 25.25,14 25.21,13.83 25.23,13.69 25.31,13.57 25.34,13.49 25.3,13.42 25.24,13.36 25.2,13.29 25.18,13.26 25.13,13.26 25.12,13.27 25.05,13.3 24.98,13.32 24.37,13.32 24.37,13.92 24.38,13.93 24.41,13.99 24.42,14.06 24.42,14.36 24.36,14.52 24.2,14.59 23.92,14.59 23.81,14.56 23.73,14.49 23.61,14.49 23.52,14.53 23.51,14.63 23.53,14.68 23.53,14.74 23.44,14.99 23.2,15.1 23.18,15.1 23.17,15.11 23.07,15.11 23.07,15.19 23.1,15.21 23.23,15.34 23.28,15.53 23.28,15.57 23.3,15.65 23.38,15.68 23.63,15.68 23.76,15.81 24.25,15.81
GND on TOP (solid shape): 143.6,49.63 143.62,49.57 143.65,49.53 143.65,49.4 143.62,49.36 143.6,49.3 143.6,48.92 143.62,48.86 143.65,48.82 143.65,48.42 143.9,48.17 143.9,45.02 143.84,44.92 143.73,44.95 143.48,45.19 143.48,45.39 141.56,47.32 141.47,47.38 141.38,47.42 141.36,47.43 141.1,47.69 141.1,48.29 141.16,48.38 141.27,48.36 141.39,48.27 141.54,48.25 141.81,48.36 141.92,48.63 141.9,48.76 141.83,48.88 141.83,49.22 142.67,49.22 142.67,48.9 142.59,48.78 142.56,48.63 142.94,48.25 143.32,48.63 143.25,48.85 143.06,48.99 143.03,49 143.03,49.22 143.26,49.22 143.35,49.26 143.39,49.35 143.39,49.97 143.47,50.05 143.6,50.05
GND on TOP (solid shape): 143.77,94.54 143.86,94.5 143.9,94.42 143.9,94.35 144.14,94.11 144.44,94.11 144.55,94.22 144.56,94.25 144.66,94.38 144.8,94.43 144.88,94.41 144.94,94.38 144.98,94.36 145.51,94.36 145.54,94.33 145.66,94.33 145.73,94.31 145.76,94.24 145.76,93.95 145.74,93.91 145.71,93.87 145.32,93.87 145.23,93.84 145.19,93.75 145.19,93.69 145.1,93.61 144.94,93.74 144.78,93.78 144.51,93.66 144.4,93.39 144.43,93.24 144.52,93.12 144.55,93.04 144.52,92.97 144.38,92.83 144.31,92.8 144.23,92.83 144.12,92.91 143.99,92.95 143.96,92.97 143.95,93 143.94,93.05 143.92,93.1 143.73,93.29 143.73,93.5 143.57,93.66 143.57,93.78 143.55,93.86 143.49,93.93 143.46,93.96 143.44,94 143.45,94.03 143.45,94.41 143.44,94.44 143.49,94.51 143.57,94.54
GND on TOP (solid shape): 186.77,20.62 186.86,20.56 186.84,20.45 186.76,20.33 186.73,20.18 186.73,19.68 186.63,19.58 186.63,19.48 186.58,19.39 186.48,19.39 186.43,19.41 186.38,19.41 186.09,19.41 185.99,19.39 185.91,19.32 185.56,19.32 185.48,19.39 185.38,19.41 185.08,19.41 184.98,19.39 184.9,19.32 184.7,19.32 184.21,19.81 183.91,19.81 183.87,19.85 183.84,19.93 183.87,20 183.93,20.08 183.95,20.17 183.95,20.24 184.13,20.42 184.65,20.42 184.73,20.38 184.74,20.28 184.73,20.22 184.72,20.15 184.83,19.88 185.1,19.77 185.26,19.81 185.39,19.9 185.46,19.94 185.54,19.9 185.67,19.81 185.82,19.77 186.09,19.88 186.21,20.15 186.17,20.31 186.07,20.44 186.04,20.56 186.14,20.62
GND on TOP (solid shape): outline of 141 points within 130.1,92.33 134.74,96.37
GND on TOP (solid shape): 86.58,47.71 86.67,47.67 86.68,47.57 86.66,47.51 86.65,47.44 86.76,47.19 87.01,47.09 87.18,47.13 87.31,47.25 87.38,47.29 87.46,47.26 87.67,47.06 87.66,46.98 87.67,46.92 87.69,46.87 87.68,46.78 87.6,46.73 87.45,46.58 86.79,46.58 86.24,46.03 86.24,45.59 86.2,45.51 86.11,45.49 86.06,45.51 86,45.51 85.85,45.48 85.72,45.38 85.61,45.35 85.54,45.44 85.54,46.47 85.61,46.56 85.72,46.53 85.85,46.44 86,46.4 86.25,46.5 86.35,46.76 86.32,46.91 86.23,47.03 86.2,47.11 86.24,47.19 86.36,47.32 86.4,47.48 86.39,47.53 86.38,47.58 86.4,47.67 86.48,47.71
GND on TOP (solid shape): 90.66,118.12 90.74,118.08 90.76,117.99 90.74,117.93 90.74,117.87 90.85,117.6 91.12,117.49 91.25,117.51 91.37,117.58 91.44,117.6 91.51,117.58 91.62,117.51 91.76,117.49 91.82,117.49 91.88,117.51 91.97,117.49 92.01,117.41 92.01,115.33 92.24,115.1 92.24,112.85 92.18,112.76 92.08,112.77 91.97,112.83 91.85,112.84 91.84,112.84 91.76,112.87 91.73,112.95 91.73,114.96 91.73,115.02 91.72,115.02 91.7,115.04 91.66,115.07 91.6,115.09 90.72,115.09 90.69,115.08 90.66,115.07 90.56,115.08 90.51,115.16 90.51,116.01 90.42,116.1 90.42,116.19 90.39,116.28 90.3,116.32 89.66,116.32 89.47,116.52 89.47,117.11 89.49,117.18 89.55,117.21 89.77,117.35 89.85,117.59 89.74,117.86 89.47,117.97 89.43,117.97 89.39,117.96 89.33,118.02 89.44,118.12
GND on TOP (solid shape): 56.02,99.73 57.05,99.73 57.07,99.7 57.09,99.67 57.08,99.63 57.05,99.6 57.05,99.56 57.05,99.35 57.08,99.28 57.15,99.25 57.53,99.25 57.57,99.26 57.61,99.29 57.62,99.3 57.94,99.3 57.98,99.34 58.03,99.29 58.03,99.27 58.06,99.2 58.13,99.17 58.36,99.17 58.79,98.74 59.17,98.74 59.2,98.71 59.22,98.6 59.13,98.54 59.12,98.54 58.88,98.46 58.75,98.25 58.74,98.21 58.05,98.21 57.97,98.25 57.95,98.34 57.97,98.4 57.97,98.47 57.59,98.85 57.21,98.47 57.22,98.4 57.23,98.34 57.22,98.25 57.14,98.21 57.11,98.21 57.03,98.25 57.02,98.34 57.03,98.4 57.03,98.46 56.92,98.73 56.65,98.84 56.61,98.84 56.54,98.83 54.84,100.52 54.82,100.63 54.92,100.7 54.97,100.7 55.04,100.71
GND on TOP (solid shape): 26.66,27.52 26.66,27.1 26.7,27.01 26.79,26.97 27.44,26.97 27.47,26.98 27.49,26.98 27.56,26.97 27.55,26.9 27.47,26.78 27.44,26.64 27.41,26.58 27.08,26.43 26.97,26.16 26.97,26.12 26.99,26.05 26.68,25.75 26.68,24.82 26.62,24.73 26.5,24.76 26.38,24.85 26.22,24.88 26.09,24.85 25.97,24.78 25.91,24.76 25.84,24.78 25.72,24.85 25.59,24.88 25.32,24.77 25.21,24.5 25.21,24.49 25.15,24.39 25.03,24.41 24.67,24.78 24.66,24.79 24.52,24.95 24.32,25.01 24.12,24.95 23.98,24.8 23.39,24.8 23.34,24.87 23.28,24.93 23.24,25.02 23.3,25.1 23.32,25.11 25,25.11 25.2,25.31 25.2,26.87 25.11,26.96 25.13,27 25.17,27.06 25.19,27.14 25.19,27.33 25.41,27.56 26.62,27.56
GND on TOP (solid shape): 86.4,57.54 86.43,57.62 86.51,57.65 86.53,57.65 86.87,57.65 86.87,57.45 86.84,57.43 86.8,57.38 86.78,57.31 86.78,57.23 86.82,57.13 86.93,57.08 87.03,57.08 87.1,57.1 87.23,57.21 87.34,57.24 87.56,57.01 87.34,56.78 87.25,56.8 87.14,56.87 87.08,56.88 86.53,56.88 86.47,56.86 86.42,56.82 86.35,56.79 86.27,56.81 86.18,56.86 86.07,56.88 85.89,56.83 85.76,56.69 85.68,56.63 85.59,56.67 85.48,56.76 85.33,56.8 85.28,56.79 85.23,56.78 85.2,56.77 85.14,56.83 85.18,56.87 85.18,57.11 85.22,57.19 85.31,57.21 85.36,57.2 85.41,57.2 85.55,57.23 85.66,57.31 85.74,57.35 85.82,57.32 85.93,57.23 86.07,57.2 86.3,57.3 86.4,57.53
GND on TOP (solid shape): 139.58,114.49 139.67,114.44 139.68,114.34 139.65,114.26 139.64,114.18 139.75,113.91 140.02,113.8 140.03,113.8 140.1,113.77 140.13,113.7 140.13,113.62 140.84,112.91 140.87,112.83 140.82,112.75 140.74,112.69 140.68,112.61 140.59,112.56 140.5,112.62 140.36,112.78 140.16,112.83 140.01,112.81 139.89,112.72 139.81,112.69 139.74,112.72 139.62,112.81 139.47,112.83 139.2,112.72 139.09,112.45 139.09,112.42 139.1,112.35 139.01,112.26 137.31,112.26 137.23,112.3 137.21,112.39 137.23,112.45 137.23,112.51 137.21,112.63 137.16,112.74 137.15,112.84 137.24,112.9 138.12,112.9 139.04,113.81 139.1,113.8 139.14,113.8 139.41,113.91 139.52,114.18 139.51,114.27 139.48,114.34 139.49,114.44 139.58,114.49
GND on TOP (solid shape): 66.19,17.42 66.22,17.42 67.19,17.42 67.19,17 67.15,16.99 67.04,16.91 67,16.77 67,16.47 67,16.43 67.01,16.38 67.01,16.29 66.92,16.24 66.56,16.24 66.42,16.1 66.42,15.97 66.44,15.93 66.46,15.89 66.47,15.84 66.46,15.79 66.46,15.73 66.57,15.46 66.84,15.35 66.88,15.35 67.37,15.35 67.45,15.31 67.47,15.23 67.46,15.2 67.46,15 67.47,14.96 67.45,14.87 67.37,14.83 67.1,14.83 66.79,14.52 63.72,14.52 63.63,14.57 63.63,14.67 63.65,14.7 63.78,14.7 63.82,14.66 63.88,14.64 64.26,14.64 64.32,14.66 64.36,14.7 64.54,14.7 64.58,14.66 64.64,14.64 65.02,14.64 65.08,14.66 65.12,14.7 65.19,14.7 65.27,14.78 65.34,14.81 65.42,14.78 65.49,14.74 65.57,14.72 65.85,14.72 66.01,14.79 66.08,14.95 66.08,15.25 66.04,15.38 65.92,15.46 65.89,15.48 65.89,15.69 65.84,15.74 65.84,16.07 65.87,16.09 65.91,16.12 65.94,16.17 65.95,16.2 66.01,16.2 66.01,17.14 65.95,17.14 65.92,17.22 66.14,17.44
GND on TOP (solid shape): 116.18,50.3 116.27,50.28 117.31,49.24 118.52,49.24 118.86,49.04 119.2,49.24 121.44,49.24 121.56,49.13 121.73,49.09 121.81,49.1 121.9,49.13 122,49.13 122.04,49.04 122.04,48.66 122,48.58 121.9,48.57 121.83,48.59 121.75,48.6 121.58,48.55 121.45,48.42 118.77,48.42 118.48,48.71 116.29,48.71 116.21,48.75 116.2,48.84 116.2,48.88 116.2,49.08 116.19,49.14 116.14,49.19 116.12,49.21 116.12,49.4 116.12,49.44 115.76,49.79 115.4,49.44 115.41,49.39 115.42,49.34 115.4,49.25 115.32,49.21 114.93,49.21 114.88,49.19 114.83,49.16 114.53,49.16 113.64,50.05 113.61,50.16 113.71,50.23 115.42,50.23 115.56,50.08 115.76,50.02 115.97,50.08 116.11,50.25
GND on TOP (solid shape): 207.11,14.03 207.14,14 207.2,13.83 207.14,13.66 207.11,13.63 207.11,13.14 207.14,13.11 207.18,13.03 207.2,12.94 207.16,12.8 207.05,12.71 207.02,12.7 206.98,12.65 206.95,12.62 206.91,12.6 206.88,12.59 206.46,12.18 206.04,12.18 205.95,12.24 205.97,12.35 206.14,12.51 206.14,12.52 206.17,12.57 206.19,12.62 206.19,13 206.15,13.09 206.06,13.13 205.82,13.14 205.68,13.42 205.42,13.52 205.31,13.51 205.21,13.46 205.17,13.44 205.07,13.54 205.12,13.65 205.72,13.65 205.73,13.61 205.78,13.54 205.86,13.51 206.06,13.51 206.15,13.55 206.19,13.64 206.19,14.02 206.15,14.11 206.06,14.15 205.86,14.15 205.78,14.12 205.73,14.05 205.72,14.01 205.12,14.01 205.11,14.05 205.07,14.12 204.99,14.15 204.79,14.15 204.79,14.4 204.99,14.4 205.07,14.43 205.11,14.5 205.12,14.54 205.72,14.54 205.73,14.5 205.78,14.43 205.86,14.4 206.06,14.4 206.15,14.44 206.19,14.53 206.19,14.91 206.18,14.94 206.2,15.02 206.28,15.06 207.11,15.06
GND on TOP (solid shape): 115.33,39.76 115.46,39.64 115.63,39.59 115.67,39.6 115.75,39.57 115.78,39.5 115.78,38.7 116.17,38.31 116.91,38.31 116.98,38.25 117,38.14 116.91,38.07 116.81,38.07 116.72,38.04 116.69,37.95 116.69,37.24 116.71,37.16 116.78,37.11 116.82,37.1 116.82,36.85 116.78,36.81 116.77,36.75 116.77,36.43 116.7,36.36 116.34,36.36 116.01,36.69 116.01,36.71 115.97,36.84 115.85,36.93 115.82,36.94 115.82,37.26 115.48,37.6 115.48,37.71 115.41,37.87 115.25,37.94 114.95,37.94 114.82,37.89 114.73,37.78 114.72,37.75 114.66,37.75 114.57,37.66 114.51,37.72 114.51,37.98 114.63,38.12 114.67,38.29 114.56,38.56 114.29,38.67 114.24,38.67 114.19,38.66 114.12,38.67 114.07,38.72 114.04,38.79 113.99,38.85 113.97,38.89 113.99,38.92 114,38.94 114.04,38.96 114.08,38.94 114.12,38.92 114.16,38.91 114.37,38.91 114.46,38.95 114.49,39.04 114.49,39.42 114.48,39.48 114.44,39.52 114.44,39.67 114.82,39.67 114.88,39.69 114.93,39.74 114.94,39.76
GND on TOP (solid shape): 136.7,94.6 136.7,93.97 136.75,93.91 136.78,93.81 136.71,93.74 136.57,93.68 136.48,93.57 136.38,93.52 136.3,93.57 136.16,93.73 135.95,93.79 135.57,93.41 135.95,93.03 136.14,93.08 136.28,93.21 136.37,93.26 136.46,93.21 136.51,93.13 136.57,93.07 136.61,92.99 136.57,92.91 136.44,92.77 136.4,92.59 136.41,92.5 136.45,92.4 136.45,92.3 136.36,92.25 135.6,92.25 135.51,92.3 135.51,92.4 135.55,92.5 135.56,92.59 135.45,92.86 135.18,92.98 135.14,92.99 135.13,93.03 135.13,93.94 135.03,94.04 135.08,94.1 135.13,94.09 135.4,94.2 135.52,94.47 135.51,94.54 135.49,94.6 135.5,94.7 135.59,94.74 136.56,94.74
GND on TOP (solid shape): outline of 103 points within 18.37,14.08 21.4,17.09
GND on TOP (solid shape): 147.29,108.97 147.28,108.93 147.26,108.9 146.87,108.51 146.84,108.49 146.8,108.48 146.71,108.48 146.63,108.46 146.57,108.42 146.55,108.39 146.52,108.37 146.45,108.3 146.42,108.21 146.41,108.18 146.37,108.17 146.11,108.05 145.99,107.79 145.98,107.75 145.95,107.74 145.86,107.71 145.79,107.64 145.76,107.6 145.69,107.54 145.66,107.51 145.58,107.47 145.5,107.51 145.47,107.54 145.4,107.6 145.37,107.64 145.3,107.71 145.21,107.74 145.17,107.75 145.16,107.79 145.11,107.97 144.98,108.1 144.93,108.19 144.98,108.28 145.11,108.41 145.16,108.6 145.11,108.79 144.97,108.93 144.95,108.95 144.94,108.99 144.94,109.08 144.9,109.16 144.81,109.24 144.58,109.24 144.58,109.44 144.96,109.44 144.96,109.38 145.51,108.84 145.58,108.84 145.7,108.81 145.79,108.72 145.98,108.62 146.17,108.72 146.26,108.81 146.38,108.84 146.47,108.82 146.55,108.77 146.7,108.72 146.86,108.78 147.09,109.01 147.09,109.54 147.29,109.54
GND on TOP (solid shape): 185.21,24.37 185.22,24.32 185.25,24.28 185.26,24.24 185.25,24.21 185.22,24.17 185.21,24.12 185.21,23.92 185.25,23.83 185.34,23.79 185.72,23.79 185.78,23.8 185.83,23.84 186.01,23.84 186.17,23.68 187.43,23.68 187.44,23.64 187.46,23.6 187.49,23.57 187.49,23.33 187.29,23.33 187.16,23.46 186.98,23.51 186.86,23.49 186.75,23.43 186.69,23.4 186.62,23.43 186.52,23.49 186.4,23.51 186.26,23.48 186.15,23.4 186.08,23.37 186.02,23.39 185.92,23.44 185.81,23.46 185.7,23.44 185.6,23.39 185.57,23.38 185.54,23.39 185.5,23.41 185.45,23.42 184.8,23.42 184.71,23.38 184.67,23.29 184.67,22.85 184.34,22.85 184.07,22.58 183.99,22.55 183.92,22.59 183.83,22.67 183.73,22.7 183.43,22.7 183.29,22.65 183.21,22.54 183.2,22.51 182.85,22.51 182.75,22.57 182.77,22.68 182.85,22.75 182.86,22.76 183.01,22.9 183.07,23.1 183.05,23.23 182.98,23.34 182.95,23.38 183.44,23.87 183.71,23.87 183.87,23.93 183.94,24.09 183.94,24.36 184.15,24.57 185.21,24.57
GND on TOP (solid shape): 94.76,31.05 94.84,31.03 94.87,30.95 94.87,30.83 95.11,30.59 96.02,30.59 96.21,30.4 96.31,30.38 96.35,30.39 96.39,30.4 96.44,30.4 96.96,30.4 97.08,30.38 97.19,30.31 97.31,30.18 97.38,30.08 97.41,29.96 97.31,29.73 97.09,29.64 97,29.65 96.91,29.7 96.75,29.74 96.61,29.66 96.46,29.51 96.44,29.51 96.36,29.47 96.32,29.39 96.32,29.01 96.33,28.98 96.33,28.82 95.99,28.82 95.74,28.57 95.66,28.54 95.58,28.58 95.57,28.6 95.55,28.64 95.57,28.67 95.6,28.71 95.6,28.76 95.6,28.93 95.81,29.14 95.82,29.14 95.95,29.27 96,29.45 95.98,29.55 95.94,29.64 95.93,29.71 95.96,29.77 96.01,29.85 96.03,29.93 96.03,30.24 95.96,30.4 95.8,30.46 95.52,30.46 95.36,30.4 95.29,30.24 95.29,29.93 95.29,29.9 95.26,29.81 95.16,29.79 95.11,29.8 95.06,29.81 94.94,29.79 94.84,29.73 94.73,29.72 94.67,29.81 94.67,31 94.69,31.03 94.72,31.05
GND on TOP (solid shape): 34.59,90.22 34.57,90.18 34.57,90.16 34.57,89.96 34.57,89.92 34.59,89.89 34.62,89.82 34.59,89.76 34.53,89.65 34.5,89.52 34.61,89.27 34.86,89.16 35.03,89.21 35.16,89.32 35.24,89.37 35.33,89.32 35.45,89.21 35.62,89.16 35.87,89.27 35.98,89.52 35.96,89.65 35.89,89.76 35.86,89.82 35.89,89.89 35.91,89.92 35.91,89.96 35.91,90.16 35.91,90.18 35.9,90.22 35.9,90.28 35.99,90.28 36.07,90.25 36.09,90.17 36.09,90.16 36.09,89.96 36.12,89.89 36.22,89.84 36.23,89.8 36.23,88.82 36.8,88.26 36.8,86.42 37.05,86.16 37.05,86.09 37,86.04 36.91,86.05 36.84,86.07 36.8,86.14 36.73,86.3 36.58,86.38 36.52,86.42 36.5,86.48 36.5,86.49 36.44,86.68 36.3,86.81 36.3,87.31 34.25,89.36 34.25,89.8 34.26,89.84 34.36,89.89 34.39,89.96 34.39,90.16 34.39,90.17 34.42,90.25 34.49,90.28 34.59,90.28
GND on TOP (solid shape): 11.83,114.08 13.63,114.08 14.52,113.19 16.09,113.19 16.16,113.12 16.16,111.29 16.52,110.93 17.84,110.93 17.92,110.87 17.9,110.76 17.84,110.7 17.84,108.29 13.19,103.64 11.74,103.64 11.73,103.66 11.63,103.76 11.51,103.83 11.36,103.88 11.2,103.9 7.3,103.9 7.3,104.4 7.1,104.9 6.6,105.1 5.2,105.1 4.7,104.9 4.5,104.4 4.5,103.9 0.71,103.9 0.5,104.11 0.5,105.19 0.51,105.2 2.1,105.2 2.1,111.2 0.51,111.2 0.5,111.21 0.5,112.59 0.71,112.8 3.3,112.8 3.6,112.58 3.97,112.5 5.93,112.5 6.3,112.58 6.6,112.8 6.62,112.82 7.29,112.83 7.3,112.81 8.47,112.51 8.89,113.64 8.9,113.73 8.98,113.78 9.86,113.78 10.33,113.97 10.53,114.45 10.46,114.75 10.26,114.99 10.22,115.11 10.32,115.17 10.73,115.17
GND on TOP (solid shape): 113.68,51.19 116.1,51.19 116.79,50.5 116.78,50.44 116.77,50.38 116.72,50.33 115.99,51.07 113.63,51.07 112.18,52.52 110.28,52.52 108.47,50.71 105.73,50.71 102.71,47.69 100.6,47.69 100.24,47.33 99.34,47.33 99.29,47.39 99.29,47.45 99.3,47.48 98.69,47.73 98.94,47.12 98.97,47.13 99.03,47.14 99.2,46.97 100.39,46.97 100.75,47.33 102.85,47.33 105.88,50.35 108.62,50.35 109.26,51 109.36,51.03 109.43,50.96 109.46,50.91 109.49,50.86 109.52,50.79 109.49,50.73 109.43,50.62 109.41,50.49 109.42,50.41 109.45,50.33 109.45,50.23 109.36,50.18 105.88,50.18 102.91,47.21 100.8,47.21 100.44,46.85 98.67,46.85 98.08,46.26 97.47,46.26 97.47,46.31 97.36,46.55 97.12,46.65 97.06,46.64 97,46.63 96.91,46.64 96.86,46.72 96.86,47.19 96.91,47.23 96.96,47.28 97.04,47.32 97.12,47.27 97.25,47.15 97.42,47.11 97.67,47.21 97.78,47.47 97.76,47.56 97.73,47.65 97.73,47.75 97.81,47.8 98.18,47.8 98.82,48.44 103.28,48.44 105.75,50.91 108.49,50.91 110.23,52.64 112.23,52.64
GND on TOP (solid shape): 133.09,108.86 133.18,108.81 133.19,108.72 133.16,108.64 133.16,108.57 133.27,108.3 133.54,108.19 133.72,108.24 133.86,108.37 133.95,108.42 134.03,108.37 134.17,108.24 134.35,108.2 134.62,108.31 134.74,108.58 134.73,108.65 134.71,108.72 134.72,108.81 134.8,108.86 135.53,108.86 135.61,108.81 135.62,108.72 135.6,108.65 135.6,108.58 135.71,108.31 135.98,108.2 136.16,108.24 136.29,108.36 136.38,108.41 136.46,108.36 136.51,108.31 136.56,108.26 136.61,108.18 136.56,108.1 136.44,107.96 136.4,107.78 136.4,107.72 136.42,107.65 136.41,107.56 136.32,107.52 132.57,107.52 132.04,106.99 132.02,106.99 131.81,107.19 131.45,107.19 131.12,106.85 131.12,106.51 131.74,105.9 131.74,105.85 131.68,105.79 131.66,105.79 131.03,106.43 130.69,106.43 130.4,106.13 130.4,105.8 131.07,105.13 131.07,105.11 131,105.04 130.98,105.04 130.31,105.71 129.97,105.71 129.68,105.42 129.68,105.08 130.29,104.47 130.29,104.42 130.23,104.37 130.21,104.37 129.59,104.99 129.25,104.99 128.58,104.32 128.48,104.32 128.44,104.35 128.45,104.4 132.9,108.86
GND on TOP (solid shape): 30.04,14.34 29.28,13.59 29.28,13.34 29.24,13.25 29.14,13.25 29.07,13.27 28.99,13.28 28.72,13.17 28.61,12.9 28.64,12.76 28.71,12.64 28.73,12.58 28.71,12.51 28.64,12.39 28.61,12.26 28.72,11.99 28.99,11.88 29.07,11.89 29.14,11.91 29.24,11.9 29.28,11.82 29.28,10.79 28.82,10.32 23.36,10.32 22.34,9.31 20.94,9.31 20.07,8.43 17.39,8.43 15.23,10.6 15.23,11.41 14.98,11.66 14.98,11.72 15.05,11.82 15.16,11.79 15.27,11.7 15.41,11.67 15.48,11.64 15.51,11.57 15.51,11.23 15.54,11.15 15.61,11.12 15.81,11.12 15.85,11.13 15.88,11.15 15.92,11.17 15.96,11.15 15.98,11.12 15.98,10.99 16.11,10.86 16.11,9.92 17.48,8.56 19.58,8.56 20.73,9.71 22.52,9.71 23.59,10.77 26.64,10.77 28.17,12.29 28.17,13.11 28.43,13.37 28.43,14.34 28.54,14.34 28.61,14.31 28.64,14.23 28.64,14.21 29.02,13.83 29.4,14.21 29.4,14.23 29.43,14.31 29.5,14.34 29.8,14.34 29.88,14.36 29.96,14.4 29.97,14.41 30.04,14.41
GND on TOP (solid shape): 112.7,16.95 112.76,17.05 112.87,17.03 112.96,16.93 112.96,16.29 113.73,15.52 113.75,15.42 113.68,15.35 113.44,15.22 113.35,14.97 113.35,14.92 113.12,14.69 108.61,14.69 107.95,15.36 107.47,15.84 107.44,15.93 107.5,16.01 107.57,16.04 107.63,16.09 107.69,16.11 107.76,16.09 107.87,16.01 108.01,15.99 108.06,15.99 108.13,16 108.19,15.94 108.57,15.94 108.58,15.9 108.62,15.83 108.7,15.8 109.07,15.8 109.07,15.69 108.93,15.55 108.87,15.35 109.25,14.97 109.63,15.35 109.58,15.54 109.45,15.68 109.43,15.69 109.43,15.82 109.45,15.84 109.47,15.86 109.48,15.9 109.49,15.94 109.74,15.94 109.85,16.05 109.93,16.05 109.93,16 109.97,15.92 110.06,15.88 110.67,15.88 110.76,15.92 110.8,16.01 110.8,16.44 110.79,16.48 110.77,16.53 110.78,16.58 110.82,16.6 110.88,16.59 110.88,16.55 111.38,16.05 111.83,16.05 111.83,16 111.87,15.92 111.96,15.88 112.57,15.88 112.66,15.92 112.7,16.01 112.7,16.44 112.69,16.48 112.66,16.55 112.69,16.62 112.7,16.66
GND on TOP (solid shape): 192.32,27.82 192.52,27.62 192.55,27.51 192.46,27.45 192.21,27.32 192.11,27.07 192.5,26.68 192.88,27.07 192.85,27.21 192.76,27.34 192.74,27.45 192.83,27.51 193.17,27.51 193.26,27.45 193.23,27.33 193.13,27.2 193.1,27.04 193.21,26.77 193.48,26.66 193.61,26.69 193.73,26.75 193.8,26.78 193.86,26.75 193.88,26.74 193.9,26.7 193.88,26.64 193.88,26.61 193.88,26.25 193.64,26.25 193.56,26.33 193.15,26.33 193.14,26.36 193.06,26.48 192.92,26.53 192.64,26.53 192.48,26.46 192.41,26.3 192.41,26 192.46,25.87 192.57,25.78 192.6,25.77 192.6,25.51 192.58,25.5 192.45,25.42 192.39,25.28 192.39,24.85 192.35,24.77 192.26,24.76 192.2,24.77 192.14,24.78 192.02,24.76 191.91,24.7 191.81,24.7 191.76,24.79 191.76,27.09 192.15,27.49 192.15,28.01 192.25,28.05 192.32,28.05
GND on TOP (solid shape): 48.18,37.06 48.24,37.15 48.35,37.13 48.46,37.02 48.46,36.99 48.53,36.85 48.68,36.81 48.75,36.84 48.77,36.86 48.86,36.92 48.96,36.94 49.14,36.87 49.21,36.69 49.21,36.69 49.26,36.56 49.39,36.51 49.78,36.51 49.78,36.3 49.24,36.3 49.2,36.31 49.17,36.33 49.12,36.38 49.06,36.42 48.99,36.44 48.96,36.44 48.88,36.45 48.82,36.48 48.58,36.49 48.46,36.28 48.46,34.51 48.56,34.33 48.76,34.29 48.79,34.3 48.83,34.3 48.85,34.3 48.92,34.31 49,34.34 49.03,34.35 49.78,34.35 49.78,34.15 49.19,34.15 49.09,34.06 49.08,34 48.99,33.85 48.83,33.79 48.79,33.8 48.76,33.8 48.56,33.77 48.46,33.58 48.46,33.19 48.61,33.04 48.62,33.03 48.69,32.94 48.78,32.87 48.79,32.87 48.86,32.8 48.88,32.69 48.79,32.63 48.39,32.63 48.35,32.62 48.28,32.61 48.25,32.56 48.23,32.54 47.69,32 47.68,31.93 47.68,31.55 47.69,31.5 47.69,31.21 47.68,31.16 47.68,30.78 47.69,30.75 47.69,30.14 47.69,30.09 47.31,30.09 47.31,32.27 48.18,33.14
GND on TOP (solid shape): 86.7,42.92 86.83,42.74 87.04,42.67 87.09,42.67 87.14,42.68 87.23,42.66 87.27,42.58 87.27,42.2 87.44,42.03 87.44,34.65 87.66,34.43 87.66,33.77 87.37,33.48 87.37,32.99 86.9,32.53 86.9,32.04 86.28,31.42 86.17,31.53 86.18,31.59 86.18,31.62 86.14,31.79 86.02,31.92 86,31.96 86.01,32 86.02,32.01 86.05,32.02 86.09,32.01 86.21,31.93 86.35,31.9 86.6,32 86.7,32.26 86.65,32.43 86.52,32.57 86.52,33.11 86.85,33.44 86.85,34.48 86.04,35.29 86.04,35.98 86.08,36.06 86.17,36.07 86.23,36.06 86.29,36.05 86.56,36.17 86.68,36.44 86.6,36.66 86.41,36.8 86.39,36.8 86.35,36.85 86.4,36.9 86.4,37.24 86.45,37.32 86.54,37.34 86.6,37.32 86.66,37.32 86.93,37.43 87.04,37.7 87.01,37.83 86.94,37.95 86.92,38.02 86.94,38.08 87.01,38.2 87.04,38.33 86.93,38.6 86.66,38.71 86.6,38.71 86.54,38.7 86.45,38.71 86.4,38.79 86.4,42.57 86.6,42.77 86.6,42.96 86.69,42.96
GND on TOP (solid shape): outline of 84 points within 192.83,22.94 197.85,25.97
GND on TOP (solid shape): 102.16,76.47 102.26,76.45 104.17,74.54 104.15,74.5 104.09,74.4 104.07,74.28 104.08,74.24 104.09,74.17 103.37,73.44 103.07,73.44 102.99,73.49 102.99,73.6 103.02,73.68 103.03,73.77 102.68,74.13 102.32,73.77 102.33,73.7 102.24,73.62 102.19,73.67 102.19,73.68 102.17,73.8 102.1,73.9 102.07,73.97 102.1,74.03 102.15,74.14 102.17,74.25 102.07,74.5 101.81,74.61 101.73,74.6 101.66,74.57 101.56,74.57 101.51,74.66 101.51,74.86 101.72,75.07 102.07,75.07 102.38,74.75 102.37,74.7 102.37,74.66 102.73,74.31 103.08,74.66 103.06,74.78 103,74.89 102.98,74.95 103,75.02 103.06,75.13 103.08,75.25 102.98,75.5 102.73,75.6 102.61,75.58 102.51,75.52 102.47,75.5 102.31,75.65 102.2,75.65 102.12,75.69 102.11,75.78 102.12,75.83 102.12,75.88 102.1,76.01 102.03,76.12 102,76.18 102.02,76.25 102.06,76.32 102.09,76.4
GND on TOP (solid shape): outline of 130 points within 144.4,51.78 148.31,55.63
GND on TOP (solid shape): 131.19,90.47 131.19,89.62 132.62,88.19 133.97,88.19 134.22,87.93 135.41,87.93 135.87,87.48 136.84,87.48 136.9,87.41 136.9,86.72 137.17,86.46 139.41,86.46 139.42,86.44 139.42,86.22 139.38,86.18 138.6,86.18 138.24,85.82 138.24,85.72 138.1,85.58 138.05,85.39 138.06,85.28 138.12,85.17 138.12,85.07 138.03,85.01 137.93,85.01 137.84,85.07 137.86,85.18 137.92,85.29 137.94,85.42 137.83,85.69 137.56,85.8 137.39,85.76 137.26,85.65 137.17,85.61 137.09,85.65 136.96,85.77 136.78,85.82 136.55,85.74 136.41,85.55 136.41,85.53 136.37,85.49 136.27,85.58 136.27,86.3 135.69,86.88 135.68,86.91 135.69,86.95 135.78,87.07 135.81,87.22 135.42,87.6 135.04,87.22 135.06,87.12 135.1,87.02 135.1,86.92 135.01,86.87 134.81,86.87 134.73,86.91 134.71,87 134.73,87.06 134.73,87.12 134.62,87.39 134.35,87.5 134.12,87.43 133.98,87.23 133.98,87.22 133.94,87.18 133.86,87.26 133.86,87.4 133.2,88.06 132.57,88.06 131.06,89.56 131.06,90.42 129.79,91.69 129.78,91.73 129.8,91.77 129.83,91.79 129.85,91.81
GND on TOP (solid shape): outline of 81 points within 16.7,9.13 20.64,12.88
GND on TOP (solid shape): 40.4,71.18 40.51,71.2 40.57,71.11 40.57,71.1 40.55,71.04 40.31,70.91 40.25,70.73 40.31,70.54 40.49,70.45 40.55,70.41 40.57,70.34 40.57,70.3 40.55,70.24 40.31,70.11 40.25,69.93 40.33,69.73 40.53,69.65 40.7,69.71 40.8,69.87 40.84,69.93 40.9,69.95 40.93,69.95 41.11,70 41.24,70.13 41.33,70.18 41.42,70.13 41.51,70.02 41.65,69.96 41.66,69.95 41.71,69.91 41.65,69.85 41.64,69.85 41.45,69.72 41.37,69.5 41.35,69.44 41.11,69.31 41.05,69.13 41.05,69.12 41.07,69.01 41.13,68.92 41.37,68.68 41.38,68.62 41.39,68.58 41.38,68.48 41.3,68.44 40.53,68.44 40.2,68.76 40.2,69.05 39.92,69.33 39.83,69.39 39.73,69.41 39.69,69.43 39.68,69.49 39.92,69.73 39.98,69.82 40.01,69.93 39.94,70.11 39.77,70.2 39.7,70.24 39.68,70.31 39.68,70.35 39.7,70.41 39.77,70.45 39.94,70.55 40.01,70.73 40,70.79
GND on TOP (solid shape): outline of 84 points within 194.15,25.39 197.87,29.7
GND on TOP (solid shape): outline of 116 points within 111.85,15.66 120.84,22.91
GND on TOP (solid shape): outline of 179 points within 92.85,44.45 96.51,47.8
GND on TOP (solid shape): outline of 91 points within 122.36,29.63 130.22,34
GND on TOP (solid shape): outline of 91 points within 123.16,118.94 124.56,122.62
GND on TOP (solid shape): outline of 195 points within 35.43,22.4 39.34,28.56
