# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 107.22,121.46 107.3,121.42 107.31,121.33 107.31,121.29 107.31,120.64 107.34,120.56 107.41,120.51 107.45,120.5 107.45,120.01 107.41,119.96 107.39,119.96 107.15,119.83 107.06,119.58 107.06,119.54 107.07,119.47 106.98,119.37 106.98,119.27 106.86,119.16 106.8,119.01 106.8,118.96 106.41,118.96 106.41,119.67 106.77,120.03 106.81,120.03 106.9,120.07 106.93,120.16 106.93,120.36 106.9,120.45 106.81,120.49 106.42,120.49 106.33,120.45 106.3,120.36 106.3,120.16 106.32,120.08 106.12,119.88 106.06,119.87 106.03,119.92 106.03,120.02 106.07,120.03 106.14,120.08 106.17,120.16 106.17,120.36 106.16,120.4 106.14,120.44 106.12,120.5 106.13,120.56 106.14,120.58 106.15,120.61 106.15,120.68 106.17,120.75 106.24,120.79 106.42,120.84 106.55,120.98 106.56,121 106.63,121 107.11,121.48
GND on BOTTOM (solid shape): 75.08,24.62 75.16,24.59 75.18,24.51 75.18,24.5 75.18,24.3 75.21,24.22 75.28,24.17 75.32,24.16 75.32,23.99 75.29,23.98 75.17,23.89 75.12,23.76 75.12,23.48 75.14,23.38 75.2,23.3 75.24,23.23 75.2,23.15 75.16,23.1 75.13,23.05 75.12,23.02 74.86,23.02 74.85,23.05 74.77,23.16 74.63,23.2 74.33,23.2 74.17,23.14 74.11,22.98 74.11,22.87 74.08,22.82 74.02,22.83 73.71,23.14 73.69,23.14 73.6,23.23 73.49,23.26 73.19,23.26 73.08,23.23 72.99,23.14 72.63,23.14 72.6,23.16 72.57,23.18 72.55,23.23 72.57,23.27 72.67,23.36 72.7,23.48 72.7,23.76 72.66,23.89 72.54,23.98 72.5,23.99 72.5,24.16 72.54,24.17 72.61,24.22 72.64,24.3 72.64,24.5 72.64,24.51 72.67,24.59 72.74,24.62
GND on BOTTOM (solid shape): 75.55,118.94 75.55,118.71 75.62,118.55 75.78,118.49 76.03,118.49 76.25,118.26 76.25,117.51 76.45,117.31 76.45,116.52 76.29,116.37 76.26,116.38 76.21,116.4 76.15,116.41 75.85,116.41 75.69,116.34 75.63,116.18 75.63,115.88 75.55,115.8 75.48,115.78 75.42,115.78 75.42,116 75.39,116.12 75.31,116.2 75.28,116.21 75.28,116.45 75.31,116.47 75.39,116.55 75.42,116.66 75.42,116.96 75.35,117.12 75.19,117.19 74.91,117.19 74.82,117.17 74.74,117.11 74.66,117.08 74.59,117.11 74.53,117.16 74.47,117.18 74.43,117.19 74.43,117.41 74.49,117.45 74.51,117.48 74.59,117.51 74.67,117.48 74.75,117.42 74.84,117.4 75.12,117.4 75.28,117.46 75.35,117.62 75.35,117.92 75.32,118.04 75.24,118.12 75.21,118.14 75.21,118.37 75.24,118.39 75.32,118.47 75.35,118.58 75.35,118.85 75.5,119
GND on BOTTOM (solid shape): 95.63,49.05 95.67,49.06 95.7,49.06 95.77,49.04 95.81,48.97 95.91,48.78 96.11,48.7 96.19,48.71 96.36,48.54 96.36,48.51 96.42,48.33 96.56,48.21 96.61,48.16 96.62,48.09 96.61,48.05 96.61,48.01 96.61,47.97 96.62,47.92 96.61,47.85 96.56,47.8 96.4,47.68 96.34,47.49 96.34,47.46 96.36,47.39 96.25,47.28 96.22,47.3 96.17,47.31 96.11,47.31 96.09,47.31 96,47.36 95.99,47.46 96.02,47.54 96.03,47.62 95.94,47.85 95.71,47.95 95.65,47.98 95.62,48.04 95.53,48.23 95.34,48.31 95.27,48.35 95.25,48.41 95.25,48.6 95.27,48.67 95.54,48.8 95.62,49.01
GND on BOTTOM (solid shape): 123.73,74.1 124.17,73.66 128.81,73.66 129.18,73.29 129.86,73.29 129.96,73.22 129.94,73.11 129.75,72.92 129.75,70.16 129.79,70.11 129.82,70 129.72,69.94 129.61,69.94 129.61,69.92 128.48,68.79 125.02,68.79 124.79,68.57 123.27,68.57 123.26,68.56 123.15,68.54 123.09,68.63 123.09,71.61 122.71,71.99 114.41,71.99 113.99,71.58 113.99,67.96 113.96,67.88 113.89,67.86 113.88,67.86 113.81,67.88 113.64,68.24 113.35,68.36 113.25,68.35 113.15,68.32 113.05,68.32 113,68.41 113,71.25 112.19,72.06 111.14,72.06 110.88,72.32 110.86,72.43 110.95,72.49 113.35,72.49 113.43,72.45 113.44,72.35 113.43,72.29 113.42,72.22 113.8,71.84 114.18,72.22 114.18,72.29 114.16,72.35 114.17,72.45 114.26,72.49 118.17,72.49 119,73.31 119,74.32 119.28,74.6 123.73,74.6
GND on BOTTOM (solid shape): 67.31,111.45 67.31,111.15 67.37,110.99 67.53,110.92 67.72,110.92 67.75,110.89 67.77,110.78 67.68,110.71 67.53,110.71 67.37,110.65 67.31,110.49 67.31,110.19 67.37,110.03 67.53,109.96 67.81,109.96 67.93,109.99 68.01,110.08 68.03,110.11 68.26,110.11 68.27,110.08 68.36,109.99 68.47,109.96 68.75,109.96 68.85,109.98 68.93,110.04 69,110.07 69.08,110.04 69.11,110.01 69.16,109.98 69.16,109.74 69.11,109.7 69.08,109.68 69,109.64 68.93,109.68 68.85,109.73 68.75,109.75 68.47,109.75 68.36,109.72 68.27,109.63 68.26,109.61 68.03,109.61 68.01,109.63 67.93,109.72 67.81,109.75 67.53,109.75 67.44,109.73 67.36,109.68 67.28,109.64 67.21,109.68 67.13,109.73 67.03,109.75 66.99,109.75 66.06,110.68 66.07,110.71 66.1,110.78 66.1,110.86 66.09,110.95 66.06,111.03 66.04,111.06 66.53,111.55 67.31,111.55
GND on BOTTOM (solid shape): 154.25,18.57 154.25,18.28 154.09,18.12 153.69,18.12 153.6,18.09 153.57,18 153.57,16.91 153.58,16.84 153.62,16.8 153.67,16.74 153.66,16.67 153.63,16.58 153.62,16.5 153.73,16.23 154,16.11 154.08,16.12 154.16,16.15 154.19,16.16 156.42,13.94 156.44,13.85 156.39,13.78 156.23,13.64 156.17,13.45 156.27,13.2 156.53,13.09 156.72,13.15 156.85,13.31 156.93,13.37 157.02,13.34 157.9,12.45 157.93,12.34 157.83,12.28 156.93,12.28 153.18,16.03 153.18,16.16 153.33,16.3 153.38,16.5 153.37,16.58 153.34,16.67 153.33,16.74 153.37,16.8 153.42,16.84 153.43,16.91 153.43,18 153.39,18.09 153.3,18.12 152.79,18.12 152.69,18.22 152.66,18.3 152.69,18.37 152.78,18.49 152.82,18.64 152.82,18.69 154.12,18.69
GND on BOTTOM (solid shape): 106.05,62.89 106.14,62.92 106.22,62.85 106.38,62.66 106.61,62.59 106.66,62.59 106.7,62.6 106.78,62.58 106.82,62.5 106.82,62.09 105.38,60.65 103.53,60.65 103.33,60.85 103.32,60.9 103.37,60.93 103.45,60.93 103.59,60.8 105.19,60.8 105.85,61.46 105.85,61.81 105.91,61.87 105.97,61.86 106.01,61.86 106.36,62.22 106.01,62.57 105.88,62.55 105.78,62.49 105.71,62.47 105.65,62.49 105.54,62.55 105.42,62.57 105.17,62.47 105.07,62.22 105.11,62.04 105.24,61.91 105.24,61.71 104.94,61.41 103.84,61.41 103.71,61.54 103.49,61.54 103.44,61.58 103.45,61.63 103.48,61.66 103.68,61.66 103.92,61.9 103.99,61.89 104.02,61.89 104.26,61.98 104.35,62.22 104.27,62.44 104.06,62.54 104.04,62.55 104,62.59 104.1,62.7 105.86,62.7
GND on BOTTOM (solid shape): 71.99,124.04 72.04,124.05 72.08,124.01 72.08,123.91 72.14,123.75 72.3,123.69 72.32,123.69 72.55,123.46 73.54,123.46 73.54,121.83 73.93,121.45 73.88,121.4 73.82,121.4 73.76,121.38 73.72,121.42 73.43,121.42 73.43,121.52 73.39,121.61 73.3,121.64 72.49,121.64 72.4,121.61 72.36,121.52 72.36,121.47 72.12,121.47 72.11,121.45 72.05,121.44 72.02,121.49 72.02,121.71 72.06,121.72 72.23,121.81 72.34,121.97 72.38,122.03 72.46,122.04 72.49,122.04 73.3,122.04 73.39,122.08 73.43,122.17 73.43,122.85 73.39,122.94 73.3,122.98 72.49,122.98 72.4,122.94 72.36,122.85 72.36,122.72 72.21,122.72 71.96,122.47 71.94,122.47 71.69,122.35 71.59,122.09 71.59,122.04 71.56,122 71.56,121.65 71.42,121.51 70.72,121.51 70.65,121.54 70.62,121.87 70.99,122.24 70.99,122.34 71.02,122.36 71.13,122.44 71.18,122.57 71.18,122.87 71.16,122.96 71.11,123.03 71.09,123.1 71.12,123.17
GND on BOTTOM (solid shape): 172.54,33.5 172.57,33.41 172.51,33.33 172.34,33.19 172.27,32.98 172.31,32.81 172.42,32.68 172.45,32.57 172.36,32.5 171.93,32.5 171.82,32.39 171.71,32.37 171.65,32.47 171.65,32.5 171,32.77 171.27,32.12 171.29,32.12 171.39,32.06 171.37,31.94 170.68,31.26 169.41,31.26 169.32,31.3 169.31,31.39 169.32,31.45 169.33,31.51 169.26,31.72 169.09,31.86 169.03,31.94 169.06,32.03 169.35,32.33 169.35,32.72 169.76,33.13 171.38,33.13 171.65,33.24 171.77,33.51 171.75,33.64 171.69,33.75 171.68,33.85 171.77,33.91 172.13,33.91
GND on BOTTOM (solid shape): outline of 148 points within 34.96,27.26 48.07,31.53
GND on BOTTOM (solid shape): 90.67,90.73 90.74,90.73 90.76,90.7 90.84,90.58 90.97,90.54 91.27,90.54 91.4,90.58 91.49,90.7 91.5,90.73 91.76,90.73 91.77,90.7 91.85,90.58 91.99,90.54 92.29,90.54 92.42,90.58 92.5,90.7 92.51,90.73 92.78,90.73 92.79,90.7 92.87,90.58 93,90.54 93.27,90.54 93.45,90.36 93.47,90.25 93.38,90.19 91.41,90.19 90.98,89.76 90.91,89.77 90.87,89.78 90.6,89.66 90.49,89.39 90.52,89.23 90.63,89.1 90.66,88.98 90.56,88.92 90.23,88.92 90.14,88.96 90.14,89.06 90.14,89.1 90.14,89.3 90.14,89.33 90.12,89.36 90.1,89.42 90.12,89.48 90.14,89.51 90.14,89.55 90.14,89.75 90.14,89.78 90.12,89.81 90.1,89.87 90.12,89.93 90.14,89.96 90.14,90 90.14,90.2 90.14,90.23 90.13,90.25 90.12,90.29 90.14,90.32 90.23,90.44 90.26,90.59 90.25,90.65 90.24,90.71 90.25,90.8 90.33,90.84 90.42,90.84 90.46,90.85 90.49,90.86 90.52,90.88
GND on BOTTOM (solid shape): outline of 146 points within 163.86,11.37 175.25,13.57
GND on BOTTOM (solid shape): 88.75,28.55 88.77,28.51 88.77,28.27 88.81,28.18 88.9,28.14 89.13,28.14 89.4,27.87 89.93,27.87 90.04,27.77 90.24,27.77 90.29,27.73 90.35,27.72 90.73,27.72 90.78,27.73 90.83,27.77 90.86,27.77 90.95,27.73 90.96,27.64 90.96,27.6 90.96,27.39 90.01,27.39 89.62,27 89.62,23.77 90.14,23.25 91.92,23.25 92.17,23 92.32,23 92.33,22.97 92.38,22.93 92.45,22.91 92.59,22.91 92.67,22.86 92.68,22.76 92.64,22.68 92.63,22.59 92.74,22.34 92.99,22.24 93.11,22.26 93.22,22.32 93.28,22.34 93.57,22.24 93.87,22.34 93.93,22.32 94.04,22.26 94.16,22.24 94.23,22.24 94.29,22.26 94.39,22.25 94.43,22.17 94.43,21.79 94.37,21.69 94.25,21.72 94.12,21.82 93.97,21.86 93.92,21.85 93.85,21.84 93.61,22.08 92.9,22.08 92.57,21.76 92.54,21.79 92.41,21.88 92.26,21.91 92.22,21.9 92.15,21.89 91.78,22.26 89.87,22.26 88.66,23.48 88.66,28.53 88.7,28.55
GND on BOTTOM (solid shape): 146.93,38.52 147.07,38.39 147.25,38.34 147.38,38.36 147.49,38.42 147.58,38.44 147.65,38.37 147.66,38.33 147.68,38.29 147.69,38.22 147.65,38.16 147.62,38.12 147.61,38.06 147.61,37.25 147.62,37.19 147.68,37.14 147.7,37.12 147.7,37.01 147.65,36.92 147.54,36.93 147.47,36.97 147.38,37 147.37,37 147.19,37.18 147.21,37.25 147.21,38.06 147.17,38.16 147.08,38.19 146.4,38.19 146.31,38.15 146.27,38.06 146.27,37.25 146.31,37.16 146.4,37.12 146.5,37.12 146.5,37 146.94,36.57 146.94,36.55 147.03,36.37 147.2,36.26 147.23,36.25 147.23,35.5 147.19,35.42 147.1,35.4 147.03,35.42 146.96,35.43 146.82,35.4 146.7,35.33 146.69,35.31 146.61,35.31 146.61,35.39 146.63,35.41 146.67,35.48 146.69,35.56 146.69,35.84 146.62,36 146.46,36.07 146.16,36.07 146.11,36.06 146.06,36.05 146.02,36.03 145.62,36.44 145.62,36.62 145.6,36.71 145.55,36.79 145.53,36.82 145.54,36.86 145.61,36.97 145.63,37.1 145.59,37.29 145.46,37.43 145.46,37.68 146.3,38.52
GND on BOTTOM (solid shape): 129.74,95.67 129.79,95.66 129.81,95.66 129.91,95.6 129.89,95.49 129.88,95.48 129.88,92.67 129.33,92.12 128.53,92.12 128.28,91.87 128.28,91.35 128.22,91.26 128.11,91.28 126.17,93.22 126.17,93.35 126.26,93.39 126.39,93.28 126.55,93.24 126.77,93.32 126.9,93.51 126.97,93.58 127.07,93.56 127.34,93.28 127.34,93.09 127.19,92.96 127.14,92.77 127.49,92.42 127.85,92.77 127.79,92.96 127.65,93.09 127.65,93.29 127.73,93.29 127.74,93.26 127.87,93.12 128.06,93.07 128.09,93.08 128.18,93.05 128.21,92.96 128.2,92.92 128.56,92.57 128.92,92.92 128.89,93.06 128.81,93.18 128.78,93.25 128.81,93.32 128.99,93.5 128.99,94.66 128.82,94.83 128.8,94.94 128.9,95.01 128.99,95.01 129.67,95.68
GND on BOTTOM (solid shape): 100.44,107.35 100.53,107.3 100.51,107.19 100.47,107.11 100.45,107.02 100.48,106.91 100.55,106.82 100.6,106.75 100.57,106.67 98.94,105.04 98.94,102.23 97.97,101.26 96.78,101.26 96.7,101.3 96.68,101.38 96.69,101.44 96.69,101.74 96.64,101.87 96.53,101.95 96.5,101.96 96.5,102.23 96.53,102.24 96.64,102.32 96.69,102.45 96.69,102.75 96.64,102.88 96.53,102.97 96.5,102.98 96.5,103.24 96.53,103.25 96.59,103.28 96.63,103.32 96.71,103.36 96.79,103.32 96.86,103.26 96.96,103.24 97.24,103.24 97.32,103.26 97.39,103.3 97.48,103.3 97.96,103.79 97.97,103.79 98.21,104.13 97.97,104.46 97.96,104.46 97.48,104.95 97.39,104.95 97.32,105 97.24,105.01 96.96,105.01 96.86,104.99 96.79,104.93 96.71,104.9 96.63,104.93 96.59,104.97 96.53,105 96.5,105.01 96.5,105.27 96.53,105.28 96.64,105.37 96.69,105.5 96.69,105.8 96.64,105.93 96.53,106.02 96.5,106.03 96.5,106.29 96.53,106.3 96.64,106.38 96.69,106.52 96.69,106.78 97.26,107.35
GND on BOTTOM (solid shape): 97.27,36.61 97.24,36.58 97.22,36.54 97.21,36.5 97.21,36.12 97.25,36.03 97.34,35.99 97.54,35.99 97.63,36.03 97.67,36.12 97.67,36.5 97.66,36.56 97.62,36.6 97.62,36.73 97.81,36.73 97.89,36.66 97.8,36.57 97.79,36.51 97.79,36.3 97.8,36.26 97.82,36.22 97.84,36.18 97.82,36.15 97.8,36.11 97.79,36.06 97.79,35.85 97.82,35.77 97.89,35.73 97.93,35.72 97.93,35.65 97.9,35.62 97.9,35.54 97.87,35.53 97.76,35.45 97.71,35.32 97.71,35.01 97.76,34.88 97.87,34.8 97.9,34.79 97.9,34.74 98.18,34.46 98.18,34.03 98.19,33.98 98.15,33.95 98.01,33.95 97.88,34.08 97.71,34.12 97.59,34.11 97.49,34.05 97.39,34.04 97.33,34.14 97.33,34.41 96.71,35.04 96.68,35.12 96.71,35.19 96.81,35.32 96.85,35.48 96.83,35.6 96.78,35.71 96.76,35.77 96.79,35.84 96.87,35.95 96.89,36.08 96.8,36.31 96.58,36.41 96.56,36.41 96.37,36.61 96.35,36.65 96.32,36.71 96.35,36.78 96.36,36.81 96.37,36.84 96.37,37.02 96.62,37.27
GND on BOTTOM (solid shape): 163.79,25.1 163.9,25.12 163.96,25.03 163.96,24.27 163.92,24.27 163.84,24.23 163.81,24.14 163.81,23.75 162.23,22.17 161.44,22.17 160.92,21.65 160.59,21.32 160.53,21.32 160.44,21.37 160.43,21.46 160.46,21.58 160.44,21.7 160.46,21.8 160.55,21.83 160.97,22.14 160.69,22.58 160.65,22.59 160.65,22.72 160.68,22.73 160.8,22.82 160.84,22.95 160.84,23.25 160.8,23.38 160.68,23.47 160.65,23.48 160.65,23.74 160.68,23.75 160.78,23.81 160.83,23.9 160.84,23.94 160.92,23.94 161.1,24.12 161.19,24.15 161.26,24.1 161.34,24.02 161.46,23.99 161.74,23.99 161.83,24.01 161.91,24.07 161.99,24.11 162.06,24.07 162.11,24.03 162.18,24 162.2,23.98 162.2,23.94 162.16,23.9 162.16,23.65 162.12,23.6 162.11,23.54 162.11,23.16 162.15,23.07 162.24,23.04 162.44,23.04 162.52,23.06 162.57,23.14 162.57,23.18 162.7,23.18 163.42,23.9 163.42,23.9 163.64,24.24 163.44,24.58 163.44,24.75
GND on BOTTOM (solid shape): 65.28,23.89 65.34,23.87 65.38,23.84 65.42,23.82 65.42,23.25 66.63,22.03 66.83,22.03 66.87,22 66.93,21.98 67.31,21.98 67.37,22 67.41,22.03 67.55,22.03 67.56,21.99 67.6,21.92 67.68,21.89 68.33,21.89 68.41,21.92 68.46,21.99 68.47,22.03 68.95,22.03 69.03,21.99 69.05,21.9 69.04,21.86 69.04,20.56 69.08,20.47 69.17,20.43 69.34,20.43 69.44,20.37 69.41,20.26 69.18,20.03 69.07,20.01 69.01,20.11 69.01,20.13 68.36,20.4 68.63,19.75 68.65,19.75 68.75,19.69 68.73,19.58 68.51,19.36 68.51,17.59 68.8,17.3 68.82,17.19 68.72,17.13 66.59,17.13 64.05,19.67 61.65,19.67 61.55,19.73 61.57,19.84 62.19,20.46 62.19,21.77 64.21,23.79 64.28,23.78 64.32,23.77 64.46,23.8 64.57,23.87 64.64,23.89 64.96,23.77
GND on BOTTOM (solid shape): 118.98,105.54 118.96,105.47 118.96,105.42 119.06,105.17 119.31,105.07 119.46,105.09 119.57,105.18 119.66,105.21 119.73,105.17 119.85,105.06 120.01,105.01 120.09,104.97 120.11,104.89 120.1,104.86 120.1,104.82 120.14,104.68 120.24,104.57 120.24,104.57 120.39,104.42 120.37,104.35 120.37,104.3 120.47,104.05 120.72,103.95 120.76,103.95 120.8,103.95 120.9,103.92 120.92,103.82 120.91,103.77 120.9,103.72 120.94,103.57 121.05,103.46 121.05,103.31 120.98,103.31 120.96,103.33 120.84,103.42 120.69,103.46 120.56,103.43 120.46,103.37 119.95,103.88 119.86,103.88 119.8,103.95 119.72,104 119.67,104.05 119.66,104.12 119.67,104.16 119.67,104.2 119.57,104.45 119.31,104.56 119.27,104.56 119.19,104.54 119.07,104.67 119.08,104.7 119.1,104.76 119.11,104.82 119.03,105.02 118.85,105.12 118.77,105.17 118.77,105.27 118.8,105.34 118.81,105.42 118.8,105.49 118.78,105.55 118.79,105.6 118.83,105.62 118.89,105.63
GND on BOTTOM (solid shape): outline of 85 points within 42.96,14.38 46.68,18.69
GND on BOTTOM (solid shape): 113,67.45 113.05,67.54 113.15,67.55 113.25,67.51 113.35,67.5 113.42,67.47 113.58,67.11 113.88,66.99 113.89,66.99 113.96,66.96 113.99,66.89 113.99,65.65 114.23,65.41 116.31,65.41 116.77,64.95 116.77,61.1 116.77,61.07 116.85,60.92 117.01,60.87 117.11,60.87 117.22,60.87 119.96,59.74 121.09,57 120.84,55.61 120.1,54.41 120.06,54.37 119.83,54.37 118.4,52.94 115.1,52.94 115.04,52.88 114.96,52.88 114.89,52.92 114.86,53 114.87,53.04 114.87,53.07 114.76,53.34 114.49,53.45 114.26,53.38 114.12,53.18 114.05,53.11 113.95,53.13 113.77,53.32 113.77,53.8 113.79,53.85 113.8,53.89 113.8,54.54 113.76,54.64 113.66,54.67 113.55,54.67 113.44,54.79 113.44,58.48 113.36,58.51 113.33,58.58 113.33,59.4 113.7,59.77 113.7,62.5 113,63.2
GND on BOTTOM (solid shape): 57.86,104.88 57.92,104.86 58.03,104.79 58.15,104.76 58.24,104.7 58.22,104.59 58.17,104.54 58.17,104.27 58.19,104.17 58.26,104.11 58.4,103.88 58.26,103.66 58.22,103.63 58.17,103.55 58.17,102.15 58.19,102.04 58.26,101.96 58.28,101.93 58.27,101.9 58.24,101.81 58.23,101.71 58.34,101.44 58.61,101.33 58.81,101.39 58.95,101.54 59.35,101.54 59.56,101.33 59.56,100.06 61.06,98.56 61.06,98.11 61.01,98.02 61,97.91 60.93,97.82 60.82,97.85 60.63,98.04 60.64,98.11 60.64,98.16 60.53,98.43 60.26,98.54 60.22,98.54 60.15,98.52 59.57,99.1 58.15,99.1 57.94,98.89 57.83,98.87 57.77,98.96 57.77,99.12 57.21,99.68 57.21,103.43 57.38,103.59 57.64,103.59 57.8,103.66 57.87,103.82 57.87,104.1 57.8,104.26 57.64,104.32 57.38,104.32 57.27,104.43 57.08,104.43 57.06,104.45 57.06,104.56 57.1,104.56 57.17,104.61 57.2,104.69 57.2,104.72 57.25,104.81 57.35,104.81 57.44,104.77 57.54,104.76 57.67,104.79 57.79,104.86
GND on BOTTOM (solid shape): 85.55,45.31 85.64,45.28 85.67,45.19 85.67,45.16 85.72,44.99 85.84,44.87 85.9,44.78 85.84,44.69 85.72,44.57 85.67,44.41 85.63,44.33 85.55,44.31 85.51,44.31 85.32,44.24 85.21,44.07 85.16,44 85.08,43.99 85.02,44.01 84.96,44.01 84.73,43.93 84.63,43.71 84.59,43.64 84.52,43.61 84.51,43.61 84.37,43.58 84.26,43.48 84.25,43.46 84.23,43.46 84.03,43.26 83.97,43.28 83.92,43.28 83.85,43.3 83.81,43.36 83.76,43.48 83.67,43.57 83.62,43.66 83.67,43.75 83.78,43.86 83.82,44.01 83.82,44.04 83.85,44.12 83.94,44.15 83.97,44.14 84.01,44.14 84.22,44.21 84.33,44.4 84.34,44.42 84.43,44.51 84.51,44.5 84.7,44.57 84.81,44.75 84.85,44.81 84.92,44.83 84.96,44.83 85.19,44.92 85.29,45.15 85.29,45.17 85.43,45.31
GND on BOTTOM (solid shape): 95.6,92.75 95.6,91.61 95.88,91.34 95.91,91.27 95.88,91.2 95.84,91.13 95.82,91.05 95.82,90.77 95.87,90.63 95.99,90.55 96.02,90.54 96.02,90.45 95.99,90.4 95.94,90.41 95.56,90.78 95.56,91.05 95.5,91.21 95.34,91.28 95.03,91.28 94.87,91.21 94.81,91.05 94.81,90.77 94.87,90.61 95.03,90.54 95.3,90.54 95.41,90.43 95.35,90.37 95.32,90.39 95.05,90.39 94.85,90.21 94.75,90.21 94.49,90.47 94.46,90.54 94.48,90.61 94.53,90.69 94.55,90.77 94.55,91.05 94.48,91.21 94.32,91.28 94.02,91.28 93.86,91.21 93.79,91.05 93.79,90.77 93.84,90.63 93.95,90.55 93.99,90.54 93.99,90.45 93.98,90.42 93.9,90.42 93.53,90.78 93.53,91.05 93.46,91.21 93.3,91.28 93,91.28 92.87,91.23 92.79,91.12 92.78,91.09 92.51,91.09 92.5,91.12 92.42,91.23 92.29,91.28 91.99,91.28 91.85,91.23 91.77,91.12 91.76,91.09 91.5,91.09 91.49,91.12 91.46,91.18 91.42,91.22 91.38,91.3 91.42,91.38 91.48,91.45 91.5,91.55 91.5,91.69 91.5,92.79 91.86,93.15 95.2,93.15
GND on BOTTOM (solid shape): 109.77,119.7 109.79,119.65 109.79,119.63 109.79,119.25 109.79,119.22 109.81,119.18 109.83,119.15 109.71,119.03 109.69,119.03 109.45,118.87 109.36,118.6 109.36,118.54 109.34,118.46 109.27,118.43 109.02,118.32 108.93,118.07 108.95,117.94 109.03,117.82 109.05,117.75 109.03,117.68 108.95,117.57 108.93,117.44 109.03,117.18 109.28,117.08 109.44,117.11 109.56,117.21 109.67,117.24 109.74,117.15 109.74,116.37 109.7,116.29 109.6,116.27 109.55,116.29 109.49,116.29 109.23,116.19 109.13,115.94 109.18,115.75 109.33,115.62 109.33,115.49 109.22,115.38 109.05,115.54 109.05,115.75 108.42,116.38 108.42,118.12 108.45,118.14 108.63,118.3 108.7,118.53 108.61,118.79 108.38,118.94 108.35,118.95 108.35,119.07 108.38,119.12 108.4,119.18 108.4,119.56 108.44,119.6 108.69,119.58 108.75,119.55 108.78,119.5 108.83,119.46 108.89,119.39 108.98,119.37 109.23,119.37 109.33,119.44 109.33,119.46 109.34,119.47 109.4,119.55 109.44,119.64 109.5,119.66 109.56,119.67 109.58,119.67 109.65,119.68 109.71,119.7
GND on BOTTOM (solid shape): 83.3,49.4 83.38,49.35 83.5,49.25 83.65,49.21 83.7,49.21 83.79,49.18 83.82,49.09 83.81,49.05 83.81,49.01 83.81,48.95 83.79,48.87 83.72,48.83 83.51,48.72 83.42,48.5 83.43,48.47 83.43,48.44 83.41,48.35 83.33,48.31 83.31,48.31 83.1,48.22 83.01,48.01 83.02,47.92 83.06,47.83 83.09,47.8 82.99,47.7 82.93,47.71 82.89,47.71 82.67,47.63 82.56,47.41 82.53,47.34 82.47,47.31 82.34,47.26 82.25,47.16 82.16,47.11 82.07,47.16 81.99,47.25 81.88,47.31 81.82,47.35 81.81,47.44 81.82,47.49 81.83,47.54 81.82,47.57 81.81,47.64 81.89,47.71 81.9,47.72 82.06,47.83 82.12,48.01 82.11,48.06 82.13,48.14 82.2,48.18 82.42,48.29 82.51,48.51 82.51,48.55 82.5,48.61 82.6,48.72 82.61,48.72 82.76,48.83 82.82,49.01 82.81,49.05 82.81,49.09 82.83,49.18 82.91,49.21 82.94,49.21 83.09,49.25 83.21,49.35
GND on BOTTOM (solid shape): outline of 130 points within 71.59,109.75 75.5,113.61
GND on BOTTOM (solid shape): 194.47,27.92 194.5,27.82 194.49,27.77 194.48,27.72 194.59,27.45 194.86,27.33 195,27.36 195.12,27.44 195.19,27.46 195.26,27.44 195.38,27.37 195.51,27.34 195.71,27.4 195.85,27.54 195.93,27.59 196.01,27.57 196.51,27.07 198.02,27.07 198.25,26.84 198.06,26.65 197.8,26.65 197.64,26.59 197.57,26.43 197.57,26.14 197.56,26.11 197.52,26.09 197.17,25.71 197.52,25.33 197.56,25.32 197.57,25.28 197.57,24.98 197.61,24.85 197.71,24.77 197.78,24.7 197.75,24.6 197.31,24.17 196.76,24.17 196.44,23.85 196.29,23.85 196.24,23.88 196.25,23.94 196.31,23.99 196.33,24 196.47,24.07 196.53,24.22 196.53,24.5 196.46,24.66 196.3,24.73 196,24.73 195.89,24.7 195.8,24.62 195.76,24.57 195.69,24.64 195.69,25.9 194.5,27.1 194.49,27.11 194.36,27.33 194.12,27.42 193.99,27.39 193.87,27.33 193.8,27.3 193.73,27.33 193.68,27.37 193.63,27.4 193.59,27.41 193.59,27.49 193.68,27.49 194.13,27.94 194.2,27.93 194.24,27.93 194.31,27.93 194.37,27.95
GND on BOTTOM (solid shape): 82.16,68.9 82.25,68.85 82.35,68.75 82.5,68.7 82.57,68.67 82.59,68.58 82.59,68.52 82.68,68.3 82.89,68.19 82.91,68.19 83.02,68.09 83.01,68.01 83.1,67.79 83.31,67.7 83.35,67.71 83.44,67.66 83.45,67.56 83.43,67.49 83.42,67.42 83.5,67.19 83.72,67.09 83.78,67.06 83.81,66.99 83.81,66.96 83.79,66.88 83.71,66.85 83.47,66.75 83.37,66.52 83.38,66.48 83.38,66.44 83.37,66.36 83.29,66.31 83.26,66.31 83.21,66.33 83.21,66.38 83.24,66.46 83.25,66.54 83.15,66.78 82.92,66.87 82.84,66.91 82.82,66.98 82.82,67.01 82.78,67.16 82.66,67.27 82.66,67.33 82.55,67.45 82.56,67.51 82.56,67.55 82.47,67.78 82.23,67.88 82.22,67.88 82.14,67.91 82.12,67.99 82.12,68.01 82.08,68.16 81.96,68.27 81.96,68.33 81.87,68.42 81.89,68.49 81.89,68.52 81.89,68.57 81.88,68.61 81.88,68.68 81.93,68.73 82.01,68.78 82.07,68.85
GND on BOTTOM (solid shape): 93.9,70.13 93.97,70.11 94.04,70.1 94.09,70.11 94.17,70.08 94.21,70.01 94.3,69.79 94.51,69.7 94.59,69.71 94.73,69.57 94.74,69.52 94.71,69.48 94.66,69.48 94.59,69.5 94.51,69.51 94.21,69.21 94.51,68.9 94.55,68.91 94.6,68.92 94.69,68.9 94.73,68.82 94.73,68.8 94.69,68.72 94.6,68.7 94.55,68.71 94.51,68.71 94.3,68.62 94.21,68.41 94.21,68.39 94.17,68.31 94.09,68.28 94.04,68.29 93.99,68.28 93.95,68.27 93.85,68.29 93.82,68.38 93.82,68.41 93.73,68.62 93.51,68.71 93.45,68.71 93.37,68.73 93.33,68.8 93.23,69.03 93,69.12 92.94,69.12 92.85,69.14 92.82,69.21 92.81,69.28 92.9,69.36 92.96,69.35 93,69.35 93.21,69.43 93.33,69.63 93.37,69.7 93.45,69.71 93.48,69.71 93.51,69.7 93.73,69.79 93.82,70.01 93.81,70.09 93.87,70.15
GND on BOTTOM (solid shape): outline of 91 points within 73.17,116.56 75.27,120.99
GND on BOTTOM (solid shape): outline of 88 points within 143.08,46.59 146.56,51.09
GND on BOTTOM (solid shape): 87.71,45.31 87.76,45.24 87.86,45.02 88.09,44.93 88.1,44.93 88.18,44.9 88.21,44.82 88.21,44.81 88.19,44.77 88.14,44.76 88.11,44.76 88.07,44.77 87.84,44.67 87.74,44.44 87.74,44.4 87.71,44.31 87.61,44.3 87.56,44.31 87.51,44.31 87.34,44.26 87.23,44.12 87.18,44.07 87.11,44.06 87.08,44.06 87.04,44.06 86.81,43.97 86.71,43.73 86.71,43.71 86.67,43.63 86.58,43.61 86.55,43.61 86.51,43.61 86.36,43.57 86.25,43.47 86.25,43.46 86.1,43.31 86.04,43.33 86,43.33 85.96,43.33 85.93,43.32 85.85,43.33 85.81,43.39 85.75,43.49 85.67,43.57 85.62,43.66 85.67,43.75 85.77,43.85 85.82,43.98 85.86,44.05 85.94,44.07 86,44.06 86.23,44.16 86.33,44.39 86.32,44.47 86.38,44.53 86.41,44.52 86.46,44.51 86.51,44.5 86.72,44.58 86.82,44.78 86.86,44.85 86.95,44.87 86.99,44.85 87.04,44.85 87.27,44.95 87.37,45.18 87.37,45.25 87.43,45.31 87.51,45.3 87.57,45.31 87.62,45.32
GND on BOTTOM (solid shape): 95.83,68.29 95.91,68.28 95.99,68.25 96.07,68.24 96.13,68.24 96.18,68.25 96.27,68.23 96.31,68.14 96.31,68.11 96.34,67.97 96.43,67.87 96.47,67.8 96.44,67.72 96.38,67.62 96.36,67.51 96.37,67.43 96.21,67.3 96.15,67.31 96.11,67.31 95.9,67.22 95.81,67.01 95.81,66.98 95.78,66.89 95.7,66.86 95.61,66.86 95.53,66.88 95.49,66.95 95.38,67.16 95.16,67.25 94.98,67.19 94.86,67.04 94.84,67.02 94.75,67 94.73,67.02 94.63,67.09 94.51,67.11 94.48,67.11 94.41,67.14 94.37,67.2 94.36,67.25 94.38,67.3 94.43,67.32 94.47,67.31 94.51,67.3 94.73,67.39 94.82,67.61 94.82,67.64 94.85,67.73 94.95,67.75 95,67.73 95.06,67.73 95.09,67.73 95.17,67.7 95.21,67.62 95.21,67.61 95.73,67.39 95.51,67.91 95.49,67.91 95.41,67.94 95.39,68.03 95.41,68.1 95.45,68.11 95.51,68.1 95.66,68.14 95.77,68.25
GND on BOTTOM (solid shape): 114.06,123.68 114.06,123.54 113.75,123.23 113.75,123.21 113.71,123.13 113.63,123.11 113.6,123.11 113.4,123.11 113.31,123.08 113.27,122.99 113.27,122.6 113.29,122.55 113.32,122.5 113.32,122.33 113.29,122.28 113.27,122.22 113.27,121.86 112.81,121.4 112.81,120.07 112.58,120.07 112.54,120.06 112.5,120.04 112.44,120.01 112.38,120.03 112.36,120.04 112.31,120.04 112.26,120.07 112.28,120.13 112.34,120.19 112.36,120.19 112.43,120.24 112.46,120.32 112.46,120.7 112.42,120.79 112.33,120.83 112.13,120.83 112.11,120.82 112.05,120.8 111.99,120.86 112.08,120.96 112.13,120.95 112.33,120.95 112.42,120.99 112.46,121.08 112.46,121.46 112.45,121.52 112.41,121.57 112.36,121.64 112.39,121.72 112.43,121.76 112.43,122.13 112.54,122.24 112.57,122.23 112.64,122.22 112.71,122.21 113.17,122.67 112.71,123.13 112.41,123.01 112.26,122.72 112.19,122.63 112.08,122.66 112.05,122.73 112.08,122.8 112.17,122.93 112.19,123.07 112.16,123.23 112.07,123.35 112.06,123.39 112.07,123.43 112.1,123.46 112.18,123.49 112.25,123.45 112.39,123.34 112.56,123.3 112.83,123.41 112.97,123.75 113.04,123.78 113.96,123.78
GND on BOTTOM (solid shape): 127.79,106.44 127.78,106.37 127.77,106.32 127.88,106.07 128.13,105.97 128.37,106.06 128.48,106.3 128.55,106.39 128.66,106.36 129.88,105.14 129.88,101.63 129.83,101.54 129.73,101.54 129.65,101.57 129.56,101.58 129.52,101.58 129.44,101.56 129.04,101.97 127.79,101.97 127.02,102.74 127,102.83 127.06,102.9 127.15,102.94 127.22,103 127.29,103.03 127.36,103 127.48,102.92 127.62,102.89 127.87,102.99 127.98,103.24 127.98,103.28 127.97,103.31 127.99,103.4 128.07,103.44 128.27,103.44 128.51,103.67 128.51,104.38 128.53,104.39 128.71,104.39 128.71,104.39 128.71,103.53 128.59,103.4 128.55,103.22 128.9,102.87 129.26,103.22 129.22,103.4 129.09,103.53 129.09,104.55 128.87,104.77 128.51,104.77 128.43,104.82 128.42,104.91 128.43,104.96 128.43,105.02 128.33,105.27 128.08,105.37 128.03,105.37 127.96,105.35 127.35,105.96 127.1,105.96 127.01,106.02 127.03,106.13 127.1,106.24 127.13,106.37 127.02,106.62 126.77,106.73 126.73,106.73 126.65,106.71 126.39,106.97 126.36,107.09 126.46,107.15 127.09,107.15
GND on BOTTOM (solid shape): outline of 101 points within 99.02,18.81 110.29,24.32
GND on BOTTOM (solid shape): outline of 94 points within 174.99,17.27 178.56,22.81
GND on BOTTOM (solid shape): outline of 87 points within 197.03,16.02 200.29,21.05
GND on BOTTOM (solid shape): outline of 100 points within 52.88,102.69 54.35,107.63
GND on BOTTOM (solid shape): outline of 194 points within 143.15,32.99 146.32,37.63
GND on BOTTOM (solid shape): outline of 201 points within 37.39,14.41 43.99,17.83
GND on BOTTOM (solid shape): 118.42,112.62 118.51,112.64 118.55,112.63 118.59,112.62 118.67,112.59 118.69,112.51 118.69,112.5 118.73,112.34 118.83,112.21 118.87,112.15 118.85,112.07 118.8,111.97 118.78,111.85 118.78,111.81 118.8,111.73 118.68,111.62 118.6,111.62 118.39,111.54 118.3,111.32 118.31,111.26 118.33,111.2 118.32,111.11 118.23,111.06 117.83,111.06 117.58,110.82 117.5,110.82 117.46,110.82 117.41,110.81 117.32,110.83 117.28,110.91 117.28,110.93 117.19,111.17 116.95,111.26 116.9,111.26 116.84,111.24 116.75,111.26 116.71,111.34 116.61,111.54 116.4,111.62 116.34,111.62 116.28,111.6 116.18,111.61 116.14,111.7 116.14,111.75 116.03,112.02 115.76,112.13 115.73,112.13 115.66,112.14 115.62,112.2 115.62,112.21 115.63,112.26 115.69,112.27 115.75,112.25 115.83,112.25 116.07,112.33 116.2,112.55 116.25,112.62 116.33,112.63 116.36,112.62 116.4,112.62 116.45,112.62 116.53,112.6 116.57,112.53 116.69,112.3 116.93,112.2 117,112.21 117.06,112.23 117.16,112.22 117.2,112.13 117.2,112.12 117.29,111.91 117.5,111.82 117.71,111.9 117.81,112.11 117.81,112.13 117.9,112.22 117.97,112.21 118.02,112.2 118.27,112.3 118.38,112.54
GND on BOTTOM (solid shape): outline of 119 points within 206.69,14.46 213.46,20.11
GND on BOTTOM (solid shape): outline of 90 points within 51.2,57.28 56.91,60.73
GND on BOTTOM (solid shape): outline of 252 points within 100.63,105.69 103.91,107.5
GND on BOTTOM (solid shape): outline of 119 points within 64.11,113.9 69.46,116.35
GND on BOTTOM (solid shape): outline of 157 points within 196.66,21.06 205.4,28.92
GND on BOTTOM (solid shape): outline of 124 points within 158.93,23.57 164.85,28.65
GND on BOTTOM (solid shape): outline of 96 points within 107.16,65.16 112.27,71.3
GND on BOTTOM (solid shape): outline of 113 points within 118.7,104.65 121.05,108.51
GND on BOTTOM (solid shape): outline of 125 points within 61.85,22.08 67.93,35.36
GND on BOTTOM (solid shape): outline of 140 points within 111.39,47.04 120.89,52.04
GND on BOTTOM (solid shape): outline of 137 points within 59.69,118.45 69.77,125.39
GND on BOTTOM (solid shape): outline of 149 points within 107.74,72.87 118.69,79.45
GND on BOTTOM (solid shape): outline of 343 points within 164.81,24.9 172.24,29.83
GND on BOTTOM (solid shape): outline of 130 points within 81.17,49.11 84.23,52.24
GND on BOTTOM (solid shape): outline of 360 points within 179.63,20.9 186.69,30.1
GND on BOTTOM (solid shape): outline of 170 points within 82.19,23.52 91.54,33.02
GND on BOTTOM (solid shape): outline of 454 points within 158.79,28.68 169.32,34.54
GND on BOTTOM (solid shape): outline of 181 points within 137.83,26.92 153.01,33.15
GND on BOTTOM (solid shape): outline of 161 points within 125.15,95.31 129.88,101.66
GND on BOTTOM (solid shape): outline of 181 points within 81.93,43.36 86.22,49.46
GND on BOTTOM (solid shape): outline of 543 points within 3.24,38.72 17.25,56.48
GND on BOTTOM (solid shape): outline of 491 points within 187.13,22.26 196.02,30.41
GND on BOTTOM (solid shape): outline of 189 points within 81.84,62.59 86.48,67.14
GND on BOTTOM (solid shape): outline of 338 points within 63.64,51.63 78.63,61.95
GND on BOTTOM (solid shape): outline of 626 points within 94.42,104.81 104.11,114.92
GND on BOTTOM (solid shape): outline of 775 points within 147.1,20.13 160.29,30.55
GND on BOTTOM (solid shape): outline of 777 points within 128.93,45.66 140.94,79
GND on BOTTOM (solid shape): outline of 857 points within 113.7,14.59 135.52,28.08
GND on BOTTOM (solid shape): outline of 1090 points within 163.31,14.85 175.46,23.13
GND on BOTTOM (solid shape): outline of 1168 points within 83.47,79.1 99.85,90.99
GND on BOTTOM (solid shape): outline of 1637 points within 50.61,17.28 87.95,38.8
GND on BOTTOM (solid shape): outline of 1466 points within 108.72,99.68 121.08,112.6
GND on BOTTOM (solid shape): outline of 1925 points within 93.75,79.62 130.89,94.42
GND on BOTTOM (solid shape): outline of 1936 points within 114.23,27.85 138.95,50.76
GND on BOTTOM (solid shape): outline of 4883 points within 17.92,19.06 60.59,60.23
GND on BOTTOM (solid shape): outline of 22122 points within 60.18,33.65 115.75,88.23
GND on BOTTOM (solid shape): outline of 45532 points within 0.5,0.5 224.67,127.5
GND on SGND (solid shape): outline of 2790 points within 0.51,0.51 224.66,127.49
GND on IN1 (solid shape): 136.21,85.87 136.21,85.2 136.43,84.97 136.45,84.86 136.36,84.8 135.46,84.8 134.35,85.9 134.35,86.31 135.76,86.31
GND on IN1 (solid shape): 47.47,98.01 47.57,97.95 47.55,97.84 47.25,97.54 44.79,97.54 44.7,97.6 44.72,97.71 45.02,98.01
GND on IN1 (solid shape): 86,76.12 86.03,76.17 86.08,76.15 86.13,76.11 86.53,75.24 87.81,72.44 87.82,72.42 87.8,72.35 87.74,72.36 86,74.1
GND on IN1 (solid shape): 22.94,69.91 23,70 23.11,69.98 23.22,69.87 23.22,55.62 22.29,54.69 22.18,54.67 22.12,54.77 22.12,55.85 22.94,56.68
GND on IN1 (solid shape): 23.8,90.33 23.91,90.35 23.97,90.26 23.97,88.74 24.62,88.09 24.62,86.78 24.56,86.69 24.45,86.71 23.65,87.51 23.65,90.19
GND on IN1 (solid shape): 40.34,95.71 40.43,95.64 40.41,95.53 39.03,94.15 39.03,93.39 38.37,92.73 37.51,92.73 37.42,92.8 37.44,92.91 40.24,95.71
GND on IN1 (solid shape): 42.86,95.11 42.95,95.05 42.93,94.94 40.13,92.14 38.72,92.14 38.63,92.2 38.65,92.31 39.53,93.19 39.53,93.95 40.69,95.11
GND on IN1 (solid shape): 51.03,72.27 51.09,72.36 51.2,72.34 51.5,72.04 52.39,72.04 53.01,71.42 53.03,71.31 52.94,71.25 51.4,71.25 51.03,71.62
GND on IN1 (solid shape): 57.51,74.12 57.57,74.13 57.6,74.08 57.6,73.67 57.77,73.5 58.14,73.5 58.21,73.42 58.22,73.37 58.18,73.34 55.89,73.34 55.76,73.47 55.76,73.89 55.95,74.08 57.47,74.08
GND on IN1 (solid shape): 65.33,94.22 65.36,94.26 65.41,94.25 66.2,93.46 66.2,93.21 72.8,86.62 72.82,86.5 72.72,86.44 72.21,86.44 65.87,92.78 65.87,93.65 65.33,94.19
GND on IN1 (solid shape): 88.31,41.29 88.42,41.31 88.49,41.22 88.49,40.64 88.7,40.43 88.7,40.11 87.61,39.02 87.55,39.01 87.52,39.05 87.52,39.16 88.22,39.86 88.22,41.2
GND on IN1 (solid shape): 113.83,86.61 113.89,86.71 114,86.68 115.15,85.54 115.15,83.77 114.69,83.32 114.58,83.29 114.52,83.39 114.52,85.75 113.83,86.44
GND on IN1 (solid shape): 125.27,119.63 125.37,119.57 125.34,119.46 124.64,118.76 121.57,118.76 121.48,118.82 121.5,118.93 121.83,119.26 123.11,119.26 123.48,119.63
GND on IN1 (solid shape): 71.18,32.7 71.18,32.24 71.36,32.06 71.39,32.06 71.4,31.98 69.43,31.42 69.32,31.46 69.33,31.59 69.68,31.93 69.68,31.95 69.74,31.98 69.95,31.77 70.27,31.77 70.45,31.94 70.45,32.7 70.45,32.7 71.18,32.7
GND on IN1 (solid shape): 19.43,82.62 19.49,82.63 19.52,82.58 19.52,81.78 21.06,80.24 21.06,76.83 20.82,76.59 20.82,73.57 20.76,73.47 20.65,73.49 19.64,74.5 19.64,75.5 19.39,75.75 19.39,82.57
GND on IN1 (solid shape): 42.49,96.43 42.58,96.37 42.56,96.26 42.51,96.2 40.03,96.2 37.16,93.33 25.35,93.33 25.26,93.39 25.28,93.5 25.62,93.84 37.48,93.84 40.07,96.43
GND on IN1 (solid shape): 57.88,71.79 60.39,71.79 60.83,71.34 60.85,71.23 60.76,71.17 59.2,71.17 58.81,71.56 56.22,71.56 56.12,71.63 56.15,71.74 56.49,72.08 57.58,72.08
GND on IN1 (solid shape): 81.59,45.98 81.68,45.92 81.66,45.81 81.63,45.78 81.63,45.26 81.46,45.08 80.7,45.08 80.6,44.99 80.57,44.99 80.52,45.02 80.53,45.08 80.68,45.23 80.68,45.66 81.01,45.98
GND on IN1 (solid shape): 37.04,55.14 37.1,55.23 37.21,55.21 37.72,55.21 37.76,55.17 37.76,53.77 35.66,51.67 34.89,51.67 34.87,51.71 34.87,51.76 34.91,51.78 34.92,51.78 37.04,53.9
GND on IN1 (solid shape): 67.03,19.68 67.13,19.61 67.1,19.5 66.76,19.16 58.18,19.16 58.05,19.29 58.06,19.32 58.07,19.37 58.08,19.42 58.07,19.48 58.05,19.54 58.07,19.63 58.15,19.68
GND on IN1 (solid shape): 51.15,38.13 51.15,37.42 51.32,37.24 51.62,37.24 51.83,37.45 52,37.27 51.97,37.24 51.89,37.12 51.86,36.99 51.87,36.94 51.88,36.89 51.89,36.86 51.63,36.61 51.13,36.61 50.9,36.37 50.39,36.37 50.35,36.41 50.35,36.63 50.39,36.67 50.69,36.67 50.94,36.92 50.94,38.13 50.95,38.13 51.14,38.13
GND on IN1 (solid shape): 64.86,101.11 65.78,101.11 65.85,101.04 65.86,100.98 65.81,100.95 64.18,100.95 62.17,102.95 59.59,102.95 59.51,103.03 59.48,103.11 59.51,103.18 59.59,103.29 59.62,103.42 59.63,103.47 62.5,103.47
GND on IN1 (solid shape): 134.87,116.65 134.87,116.63 134.88,116.56 134.9,116.49 134.89,116.4 134.81,116.35 128.27,116.35 127.56,115.64 127.46,115.62 127.39,115.7 127.38,115.75 128.53,116.9 134.63,116.9
GND on IN1 (solid shape): 59.19,48.66 59.19,45.68 59.49,45.39 60.13,45.39 60.32,45.58 60.43,45.6 60.49,45.51 60.49,44.82 60.49,44.82 58.82,44.82 58.72,44.88 58.75,44.99 58.95,45.2 58.95,48.77 58.96,48.78 59.08,48.78
GND on IN1 (solid shape): 139.27,17.91 139.36,17.85 139.34,17.74 138.04,16.44 129.93,16.44 129.85,16.48 129.84,16.57 129.85,16.63 129.86,16.69 129.86,16.74 129.84,16.79 129.84,16.82 130.08,17.07 137.45,17.07 138.29,17.91
GND on IN1 (solid shape): 147.61,14.4 147.61,14.28 147.47,14.16 147.41,13.99 147.34,13.9 147.24,13.93 145.52,15.65 145.49,15.76 145.59,15.82 146.19,15.82
GND on IN1 (solid shape): 169.01,19.91 169.03,19.91 169.16,19.78 171.06,19.78 171.24,19.96 172.16,19.96 172.23,19.89 172.24,19.83 172.2,19.8 171.97,19.8 171.62,19.45 169.11,19.45 168.61,19.96 168.58,20.06 168.67,20.13 168.71,20.13 168.77,20.15
GND on IN1 (solid shape): 60.89,70.83 60.89,69.81 63.09,67.62 63.11,67.51 63.02,67.44 62.48,67.44 60.28,69.64 60.28,69.65 60.54,69.9 60.54,70.15 60.32,70.36 60.08,70.36 59.82,70.1 59.82,70.1 59.22,70.7 59.2,70.81 59.29,70.88 60.85,70.88
GND on IN1 (solid shape): 78.83,70.21 78.83,69.72 78.88,69.67 78.91,69.56 78.81,69.5 78.2,69.5 77.74,69.96 77.77,69.99 77.82,70.09 77.84,70.19 77.83,70.25 77.81,70.31 77.82,70.41 77.91,70.45 78.59,70.45
GND on IN1 (solid shape): 91.67,74.93 91.73,75.02 91.84,75 95.58,71.26 95.6,71.26 95.68,71.22 95.69,71.12 95.67,71.08 95.67,71.03 95.66,70.98 95.33,70.98 95.04,70.69 94.92,70.69 94.23,71.38 93.85,71.38 93.5,71.73 93.5,73.01 91.67,74.84
GND on IN1 (solid shape): 132.67,89.58 134.01,89.58 135,88.59 136.27,88.59 136.94,87.93 136.94,87.05 137.39,86.59 137.42,86.48 137.32,86.42 136.74,86.42 136.11,87.05 136.11,87.34 135.04,88.41 134.24,88.41 133.64,89.01 133.01,89.01 131.35,90.67 131.34,90.72 131.39,90.75 131.5,90.75
GND on IN1 (solid shape): 109.41,113.85 109.52,113.88 109.58,113.78 109.58,111.49 108.5,110.41 108.47,110.4 108.43,110.41 108.34,110.47 108.23,110.5 108.14,110.57 108.16,110.67 108.92,111.43 108.92,113.37
GND on IN1 (solid shape): 87.52,40.25 87.58,40.26 87.61,40.22 87.61,40.12 86.91,39.42 86.91,38.76 86.87,38.68 86.78,38.67 86.72,38.68 86.66,38.69 86.59,38.68 86.53,38.67 86.44,38.68 86.39,38.76 86.39,39.12
GND on IN1 (solid shape): 142.12,93.79 142.15,93.71 142.13,93.64 142.06,93.55 142.03,93.43 141.96,93.35 141.85,93.37 141.23,94 139.18,94 138.7,94.47 138.68,94.58 138.77,94.64 141.27,94.64
GND on IN1 (solid shape): 83.62,75.33 83.65,75.38 83.71,75.37 83.79,75.29 83.79,73.59 85.29,72.09 85.29,71.39 85.24,71.3 85.15,71.29 85.08,71.31 85.02,71.32 84.97,71.32 84.92,71.3 84.83,71.32 84.79,71.4 84.79,72.36 83.62,73.53
GND on IN1 (solid shape): 85.51,87.39 85.51,84.71 87.58,82.64 87.81,82.64 87.9,82.59 87.89,82.49 87.87,82.45 87.86,82.41 87.79,82.34 87.69,82.37 85.25,84.81 85.25,86.32 82.95,88.62 82.93,88.73 83.03,88.79 84.11,88.79
GND on IN1 (solid shape): 58.3,81.55 58.3,81.52 58.24,81.42 58.13,81.44 57.43,82.15 56.83,82.15 56.74,82.19 56.73,82.29 56.75,82.35 56.76,82.41 56.75,82.49 56.73,82.56 56.73,82.65 56.82,82.7 57.15,82.7
GND on IN1 (solid shape): 35.13,67.97 35.2,68.06 35.31,68.04 36.11,67.24 36.11,57.71 36.32,57.5 37.47,57.5 37.51,57.46 37.51,57.32 37.47,57.28 36.32,57.28 36.11,57.07 36.11,56.69 36.32,56.48 36.7,56.48 36.75,56.44 36.75,55.96 36.68,55.86 36.57,55.89 35.9,55.89 35.9,55.89 35.9,64.31 35.13,65.07
GND on IN1 (solid shape): 59.03,101.76 59.13,101.74 61.72,101.74 63.68,99.78 64.84,99.78 65.17,99.45 65.19,99.34 65.1,99.28 64.03,99.28 62.79,100.52 61.41,100.52 60.49,101.44 59.03,101.44 58.95,101.49 58.94,101.58 58.95,101.63 58.96,101.68
GND on IN1 (solid shape): 83.14,42.66 83.18,42.57 83.18,42.29 82.7,41.81 82.04,41.81 81.47,41.25 81.41,41.25 81.33,41.33 81.31,41.44 81.4,41.5 81.58,41.5 81.78,41.7 81.78,41.92 81.78,41.93 82.27,41.93 82.63,42.29 82.63,42.47 82.84,42.67 82.9,42.66 82.94,42.65 82.99,42.66 83.04,42.67
GND on IN1 (solid shape): 81.11,48.76 81.2,48.72 81.21,48.62 81.19,48.57 81.19,48.51 81.19,48.45 81.21,48.39 81.2,48.3 81.12,48.25 80.63,48.25 78.79,46.41 78.73,46.41 78.69,46.44 78.7,46.5 78.89,46.69 78.89,47.12 78.89,47.12 79.32,47.12 80.69,48.49 80.69,48.6 80.84,48.76
GND on IN1 (solid shape): 77.52,39.41 78.58,39.41 78.71,39.55 78.82,39.57 78.88,39.48 78.88,39.27 78.84,39.23 76.87,39.23 76.7,39.41 76.62,39.41 76.54,39.45 76.53,39.54 76.55,39.61 76.55,39.67 76.54,39.74 76.52,39.81 76.53,39.9 76.62,39.95 76.99,39.95
GND on IN1 (solid shape): 98.96,82.61 99.03,82.7 99.14,82.68 99.28,82.54 99.28,81.87 99.73,81.42 99.73,79.36 100.01,79.09 100.01,78.91 99.92,78.91 99.91,78.95 99.78,79.14 99.57,79.21 99.5,79.2 99.43,79.18 99.33,79.19 99.29,79.27 99.29,79.66 98.96,79.98
GND on IN1 (solid shape): 59,31.33 60.13,31.28 60.38,31.27 64.45,31.09 66.83,31.09 66.91,31.05 66.92,30.95 66.91,30.9 66.9,30.85 66.91,30.8 66.92,30.75 66.9,30.66 66.82,30.62 65.88,30.62 60.27,31.11 59.84,31.15 55.62,31.38 55.57,31.43 55.62,31.48 57.24,31.48
GND on IN1 (solid shape): 67.94,48.9 67.94,47.75 67.91,47.7 67.85,47.71 67.82,47.74 65.61,47.74 65.51,47.8 65.54,47.91 65.56,47.94 65.56,48.24 65.63,48.34 65.74,48.32 65.8,48.25 66.1,48.25 66.31,48.46 66.51,48.25 66.81,48.25 67.02,48.46 67.22,48.25 67.52,48.25 67.7,48.43 67.7,48.93 67.7,48.94 67.9,48.94
GND on IN1 (solid shape): 60.71,91.51 60.73,91.4 60.64,91.34 60.47,91.34 59.09,92.72 58.8,92.72 58.01,93.5 56.71,93.5 56.63,93.55 56.63,93.65 56.67,93.74 56.68,93.84 56.67,93.95 56.62,94.04 56.61,94.15 56.7,94.2 58.02,94.2
GND on IN1 (solid shape): 81.75,74.06 81.81,73.97 81.81,73.58 83.25,72.13 83.25,71.45 83.21,71.37 83.12,71.35 83.07,71.37 83.02,71.37 82.98,71.37 82.91,71.35 82.78,71.48 82.78,72.03 81.36,73.45 81.36,73.9 81.39,73.97 81.46,74 81.56,74.01 81.65,74.05
GND on IN1 (solid shape): 59.55,104.6 62.75,104.6 64.43,102.91 65.17,102.91 67.75,100.33 69.21,100.33 69.24,100.3 69.26,100.24 69.21,100.21 67.38,100.21 65.98,101.61 65.06,101.61 62.7,103.97 59.8,103.97 58.94,104.83 58.58,104.83 58.5,104.88 58.49,104.98 58.52,105.06 58.53,105.14 58.53,105.2 58.51,105.27 58.52,105.36 58.61,105.4 58.74,105.4
GND on IN1 (solid shape): 94.74,87.96 94.8,88.05 94.91,88.03 95.3,87.64 95.72,87.64 96.11,88.03 96.11,88.03 96.32,87.82 96.32,87.82 95.93,87.43 95.93,87.01 98.39,84.55 98.39,83.53 98.33,83.43 98.22,83.46 96.9,84.77 96.48,84.77 96.3,84.59 96.29,84.59 96.08,84.8 96.08,84.8 96.35,85.07 96.35,85.58 95.9,86.03 95.48,86.03 95.04,85.59 94.96,85.59 94.85,85.71 94.85,85.83 95.14,86.12 95.14,86.54 94.74,86.93
GND on IN1 (solid shape): 71.87,92.34 71.96,92.32 74.89,89.38 74.92,89.27 74.82,89.2 73.77,89.2 71.02,91.95 71.02,92.14 71.09,92.24 71.2,92.21 71.32,92.12 71.47,92.09 71.66,92.14 71.79,92.29
GND on IN1 (solid shape): 83.93,76.45 84.02,76.42 84.75,75.69 84.75,73.59 86.15,72.19 86.15,71.81 86.25,71.71 86.25,71.4 86.15,71.29 86.12,71.3 86.07,71.32 86.02,71.32 85.96,71.31 85.9,71.29 85.8,71.3 85.76,71.39 85.76,72.29 84.26,73.79 84.26,75.49 83.68,76.06 83.65,76.15 83.71,76.22 83.8,76.29 83.86,76.39
GND on IN1 (solid shape): 124.66,22.22 128.92,22.22 129,22.17 129.01,22.08 129,22.02 128.99,21.96 129,21.88 129.03,21.81 129.02,21.71 128.93,21.66 128.65,21.66 128.54,21.55 120.72,21.55 120.71,21.59 120.68,21.71 120.61,21.81 120.58,21.92 120.68,21.98 122.25,21.98 122.71,22.45 124.43,22.45
GND on IN1 (solid shape): 54.76,51.76 55.04,51.76 55.21,51.94 55.21,51.95 55.27,51.98 55.5,51.76 55.48,51.72 55.45,51.65 55.45,51.57 55.45,51.5 55.47,51.43 55.46,51.33 55.38,51.29 53.21,51.29 53.12,51.35 53.14,51.46 53.19,51.51 53.19,51.79 53.22,51.84 53.28,51.83 53.32,51.79 53.62,51.79 53.81,51.98 54.03,51.76 54.33,51.76 54.55,51.98
GND on IN1 (solid shape): 115.54,76.57 115.6,76.67 115.71,76.65 115.77,76.59 116.77,76.59 117.21,76.16 117.21,72.52 118.3,71.43 118.3,67.23 118.27,67.19 118.21,67.2 118.15,67.26 118.15,71.34 114.92,74.57 114.92,76.14 114.97,76.23 115.06,76.24 115.12,76.22 115.18,76.22 115.44,76.32 115.54,76.57
GND on IN1 (solid shape): 57.76,50 57.76,47.99 57.75,47.99 56.7,47.99 56.61,48.04 56.62,48.15 56.66,48.24 56.68,48.35 56.57,48.6 56.32,48.7 56.27,48.7 56.22,48.69 56.2,48.68 56.06,48.82 56.04,48.93 56.13,48.99 56.39,48.99 56.49,48.89 57.17,48.89 57.49,49.2 57.49,49.87 57.62,50 57.75,50
GND on IN1 (solid shape): 58.31,83.93 58.37,84.02 58.48,84 60.26,82.22 60.26,76.56 60.2,76.47 60.09,76.49 60.05,76.53 59.8,76.53 59.51,76.24 59.51,76.24 59.26,76.49 59.26,77.17 59.27,77.18 59.98,77.18 60.15,77.35 60.15,77.65 59.94,77.86 60.15,78.07 60.15,78.39 59.94,78.61 60.15,78.83 60.15,79.12 59.98,79.3 59.55,79.3 59.55,79.3 59.55,80.6 59.55,80.6 59.98,80.6 60.15,80.78 60.15,81.08 59.98,81.25 59.55,81.25 59.55,81.26 59.55,82.07 58.31,83.31
GND on IN1 (solid shape): 103.41,69.71 103.46,69.8 103.57,69.8 103.6,69.78 103.64,69.76 103.7,69.69 103.67,69.59 101.34,67.26 99.88,67.26 99.8,67.31 99.79,67.4 99.8,67.46 99.81,67.52 99.8,67.6 99.78,67.66 99.78,67.76 99.87,67.81 100.73,67.81 101.9,68.98 102.79,68.98 103.41,69.6
GND on IN1 (solid shape): 80.47,65.78 81.13,65.78 81.21,65.73 81.22,65.63 81.2,65.57 81.19,65.5 81.19,65.44 81.21,65.39 81.2,65.3 81.11,65.25 80.41,65.25 78.23,67.44 78.06,67.44 77.98,67.49 77.97,67.58 77.98,67.63 77.99,67.69 77.98,67.74 77.97,67.79 77.99,67.88 78.07,67.92 78.32,67.92
GND on IN1 (solid shape): 126.4,24.93 126.49,24.88 126.49,24.78 126.45,24.69 126.44,24.6 126.44,24.54 126.46,24.48 126.45,24.39 126.36,24.34 125.64,24.34 125.23,24.76 121.46,24.76 120.81,24.11 115.92,24.11 115.8,23.98 115.69,23.98 115.69,24.05 115.7,24.07 115.76,24.16 115.78,24.26 115.85,24.35 115.96,24.33 116,24.29 120.71,24.29 121.36,24.93
GND on IN1 (solid shape): 39.54,67.11 39.54,66.98 39.5,66.93 38.99,66.93 38.78,66.72 38.78,66.35 38.99,66.13 39.5,66.13 39.54,66.09 39.54,65.96 39.5,65.92 38.61,65.92 38.4,65.71 38.4,65.33 38.61,65.12 39.5,65.12 39.54,65.08 39.54,64.72 39.48,64.63 39.37,64.65 38.22,64.65 38.18,64.69 38.18,66.87 38.22,66.95 38.32,66.96 38.38,66.95 38.44,66.94 38.63,67 38.77,67.15 39.5,67.15
GND on IN1 (solid shape): 73.32,53.22 73.37,53.32 73.49,53.3 74.46,52.33 77.56,52.33 77.65,52.28 77.66,52.19 77.64,52.12 77.63,52.05 77.64,51.99 77.65,51.93 77.64,51.84 77.56,51.8 74.61,51.8 73.54,52.86 73.35,52.86 73.26,52.91 73.27,53.02 73.3,53.1 73.32,53.2
GND on IN1 (solid shape): 79.15,72.84 79.73,72.84 80.48,72.09 80.48,71.36 81.2,70.64 81.19,70.61 81.17,70.55 81.16,70.48 81.17,70.43 81.18,70.37 81.17,70.28 81.09,70.24 80.82,70.24 80.68,70.38 80.68,71.01 80.35,71.34 80.35,72.08 79.77,72.65 79.11,72.65 78.99,72.78 77.82,72.78 77.73,72.82 77.72,72.91 77.74,73.01 77.72,73.11 77.73,73.2 77.82,73.25 78.74,73.25
GND on IN1 (solid shape): 75.92,78.52 81.36,78.52 81.44,78.48 81.46,78.39 81.44,78.28 81.46,78.18 81.45,78.08 81.37,78.04 79.94,78.04 79.68,77.78 76.14,77.78 75.09,78.84 74.69,78.84 73.69,77.83 73.68,77.83 73.52,77.99 73.52,78 74.52,79.01 74.52,79.4 74.08,79.84 73.69,79.84 72.68,78.83 72.67,78.83 72.51,79 72.51,79 73.35,79.85 73.35,80.35 62.44,91.26 62.41,91.38 62.51,91.44 63,91.44
GND on IN1 (solid shape): 133.98,115.3 134.06,115.25 134.07,115.15 134.03,115.07 134.02,114.98 134.03,114.94 134.04,114.87 133.76,114.59 133.76,114.1 133.47,113.81 132.84,113.81 132.37,114.28 129.61,114.28 129.56,114.31 129.57,114.37 129.66,114.46 133.23,114.46 133.44,114.66 133.44,114.73 133.58,114.86 133.63,115.05 133.63,115.11 133.61,115.16 133.63,115.26 133.71,115.3
GND on IN1 (solid shape): 61.17,39.88 61.24,39.91 61.32,39.88 61.33,39.87 61.34,39.81 61.29,39.78 61.25,39.78 61.07,39.6 59.47,39.6 59.26,39.4 59.06,39.6 58.02,39.6 57.16,38.74 56.82,38.74 56.74,38.79 56.73,38.88 56.75,38.96 56.76,39.03 56.66,39.29 56.41,39.39 56.35,39.39 56.29,39.44 56.37,39.52 57.79,39.52 57.98,39.72 61,39.72
GND on IN1 (solid shape): 105.53,53.91 105.62,53.88 105.71,53.8 105.71,50.85 103.8,48.94 103.8,47.8 102.58,46.58 102.58,45.71 102.53,45.62 102.43,45.63 102.34,45.67 102.24,45.68 102.2,45.68 102.15,45.66 102.06,45.68 102.02,45.76 102.02,46.33 103.54,47.85 103.54,48.99 105.47,50.92 105.47,52.78 105.16,53.08 105.16,53.68 105.21,53.68 105.35,53.74 105.46,53.86
GND on IN1 (solid shape): 98.09,103.79 98.13,103.7 98.13,100.05 98.23,99.95 98.23,96.43 102.2,92.46 102.2,91.19 103.55,89.84 103.55,89.6 103.46,89.6 103.45,89.63 103.32,89.81 103.11,89.88 102.92,89.82 102.79,89.67 102.51,89.67 99.78,92.4 99.78,94.52 97.6,96.69 97.6,103.69 97.64,103.78 97.73,103.79 97.79,103.78 97.85,103.77 97.92,103.78 97.99,103.8
GND on IN1 (solid shape): 88.27,28.58 88.35,28.53 88.44,28.51 88.52,28.44 88.5,28.34 85.24,25.08 76.89,25.08 76.86,25.04 60.09,25.04 59.63,24.59 56.52,24.59 55.71,23.77 54.68,23.77 54.59,23.83 54.59,23.93 54.63,24.02 54.65,24.12 54.64,24.18 54.63,24.24 54.64,24.33 54.72,24.37 56.06,24.37 56.45,24.76 59.55,24.76 60.02,25.23 76.45,25.23 76.48,25.26 84.88,25.26 88.23,28.61
GND on IN1 (solid shape): 24.52,86.07 24.55,86.11 24.61,86.1 27.47,83.24 27.47,80.89 26.89,80.31 26.89,78.87 25.65,77.63 25.58,77.6 25.5,77.64 25.49,77.65 25.46,77.72 25.49,77.79 25.56,77.91 25.59,78.04 25.49,78.29 25.23,78.4 25.14,78.38 25.05,78.34 24.99,78.42 25.07,78.5 25.83,78.5 26.75,79.43 26.75,80.32 27.35,80.92 27.35,83.13 24.52,85.96
GND on IN1 (solid shape): 81.08,44.79 81.16,44.75 81.18,44.66 81.17,44.61 81.16,44.56 81.17,44.49 81.19,44.42 81.19,44.32 81.1,44.28 79.96,44.28 79.02,43.34 77.45,43.34 77.36,43.39 77.36,43.49 77.4,43.58 77.41,43.67 77.39,43.79 77.33,43.9 77.31,44 77.41,44.06 79.01,44.06 79.65,44.7 80.72,44.7 80.82,44.79
GND on IN1 (solid shape): 91.51,38.14 91.6,38.21 91.7,38.14 91.82,37.97 92.01,37.91 92.07,37.91 92.13,37.93 92.23,37.92 92.27,37.84 92.27,37.05 90.56,35.34 90.23,34.56 88.49,32.82 88.4,32.82 88.4,32.89 88.41,32.9 88.48,33.01 88.51,33.14 88.51,33.19 88.5,33.24 88.51,33.33 88.59,33.37 88.76,33.37 90.07,34.68 90.72,36.25
GND on IN1 (solid shape): 128.59,90.41 128.67,90.37 128.68,90.27 128.67,90.22 128.66,90.16 128.77,89.9 129.02,89.8 129.21,89.85 129.34,90 131.08,90 131.73,89.35 131.76,89.23 131.66,89.17 128.86,89.17 127.98,90.04 128,90.11 128,90.16 128,90.22 127.98,90.27 128,90.37 128.08,90.41
GND on IN1 (solid shape): 149.72,15 165.18,15 167.75,12.42 167.78,12.31 167.68,12.25 167.58,12.25 165.48,14.36 155.3,14.36 153.77,12.83 148.33,12.83 147.74,13.43 147.71,13.53 147.8,13.6 148.03,13.72 148.12,13.96 148.06,14.15 147.92,14.28 147.92,14.53 146.46,15.98 146.44,16.09 146.54,16.15 148.56,16.15
