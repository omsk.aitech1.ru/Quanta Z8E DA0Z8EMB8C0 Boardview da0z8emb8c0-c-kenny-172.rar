# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
H_THRMDC1: length 162.7
  TOP w0.102: v1(100.81,78.81) 101.07,78.81 101.18,78.7 C96270.2 ; v2(51.62,97.58) 50.16,97.58 49.2,96.63 44.63,96.63 43.04,95.03 v2(24.83,95.03) v2(23.83,95.03)
  IN1 w0.089: v2(23.83,95.03) 19.53,90.73 19.53,86.36 20.64,85.25 20.64,83.79 20.12,83.28 19.89,83.28 19.24,82.63 19.24,75.69 19.49,75.44 19.49,74.44 21.4,72.54 21.4,71.63 22.79,70.23 22.79,56.74 21.97,55.91 21.97,50.86 21.39,50.28 17.33,50.28 16.75,49.69 16.75,43.24 18.48,41.52 18.48,39.26 19.13,38.61 19.13,38.08 v2(18.86,37.81)
  IN2 w0.089: v2(51.62,97.58) 53.93,99.9 59.4,99.9 60.69,98.6 62.55,98.6 65.47,95.68 66.69,95.68 67.56,94.81 67.56,93.3 73.03,87.83 79.6,87.83 83.25,84.19 83.25,83.49 87.13,79.61 87.13,79.05 88.99,77.19 88.99,77.19 89.63,76.56 91.23,76.56 92.06,77.39 97.42,77.39 97.74,77.08 98.85,77.08 100.59,78.81 v1(100.81,78.81)
  BOTTOM w0.102: v1(100.81,78.81) 101.33,78.81 101.55,79.03 Q6544.1 ; v2(18.86,37.81) 19.06,37.61 U5400.3
HDMI_ALS_PD: length 2.3
  BOTTOM w0.102: U26.12 21.06,74.92 21.18,74.79 21.52,74.79 v2(21.68,74.64) 22.16,74.15 R2711.1
HDMI_HPD: length 14.2
  TOP w0.102: v2(17.46,89.14) 17.31,88.98 R93.2 16.47,88.98 16.44,89.02 VC1.1 15.69,89.27 R98.2
  IN1 w0.089: v2(17.46,89.14) 17.97,88.63 17.97,85.71 19.39,84.29 19.39,83.94 17.97,82.53 v2(17.97,79.74)
  BOTTOM w0.102: v2(17.97,79.74) 18.04,79.67 U26.25
HDMI_HPD_C: length 12.5
  TOP w0.102: R98.1 14.16,89.27 14.02,89.13 v2(14.02,88.89) C183.1
  IN1 w0.089: v2(14.02,88.89) 14.02,83.88 12.04,81.89 11.24,81.89 CN4.19
  BOTTOM w0.102: v2(14.02,88.89) 14.16,88.89 v2(14.54,89.27)
HDMI_HPD_PCH: length 10.4
  BOTTOM w0.102: TP8530.1 97.85,100.32 99.76,102.22 99.76,104.48 100.45,105.17 100.8,105.17 100.9,105.07 101.2,105.07 101.29,105.15 101.53,105.15 101.61,105.07 101.89,105.07 102.07,105.24 102.92,105.24 U2029.AU25
HDMI_HPD_Q: length 97.7
  IN1 w0.089: v2(25.46,87.24) 26.73,87.24 28.28,88.78 29.44,88.78 31.25,90.59 41.16,90.59 45.43,94.86 47.26,94.86 50.4,98 53.25,98 53.72,98.48 56.01,98.48 56.4,98.87 59.29,98.87 60.66,97.5 61.79,97.5 62.77,96.53 63.8,96.53 65.57,94.75 65.57,94.3 66.35,93.52 66.35,93.27 72.93,86.69 80.11,86.69 82.48,84.31 82.48,83.17 85.79,79.87 85.79,79.49 89.47,75.81 89.47,75.42 90.49,74.41 90.78,74.41 92.52,72.67 92.52,71.71 93.79,70.43 v1(94.04,70.43)
  BOTTOM w0.102: v2(25.46,87.24) 25.46,84.19 23.81,82.54 23.81,80.73 23.33,80.25 23.18,80.25 22.6,79.67 U26.3 ; v1(94.04,70.43) 93.94,70.43 U2030.G13
HDMI_SCLK: length 21.6
  TOP w0.102: C239.1 21.15,87.47 20.16,86.47 v2(19.87,86.47) 18.35,86.47 18.22,86.35 18.22,85.84 18.73,85.33 18.73,84.72 18.6,84.6 R163.2 v2(18.35,84.11) 18.35,83.44 D3.2
  IN1 w0.089: v2(18.35,84.11) 17.89,83.65 14.24,83.65 11.84,81.25 11.64,81.25 10.98,80.59 10.98,79.63 CN4.15
  BOTTOM w0.102: v2(18.35,84.11) 18.35,82.97 19.45,81.86 U26.28
HDMI_SDATA: length 21.6
  TOP w0.102: C249.1 19.72,85.57 19.72,85.2 19.85,85.08 20.23,85.08 v2(20.36,84.95) 20.36,84.7 20.26,84.6 R164.2 19.24,84.36 v2(18.98,84.11) 19.24,83.86 19.24,83.44 D4.2
  IN1 w0.089: CN4.16 11.95,78.85 12.13,78.85 12.25,78.98 12.25,81.22 14.36,83.32 18.2,83.32 v2(18.98,84.11)
  BOTTOM w0.102: v2(18.98,84.11) 18.73,83.86 18.73,83.08 19.85,81.95 U26.29
HDT_APU_TDI: length 2.4
  BOTTOM w0.102: CN2021.6 112.46,49.14 111.82,48.5 R12315.1
HDT_DBREQ#: length 2
  BOTTOM w0.102: 113.85,42.79 112.23,42.79 112.2,42.81 R567.1
HDT_TRST#: length 4.3
  BOTTOM w0.102: R12316.2 120.33,48.63 120.15,48.45 120.15,47.13 119.9,46.87 119.52,46.87 119.24,46.6 CN2021.9
HP-L2: length 18.5
  IN2 w0.381: v2(207.17,35.67) 206.06,34.56 206.06,29.96 206.82,29.2 206.82,26.76 v2(207.94,25.64)
  BOTTOM w0.203: C333.2 208.79,35.96 R248.2 209.89,35.96 210.12,36.18 R249.1 210.37,36.21 210.37,37.46 R238.2 ; U30.32 207.52,26.06 v2(207.94,25.64)
  BOTTOM w0.381: v2(207.17,35.67) 207.39,35.67 207.94,35.13 C333.2
HP-L3: length 5.3
  BOTTOM w0.203: R238.1 211.26,37.59 211.26,38.59 C327.2
  BOTTOM w0.305: CN6.4 212.29,41.4
  BOTTOM w0.381: C327.2 v2(211.27,39.61) 211.27,40.38 212.29,41.4
HP-R2: length 18.7
  IN2 w0.381: v2(207.33,36.56) 206.81,36.56 205.17,34.92 205.17,29.58 205.93,28.82 205.93,26.45 206.51,25.87 206.89,25.87 v2(207.25,25.51)
  BOTTOM w0.203: v2(207.25,25.51) 207.11,25.66 U30.33 ; v2(207.33,36.56) 207.71,36.94 R224.1 208.49,37.35 R232.2 ; R227.2 206.66,36.94
  BOTTOM w0.381: v2(207.33,36.56) 207.04,36.27 C334.2 206.44,36.72 206.66,36.94
HP-R3: length 6.9
  BOTTOM w0.203: R232.1 209.48,37.59 209.48,38.59 C323.2
  BOTTOM w0.305: CN6.2 212.4,42.4
  BOTTOM w0.381: 212.4,42.4 v2(209.48,39.48) 209.48,38.6 C323.2
HP_JD#: length 24.9
  IN3 w0.381: v2(211.77,37.07) 211.8,37.04 212.63,37.04 213.29,37.71 213.29,39.99 212.43,40.85 211.75,40.85 210.75,39.86 210.25,39.86 209.74,39.36 209.74,38.98 208.21,37.45 206.82,37.45 206.31,36.94 206.31,34.4 203.81,31.9 202.16,31.9 201.36,31.1 v2(201.36,30.72)
  BOTTOM w0.305: v2(211.77,37.07) 211.94,36.9 CN6.13
  BOTTOM w0.381: v2(201.36,30.72) 201.11,30.97 R715.2
HSYNC: length 16.7
  TOP w0.102: R2214.2 122.49,120.51 122.34,120.36 122.34,119.39 122.46,119.27 R2221.2 122.74,118.96 122.36,118.58 120.87,118.58 120.52,118.22 119.28,118.22 115.36,114.31 115.36,112.2 115.24,112.08 114.54,112.08 114.18,111.72 114.18,111.47 v2(113.68,110.96)
  BOTTOM w0.102: U2029.W34 113.24,110.52 v2(113.68,110.96)
HUB_USB3_N: length 4.1
  BOTTOM w0.102: U2033.15 95.21,88.98 95.08,89.11 94.58,89.11 93.91,89.78 92.52,89.78 TP9086.1
HUB_USB3_P: length 6.1
  BOTTOM w0.102: TP9085.1 91.48,90.01 94,90.01 94.67,89.34 95.38,89.34 95.71,89.01 U2033.16
HWPG: length 17.9
  TOP w0.102: U13.21 164.25,20.16 163.86,19.77 R369.1 R336.2 159.93,19.77 159.45,19.29 D9.2 D11.2 D8.2 D12.2 D8514.2
HWPG_1.5V: length 50.4
  TOP w0.102: PR6416.2 PR284.2 v2(195.84,30.82)
  TOP w0.203: v2(161.61,18.84) R336.1
  IN2 w0.089: v2(195.84,30.82) 195.84,30.79 196.28,30.36 196.28,29.7 194.37,27.8 194.37,27.42 194.52,27.27 194.52,24.43 193.5,23.41 193.5,21.18 192.63,20.31 190.67,20.31 188.29,22.69 187.4,22.69 187.23,22.52 184.01,22.52 180.3,18.81 179.48,18.81 178.18,20.12 177.26,20.12 176.01,21.37 171.54,21.37 170.05,19.89 165.16,19.89 164.56,19.29 164.15,19.29 164.02,19.42 163.13,19.42 162.75,19.04 162.75,18.66 162.49,18.4 162.04,18.4 v2(161.61,18.84)
HWPG_1.8VS5: length 132.9
  TOP w0.102: PR9283.2 43.24,22.08 41.72,20.56 41.72,18.05 v2(41.69,18.02) ; D11.1 156.71,13.27 v1(156.53,13.45)
  TOP w0.203: PR9283.2 43.43,23.76 43.75,24.09 43.75,25.41 43.62,25.54 PR9290.2
  IN1 w0.089: v2(41.69,18.02) 41.72,18.02 42.73,19.04 52.33,19.04 53.31,20.01 67.28,20.01 68.3,21.03 90.81,21.03 91.97,22.19 98.38,22.19 98.61,21.96 99.5,21.96 105.73,15.73 114.39,15.73 114.47,15.65 115.93,15.65 116.04,15.76 138.49,15.76 139.86,17.13 141.79,17.13 142.09,16.84 142.09,16.31 142.94,15.45 145.22,15.45 148.37,12.31 154.14,12.31 155.28,13.45 v1(156.53,13.45)
HWPG_VDDPS5: length 39.3
  TOP w0.102: v2(145.98,28.97) 145.73,28.71 145.73,25.09 146.5,24.32 146.5,23.57 146.89,23.18 146.89,20.2 146.27,19.57 146.27,14.39 147.73,12.92 150.41,12.92 150.76,13.27 D8514.1
  IN1 w0.089: v2(145.43,44.54) 145.43,41.56 145.65,41.34 145.65,34.45 146.28,33.82 146.28,30.03 145.98,29.74 v2(145.98,28.97)
  BOTTOM w0.203: PR2000.2 146.18,44.84 PR2004.2 145.67,44.79 v2(145.43,44.54)
HWPG_VDDR: length 178
  TOP w0.102: D12.1 152.99,13.27 152.42,12.7 147.64,12.7 146.04,14.29 146.04,19.7 146.66,20.32 146.66,23.08 146.27,23.48 146.27,24.23 145.5,24.99 145.5,28.05 v2(144.59,28.97)
  IN1 w0.089: v2(144.59,28.97) 144.21,28.97 138.68,34.49 138.68,35.63 132.86,41.45 129.55,41.45 127.38,43.63 127.38,46.66 126.05,47.99 126.05,63.36 124.9,64.5 124.9,67.44 118.3,74.04 118.3,76.55 116.39,78.47 116.39,79.86 115.55,80.7 115.55,82.26 v2(115.15,82.66)
  IN3 w0.089: v2(115.15,82.66) 114.43,83.39 114.43,88.03 114.53,88.13 114.53,89.03 110.54,93.02 107.48,93.02 106.51,93.99 106.51,97.95 105.03,99.43 102.14,99.43 101.1,100.48 101.1,101.48 99.32,103.26 99.32,110.72 99.06,110.98 99.06,114.1 96.13,117.02 94.01,117.02 92.66,118.37 92.66,122.42 91.8,123.28 89.57,123.28 89.41,123.45 88.54,123.45 88.35,123.26 87.81,123.26 v2(87.04,124.02)
  BOTTOM w0.102: v2(87.04,124.02) 86.74,124.02 86.53,123.82 78.13,123.82 76.1,125.84 71.17,125.84 70.67,125.35 70.67,124.55 69.45,123.33 69.45,122.95 68.24,121.74 67.67,121.74 67.02,122.39 PR128.2 PR131.2
ICMNT: length 72.3
  TOP w0.102: U13.67 182.37,16.56 182.69,16.24 C457.2 183.74,15.83 183.96,15.61 187.57,15.61 188.1,16.13 188.1,17.08 188.78,17.77 188.78,18.66 188.18,19.27 188.18,20.92 188.05,21.05 188.05,22.75 187.64,23.16 v1(186.98,23.16)
  TOP w0.254: PC235.2 138.39,34.19 138.04,34.54 v2(138.04,34.55)
  IN3 w0.089: v2(138.04,34.55) 138.64,34.55 143.56,29.63 147.59,29.63 148.77,28.45 152.73,28.45 153.29,29.01 155.93,29.01 156.52,28.41 158.19,28.41 158.48,28.7 162.66,28.7 164.11,27.25 166.32,27.25 166.87,26.7 171.88,26.7 174.09,24.5 177.13,24.5 177.78,23.84 182.96,23.84 184.1,22.7 186.48,22.7 186.93,23.16 v1(186.98,23.16)
  BOTTOM w0.198: PR249.2 137.72,34.86 138.03,34.55 v2(138.04,34.55)
IDCHG_R: length 60.2
  TOP w0.102: v2(164.65,30.97) 165.42,30.21 165.96,30.21 166.33,29.85 166.33,29.15 166.59,28.88 168.29,28.88 168.76,28.41 168.76,27.99 169.31,27.44 169.31,26.2 168.72,25.61 168.72,25.16 168.51,24.95 168.51,24.25 171.42,21.35 174.26,21.35 177.56,18.05 178.93,18.05 179.49,17.48 179.49,17.25 179.78,16.96 U13.68 182.51,16.96 C453.2
  TOP w0.254: PC73.2 137.71,33.34 v2(138.47,33.34)
  IN2 w0.089: v2(138.47,33.34) 139.96,33.34 142.47,35.84 144.82,35.84 145.57,36.59 154.22,36.59 155.19,35.62 156.08,35.62 156.85,34.85 157.84,34.85 159.76,32.93 159.76,32.72 160.31,32.17 163.46,32.17 v2(164.65,30.97)
  BOTTOM w0.198: v2(138.47,33.34) 138.47,33.54 138.15,33.86 PR250.2
ILIM_HI: length 2.2
  TOP w0.102: U7.16 16.83,47.88 16.7,47.75 R235.2
ILIM_LO: length 1.9
  TOP w0.102: U7.15 17.34,48.38 17.24,48.27 R223.2
IN_CLK: length 117.4
  TOP w0.102: v2(25.03,76.13) 24.82,75.92 24.54,75.92 24.42,76.05 C2743.1
  IN1 w0.089: v2(25.03,76.13) 25.24,75.91 25.46,75.91 25.77,76.22 25.77,77.54 27.04,78.81 27.04,80.25 27.62,80.83 27.62,83.3 24.77,86.15 24.77,88.15 24.12,88.8 24.12,90.3 25.81,91.99 28.7,91.99 29.21,91.48 29.68,91.48 30.18,91.99 40.19,91.99 44.91,96.71 47.48,96.71 50,99.24 52.74,99.24 52.89,99.39 52.89,99.39 53.21,99.71 55.5,99.71 55.89,100.1 59.91,100.1 60.83,99.18 62.21,99.18 63.46,97.93 64.27,97.93 67.68,94.53 67.68,93.68 73.44,87.92 80.62,87.92 83.72,84.83 83.72,84.44 87.8,80.36 87.8,79.38 89.6,77.58 90.77,77.58 92.12,76.24 92.12,75.22 95.73,71.61 96.49,71.61 97,71.11 100.39,71.11 100.73,70.77 102.34,70.77 v1(102.56,70.98)
  BOTTOM w0.102: v1(102.56,70.98) 102.55,70.98 102.39,70.82 101.26,70.82 100.94,70.51 U2030.F4
IN_CLK#: length 117.4
  TOP w0.102: v2(25.03,75.49) 24.82,75.7 24.52,75.7 24.42,75.6 C2742.1
  IN1 w0.089: v1(102.56,70.35) 102.34,70.57 100.64,70.57 100.31,70.9 96.91,70.9 96.4,71.41 95.64,71.41 91.92,75.13 91.92,76.15 90.69,77.38 89.51,77.38 87.6,79.3 87.6,80.28 83.51,84.36 83.51,84.74 80.54,87.72 73.36,87.72 67.48,93.6 67.48,94.45 64.19,97.73 63.37,97.73 62.13,98.98 60.74,98.98 59.82,99.9 55.97,99.9 55.58,99.5 53.29,99.5 52.98,99.19 52.82,99.03 50.09,99.03 47.56,96.51 44.99,96.51 40.28,91.79 30.27,91.79 29.76,91.28 29.13,91.28 28.62,91.79 25.89,91.79 24.32,90.21 24.32,88.89 24.97,88.23 24.97,86.23 27.82,83.38 27.82,80.75 27.24,80.17 27.24,78.73 25.97,77.46 25.97,76.13 25.55,75.71 25.24,75.71 v2(25.03,75.49)
  BOTTOM w0.102: v1(102.56,70.35) 102.3,70.61 101.98,70.61 101.56,70.19 101.29,70.19 101.19,70.29 101.19,70.44 101.26,70.51 U2030.F2
IN_D0: length 115
  TOP w0.102: v2(25.23,78.04) 25.02,77.83 24.72,77.83 24.59,77.96 C2737.1
  IN1 w0.089: v1(101.28,71.41) 100.99,71.7 100.47,71.7 100.28,71.89 99.06,71.89 98.78,72.17 95.99,72.17 94.68,73.49 94.68,73.76 92.52,75.93 92.52,76.7 90.49,78.73 90.49,79.49 90.06,79.91 90.06,80.42 89.6,80.89 87.83,80.89 84.11,84.61 84.11,84.99 80.78,88.31 75.82,88.31 75.29,88.85 73.63,88.85 70.67,91.81 70.67,92.46 64.81,98.33 63.62,98.33 62.37,99.57 60.99,99.57 60.07,100.49 55.69,100.49 55.3,100.1 53.05,100.1 52.73,99.78 52.58,99.63 49.83,99.63 47.4,97.19 44.84,97.19 42.9,95.26 40.63,95.26 39.38,94.01 39.38,93.25 38.52,92.38 25.65,92.38 23.51,90.25 23.51,87.45 24.38,86.58 24.38,85.9 27.21,83.07 27.21,80.98 26.6,80.38 26.6,79.49 25.77,78.65 25,78.65 24.6,78.24 24.6,77.92 24.77,77.75 24.95,77.75 v2(25.23,78.04)
  BOTTOM w0.102: U2030.F3 100.88,70.88 100.75,70.88 100.65,70.98 100.65,71.11 100.95,71.41 v1(101.28,71.41)
IN_D0#: length 115.1
  TOP w0.102: C2736.1 24.59,77.49 24.72,77.61 25.02,77.61 v2(25.23,77.41)
  IN1 w0.089: v1(101.28,72) 101.19,71.91 100.56,71.91 100.37,72.1 99.15,72.1 98.87,72.38 96.07,72.38 94.88,73.57 94.88,73.85 92.72,76.01 92.72,76.78 90.69,78.81 90.69,79.57 90.26,80 90.26,80.51 89.68,81.09 87.92,81.09 84.31,84.69 84.31,85.07 80.87,88.52 75.91,88.52 75.37,89.06 73.71,89.06 70.88,91.89 70.88,92.55 64.89,98.53 63.7,98.53 62.46,99.78 61.08,99.78 60.15,100.7 55.6,100.7 55.21,100.3 52.96,100.3 52.64,99.99 52.49,99.83 49.75,99.83 47.31,97.4 44.75,97.4 42.81,95.46 40.54,95.46 39.18,94.09 39.18,93.33 38.44,92.59 25.56,92.59 23.3,90.33 23.3,87.36 24.17,86.49 24.17,85.81 27.01,82.98 27.01,81.06 26.4,80.46 26.4,79.57 25.68,78.85 24.92,78.85 24.4,78.33 24.4,77.84 24.68,77.55 25.09,77.55 v2(25.23,77.41)
  BOTTOM w0.102: v1(101.28,72) 100.91,71.62 100.72,71.62 U2030.E4
IN_D1: length 114.3
  TOP w0.102: C2739.1 24.67,79.88 24.8,79.75 25.07,79.75 v2(25.28,79.96)
  IN1 w0.089: v2(25.28,79.96) 25.05,79.73 24.87,79.73 24.73,79.87 24.73,80.28 26.1,81.65 26.1,83.33 23.78,85.65 23.78,86.25 22.74,87.29 22.74,90.33 25.4,92.98 37.3,92.98 40.17,95.85 42.65,95.85 44.96,98.16 47.52,98.16 49.59,100.23 52.33,100.23 52.48,100.38 52.8,100.7 55.01,100.7 55.41,101.09 60.34,101.09 61.26,100.17 62.64,100.17 63.89,98.93 65.06,98.93 69.59,94.39 70.09,94.39 75.03,89.45 75.53,89.45 76.07,88.91 81.03,88.91 81.6,88.34 82.74,88.34 84.9,86.18 84.9,84.66 87.88,81.69 90,81.69 92.44,79.24 92.44,77.91 93.11,77.24 93.11,76.19 95.31,73.99 95.31,73.77 96.28,72.81 99.04,72.81 99.34,72.5 101.37,72.5 101.85,72.03 102.41,72.03 102.55,71.89 v1(102.55,71.74)
  BOTTOM w0.102: U2030.E1 101.81,71.92 101.94,72.04 102.25,72.04 v1(102.55,71.74)
IN_D1#: length 114.4
  TOP w0.102: v2(25.28,79.33) 25.07,79.54 24.78,79.54 24.67,79.43 C2738.1
  IN1 w0.089: v2(25.28,79.33) 25.08,79.53 24.78,79.53 24.52,79.79 24.52,80.36 25.89,81.73 25.89,83.25 23.58,85.56 23.58,86.17 22.54,87.2 22.54,90.41 25.31,93.18 37.22,93.18 40.09,96.06 42.57,96.06 44.87,98.36 47.43,98.36 49.5,100.43 52.24,100.43 52.4,100.58 52.71,100.9 54.93,100.9 55.32,101.29 60.43,101.29 61.35,100.37 62.73,100.37 63.97,99.13 65.14,99.13 69.67,94.6 70.17,94.6 75.11,89.65 75.62,89.65 76.16,89.11 81.12,89.11 81.69,88.54 82.82,88.54 85.1,86.26 85.1,84.75 87.96,81.89 90.08,81.89 92.64,79.33 92.64,78 93.32,77.33 93.32,76.28 95.52,74.08 95.52,73.86 96.36,73.01 99.12,73.01 99.43,72.71 101.46,72.71 101.93,72.23 102.41,72.23 v1(102.55,72.38)
  BOTTOM w0.102: U2030.C1 101.96,72.26 102.43,72.26 v1(102.55,72.38)
IN_D2: length 116
  TOP w0.102: v2(24.64,82.02) 24.5,81.87 24.32,81.87 C2741.1
  IN1 w0.089: v2(24.64,82.02) 24.74,81.93 25,81.93 25.21,82.13 25.21,83.01 21.83,86.39 21.83,90.55 25.47,94.19 37.33,94.19 39.93,96.78 42.45,96.78 44.75,99.08 47.31,99.08 49.25,101.03 52,101.03 52.15,101.18 52.47,101.5 54.68,101.5 55.08,101.89 57.17,101.89 57.6,102.32 59.05,102.32 59.28,102.09 61.86,102.09 63.82,100.13 64.98,100.13 69.78,95.34 70.39,95.34 75.47,90.25 75.87,90.25 76.4,89.71 81.38,89.71 81.95,89.14 84.26,89.14 85.86,87.53 85.86,84.86 87.73,82.99 89.27,82.99 89.77,82.49 91.08,82.49 93.86,79.7 93.86,78.01 94.3,77.58 94.3,76.16 96.12,74.33 96.12,74.1 96.6,73.62 99.65,73.62 99.81,73.47 100.31,73.47 100.94,74.1 101.67,74.1 v1(101.81,74.25)
  BOTTOM w0.102: v1(101.81,74.25) 101.68,74.12 100.93,74.12 100.36,73.55 100.36,72.9 99.74,72.28 U2030.E6
IN_D2#: length 116
  TOP w0.102: v2(24.64,81.39) 24.37,81.66 24.16,81.66 24.04,81.53 C2740.1
  IN1 w0.089: v2(24.64,81.39) 24.83,81.57 24.83,81.64 24.91,81.72 25.09,81.72 25.41,82.05 25.41,83.09 22.03,86.47 22.03,90.46 25.56,93.99 37.42,93.99 40.01,96.58 42.53,96.58 44.84,98.88 47.39,98.88 49.34,100.82 52.08,100.82 52.23,100.98 52.55,101.29 54.77,101.29 55.16,101.69 57.26,101.69 57.69,102.12 58.96,102.12 59.19,101.89 61.78,101.89 63.74,99.93 64.9,99.93 69.7,95.13 70.31,95.13 75.39,90.05 75.78,90.05 76.32,89.51 81.3,89.51 81.87,88.94 84.17,88.94 85.66,87.45 85.66,84.77 87.64,82.79 89.18,82.79 89.69,82.28 91,82.28 93.66,79.62 93.66,77.93 94.09,77.5 94.09,76.08 95.92,74.25 95.92,74.02 96.52,73.42 99.57,73.42 99.72,73.27 100.39,73.27 101.03,73.9 101.69,73.9 101.84,73.75 v1(101.84,73.66)
  BOTTOM w0.102: v1(101.84,73.66) 101.59,73.9 101.02,73.9 100.58,73.46 100.58,72.81 100.26,72.5 100.26,72.38 100.38,72.26 100.38,72.11 100.26,72 100.13,72 U2030.D5
INT_AMIC-VREFO: length 3.7
  BOTTOM w0.203: U30.27 206.92,28.06 207.55,28.69 v2(207.73,28.69) R686.2 208.5,29.29 208.33,29.46 C620.1
INT_EDP_AUXN: length 63.6
  IN1 w0.089: v2(54.13,102.46) 54.34,102.68 54.34,102.84 54.64,103.14 56.97,103.14 57.07,103.03 59.3,103.03 59.53,102.81 62.11,102.81 64.11,100.8 65.73,100.8 69.02,97.51 69.02,97.29 69.93,96.38 70.83,96.38 76.83,90.38 81.66,90.38 82.19,89.86 85.71,89.86 86.55,89.01 90.65,89.01 92.01,87.65 92.01,84.53 92.14,84.41 92.14,82.38 95.06,79.46 95.06,77.84 96.07,76.82 96.07,75.35 96.19,75.24 96.31,75.24 v1(96.5,75.43)
  BOTTOM w0.089: U2030.B9 97.01,72.91 97.01,73.82
  BOTTOM w0.102: v1(96.5,75.43) 96.78,75.16 96.92,75.16 97.16,74.92 97.16,73.97 97.01,73.82 ; C43.2 54.39,103.27 54.53,103.12 54.53,102.87 54.39,102.73 54.39,102.73 v2(54.13,102.46)
INT_EDP_AUXN_C: length 4.4
  BOTTOM w0.102: C43.1 54.38,103.72 54.51,103.84 54.51,105.37 54.38,105.49 R18.1 54.04,105.65 54.46,106.07 54.46,106.37 54.22,106.61 CN2.22
INT_EDP_AUXP: length 63.6
  IN1 w0.089: v2(54.76,102.46) 54.54,102.68 54.54,102.75 54.72,102.93 56.88,102.93 56.98,102.83 59.22,102.83 59.45,102.6 62.03,102.6 64.03,100.6 65.65,100.6 68.82,97.43 68.82,97.21 69.85,96.18 70.75,96.18 76.74,90.18 81.58,90.18 82.1,89.65 85.62,89.65 86.46,88.81 90.56,88.81 91.81,87.57 91.81,84.45 91.93,84.32 91.93,82.3 94.85,79.38 94.85,77.75 95.87,76.74 95.87,75.27 96.1,75.03 96.31,75.03 v1(96.5,74.84)
  BOTTOM w0.089: U2030.D9 97.01,72.46 96.71,72.77 96.71,73.04 96.81,73.14 96.81,73.93
  BOTTOM w0.102: 96.81,73.93 96.95,74.06 96.95,74.83 96.91,74.86 96.83,74.94 96.61,74.94 v1(96.5,74.84) ; v2(54.76,102.46) 54.76,103.14 54.89,103.27 C53.2
INT_EDP_AUXP_C: length 4.4
  BOTTOM w0.102: CN2.23 54.72,106.59 54.67,106.54 54.67,106.03 54.8,105.9 54.93,105.9 55.18,105.65 R22.1 54.85,105.49 54.72,105.37 54.72,103.9 54.91,103.72 C53.1
INT_EDP_TXN0: length 86
  IN1 w0.089: v2(52.79,102.36) 52.93,102.5 52.93,103.14 52.82,103.25 52.82,104.16 53.83,105.17 55.82,105.17 56.31,104.68 58.88,104.68 59.74,103.82 62.64,103.82 65,101.46 65.92,101.46 67.32,100.06 69.13,100.06 75.21,93.97 79.3,93.97 79.51,93.77 79.51,92.41 79.6,92.32 80.02,92.32 80.11,92.41 80.11,93.77 80.32,93.97 80.9,93.97 81.11,93.77 81.11,92.06 81.2,91.97 81.62,91.97 81.71,92.06 81.71,93.77 81.92,93.97 82.5,93.97 82.71,93.77 82.71,92.82 82.8,92.73 83.22,92.73 83.31,92.82 83.31,93.77 83.52,93.97 84.1,93.97 84.39,93.69 84.39,90.58 84.52,90.45 85.05,90.45 85.14,90.54 85.14,93.7 85.41,93.97 85.97,93.97 86.22,93.73 86.22,91.28 87.85,89.65 90.88,89.65 93.2,87.33 93.2,84.81 96.15,81.86 96.15,78.05 97.69,76.51 97.69,76.02 97.68,75.89 v2(97.9,75.67)
  BOTTOM w0.102: U2030.A8 97.51,73.46 97.71,73.66 97.71,75.48 v2(97.9,75.67) ; C537.2 52.35,104.66 52.48,104.54 52.48,103.6 52.96,103.12 52.96,102.53 v2(52.79,102.36)
INT_EDP_TXN0_C: length 2.5
  BOTTOM w0.102: CN2.19 52.72,106.71 52.75,106.68 52.75,106.5 52.48,106.23 52.48,105.27 52.33,105.11 C537.1
INT_EDP_TXN1: length 85.8
  IN1 w0.089: v2(50.97,101.92) 51.07,101.92 51.23,102.09 51.23,103.46 53.63,105.85 56.12,105.85 56.22,105.75 58.89,105.75 59.69,104.95 62.89,104.95 64.57,103.26 65.31,103.26 67.9,100.68 69.36,100.68 75.46,94.57 86.32,94.57 86.68,94.22 87.02,94.22 87.37,94.57 87.79,94.57 88.2,94.16 88.2,93.81 86.82,92.43 86.82,91.57 87.22,91.17 87.91,91.17 88.12,91.37 88.12,91.6 87.87,91.85 87.87,92.64 88.75,93.52 89.1,93.52 89.49,93.13 89.49,92.84 89.03,92.37 89.03,92.11 89.15,91.98 89.48,91.98 90.27,92.77 90.92,92.77 92.83,90.86 92.83,90.56 92.46,90.19 92.46,90.07 92.76,89.77 92.88,89.77 93.25,90.14 93.55,90.14 94.59,89.1 94.59,86.87 94.99,86.48 94.99,86.18 94.7,85.89 94.7,85.65 94.9,85.45 95.1,85.45 95.54,85.89 95.83,85.89 96.2,85.52 96.2,85.13 95.94,84.86 95.94,84.74 96.23,84.44 96.36,84.44 96.55,84.63 96.84,84.63 98.82,82.65 98.82,79.92 99.14,79.6 99.14,75.66 99.24,75.56 99.24,75.07 99,74.82 98.78,74.82 v1(98.56,74.61)
  BOTTOM w0.102: C535.2 50.87,102.98 51.22,102.98 51.32,102.88 51.32,102.27 v2(50.97,101.92) ; v1(98.56,74.61) 98.56,74.61 98.27,74.61 98.14,74.48 98.14,73.04 U2030.B8
INT_EDP_TXN1_C: length 4.1
  BOTTOM w0.102: CN2.16 51.22,106.68 51.35,106.55 51.35,104.16 51.26,104.06 51.26,103.56 51.13,103.44 C535.1
INT_EDP_TXN2: length 86.3
  IN1 w0.089: v1(100.21,76.13) 100.11,76.03 99.92,76.03 99.76,76.19 99.76,76.95 99.93,77.13 100.64,77.13 100.89,77.37 100.89,77.72 100.36,78.25 100.36,79.23 100.08,79.51 100.08,81.56 99.63,82.01 99.63,82.68 98.74,83.57 98.74,84.7 96.28,87.16 96.28,87.28 96.67,87.67 96.67,87.96 96.25,88.38 95.96,88.38 95.57,87.99 95.45,87.99 95.19,88.24 95.19,89.34 90.75,93.79 89.68,93.79 88.3,95.17 75.71,95.17 68.17,102.71 67.87,102.71 67.67,102.5 67.52,102.5 67.24,102.77 67.24,102.92 67.45,103.13 67.45,103.43 67.04,103.84 66.74,103.84 66.25,103.35 66.07,103.35 65.8,103.62 65.8,103.75 66.32,104.26 66.32,104.56 64.85,106.03 62.42,106.03 61.56,106.89 60.28,106.89 60.08,106.69 60.08,106.01 59.99,105.92 59.57,105.92 59.48,106.01 59.48,106.69 59.27,106.89 55.79,106.89 55.35,106.45 54.54,106.45 54.09,106.89 53.47,106.89 53.24,106.67 52.57,106.67 52.34,106.89 51.54,106.89 51.29,106.65 51.29,106.07 51.88,105.49 51.88,105.02 51.72,104.86 51.12,104.86 50.99,104.98 50.99,105.48 50.74,105.72 50.27,105.72 49.75,105.2 49.75,104.22 v2(49.6,104.07)
  BOTTOM w0.102: C533.2 49.6,104.79 v2(49.6,104.07) ; v1(100.21,76.13) 99.4,76.13 98.97,75.7 98.97,73.31 98.69,73.03 98.69,72.69 U2030.C7
INT_EDP_TXN2_C: length 2
  BOTTOM w0.102: CN2.13 49.72,106.54 49.77,106.49 49.77,105.62 49.64,105.49 C533.1
INT_EDP_TXN3: length 85.8
  IN1 w0.089: v2(50.36,102.24) 50.2,102.4 50.2,102.71 49.96,102.95 49.42,102.95 48.58,103.79 48.58,104.64 51.24,107.3 61.78,107.3 62.65,106.44 65,106.44 75.87,95.56 88.64,95.56 89.8,94.4 90.79,94.4 97.5,87.69 97.5,86.56 99.2,84.86 99.2,83.67 100.26,82.61 100.26,82.02 100.47,81.8 100.47,79.68 102.3,77.86 102.3,76.52 102.14,76.36 101.85,76.36 v1(101.74,76.47)
  BOTTOM w0.102: v1(101.74,76.47) 101.59,76.32 101.22,76.32 100.81,75.91 100.81,75.01 100.3,74.5 99.85,74.5 99.45,74.1 99.45,72.89 99.21,72.64 99.21,72.3 U2030.D6 ; C530.2 47.83,103.04 47.96,102.91 47.96,102.02 48.49,101.5 49.88,101.5 50.14,101.75 50.14,102.02 v2(50.36,102.24)
INT_EDP_TXN3_C: length 4.2
  BOTTOM w0.102: CN2.10 48.22,106.53 48.39,106.36 48.39,105.21 47.94,104.76 47.94,103.61 47.81,103.49 C530.1
INT_EDP_TXP0: length 85.9
  IN1 w0.089: v2(97.26,75.68) 97.48,75.89 97.48,76.02 97.48,76.43 95.95,77.96 95.95,81.77 92.99,84.73 92.99,87.24 90.79,89.44 87.77,89.44 86.02,91.2 86.02,93.64 85.89,93.77 85.49,93.77 85.34,93.62 85.34,90.46 85.13,90.25 84.43,90.25 84.19,90.5 84.19,93.6 84.02,93.77 83.6,93.77 83.51,93.68 83.51,92.73 83.3,92.53 82.72,92.53 82.51,92.73 82.51,93.68 82.42,93.77 82,93.77 81.91,93.68 81.91,91.97 81.7,91.76 81.12,91.76 80.91,91.97 80.91,93.68 80.82,93.77 80.4,93.77 80.31,93.68 80.31,92.32 80.1,92.11 79.51,92.11 79.31,92.32 79.31,93.68 79.22,93.77 75.13,93.77 69.04,99.86 67.23,99.86 65.84,101.26 64.92,101.26 62.56,103.62 59.66,103.62 58.79,104.48 56.22,104.48 55.74,104.96 53.91,104.96 53.02,104.08 53.02,103.34 53.14,103.22 53.14,102.74 v2(53.42,102.46)
  BOTTOM w0.089: 97.24,73.49 97.21,73.46 97.21,73.18 97.34,73.04 97.34,72.68 U2030.C8
  BOTTOM w0.102: 97.24,73.49 97.49,73.75 97.49,75.45 v2(97.26,75.68) ; v2(53.42,102.46) 53.17,102.71 53.17,103.21 52.7,103.69 52.7,104.31 C538.2
INT_EDP_TXP0_C: length 2.5
  BOTTOM w0.102: C538.1 52.82,105.11 52.7,105.24 52.7,106.14 52.97,106.41 52.97,106.49 53.22,106.74 CN2.20
INT_EDP_TXP1: length 85.8
  IN1 w0.089: v2(51.6,101.92) 51.44,102.09 51.44,103.37 53.71,105.65 56.04,105.65 56.14,105.55 58.8,105.55 59.61,104.74 62.81,104.74 64.49,103.06 65.23,103.06 67.81,100.47 69.27,100.47 75.38,94.37 86.24,94.37 86.6,94.01 87.1,94.01 87.46,94.37 87.71,94.37 88,94.08 88,93.9 86.61,92.51 86.61,91.49 87.13,90.97 88,90.97 88.32,91.29 88.32,91.69 88.07,91.93 88.07,92.55 88.84,93.32 89.02,93.32 89.29,93.05 89.29,92.92 88.82,92.46 88.82,92.02 89.07,91.78 89.56,91.78 90.35,92.57 90.84,92.57 92.63,90.77 92.63,90.65 92.26,90.28 92.26,89.98 92.67,89.57 92.97,89.57 93.34,89.94 93.46,89.94 94.39,89.01 94.39,86.79 94.79,86.39 94.79,86.27 94.5,85.98 94.5,85.56 94.82,85.24 95.19,85.24 95.62,85.68 95.75,85.68 96,85.44 96,85.21 95.73,84.95 95.73,84.65 96.15,84.24 96.44,84.24 96.63,84.42 96.76,84.42 98.61,82.57 98.61,79.84 98.94,79.51 98.94,75.57 99.04,75.47 99.04,75.15 98.91,75.03 98.78,75.03 v1(98.56,75.24)
  BOTTOM w0.102: v1(98.56,75.24) 97.93,74.61 97.93,73.26 97.7,73.03 97.7,72.78 98.01,72.46 U2030.D8 ; v2(51.6,101.92) 51.53,101.99 51.53,102.64 C536.2
INT_EDP_TXP1_C: length 4.1
  BOTTOM w0.102: CN2.17 51.72,106.64 51.57,106.48 51.57,104.07 51.47,103.97 51.47,103.59 51.62,103.44 C536.1
INT_EDP_TXP2: length 86.3
  IN1 w0.089: v1(100.21,75.51) 100.21,75.6 99.99,75.83 99.83,75.83 99.56,76.1 99.56,77.04 99.85,77.33 100.56,77.33 100.69,77.46 100.69,77.64 100.16,78.17 100.16,79.15 99.88,79.43 99.88,81.48 99.43,81.93 99.43,82.6 98.54,83.49 98.54,84.61 96.08,87.07 96.08,87.37 96.47,87.76 96.47,87.88 96.17,88.18 96.05,88.18 95.65,87.79 95.36,87.79 94.99,88.16 94.99,89.26 90.66,93.59 89.6,93.59 88.22,94.96 75.63,94.96 68.08,102.51 67.96,102.51 67.75,102.3 67.43,102.3 67.04,102.69 67.04,103.01 67.25,103.22 67.25,103.34 66.95,103.64 66.83,103.64 66.33,103.15 65.99,103.15 65.6,103.54 65.6,103.83 66.12,104.35 66.12,104.47 64.76,105.83 62.33,105.83 61.47,106.69 60.37,106.69 60.28,106.6 60.28,105.92 60.07,105.71 59.48,105.71 59.28,105.92 59.28,106.6 59.19,106.69 55.87,106.69 55.43,106.25 54.45,106.25 54.01,106.69 53.55,106.69 53.33,106.46 52.49,106.46 52.26,106.69 51.62,106.69 51.5,106.56 51.5,106.16 52.08,105.57 52.08,104.93 51.8,104.65 51.03,104.65 50.79,104.9 50.79,105.39 50.66,105.52 50.35,105.52 49.95,105.12 49.95,104.28 50.16,104.07 v2(50.23,104.07)
  BOTTOM w0.102: U2030.B6 99.01,73.05 99.18,73.22 99.18,75.61 99.49,75.91 99.81,75.91 99.88,75.84 99.88,75.6 99.98,75.51 v1(100.21,75.51) ; C534.2 49.94,105.04 49.81,104.92 49.81,104.54 49.88,104.47 50.11,104.47 50.23,104.35 v2(50.23,104.07)
INT_EDP_TXP2_C: length 2
  BOTTOM w0.102: C534.1 50.11,105.49 49.99,105.62 49.99,106.4 50.22,106.64 CN2.14
INT_EDP_TXP3: length 85.8
  IN1 w0.089: v1(101.76,75.88) 102.03,76.15 102.22,76.15 102.5,76.43 102.5,77.94 100.68,79.77 100.68,81.89 100.47,82.1 100.47,82.69 99.4,83.76 99.4,84.95 97.71,86.64 97.71,87.77 90.88,94.6 89.88,94.6 88.72,95.76 75.96,95.76 65.08,106.64 62.73,106.64 61.87,107.5 51.16,107.5 48.38,104.72 48.38,103.71 49.34,102.75 49.87,102.75 50,102.62 50,102.51 v2(49.73,102.24)
  BOTTOM w0.102: v1(101.76,75.88) 101.54,76.1 101.31,76.1 101.03,75.82 101.03,74.92 100.39,74.28 99.94,74.28 99.67,74.01 99.67,73.15 99.79,73.02 99.89,73.02 99.96,72.95 99.96,72.83 99.64,72.51 U2030.C6 ; v2(49.73,102.24) 49.92,102.05 49.92,101.84 49.8,101.71 48.58,101.71 48.18,102.11 48.18,102.96 48.25,103.04 C531.2
INT_EDP_TXP3_C: length 4.2
  BOTTOM w0.102: CN2.11 48.72,106.53 48.61,106.41 48.61,105.12 48.16,104.67 48.16,103.64 48.31,103.49 C531.1
INT_HDMI_AUXN: length 103.6
  TOP w0.102: v2(24.86,89.87) 25.08,89.65 25.3,89.65 25.55,89.39 25.55,88.72 24.83,88 24.83,85.58 23.68,84.44 21.65,84.44 21.46,84.24 21.46,83.77 21.55,83.67 R106.1 21.55,82.63 v2(21.65,82.54)
  IN1 w0.089: v2(24.86,89.87) 24.95,89.77 25.55,89.77 25.89,90.11 25.89,90.88 26.39,91.38 27.83,91.38 28.47,90.74 30.36,90.74 30.92,91.3 40.92,91.3 45.37,95.75 47.36,95.75 50.23,98.61 53.06,98.61 53.5,99.05 55.78,99.05 56.21,99.48 59.57,99.48 60.51,98.54 61.94,98.54 63.21,97.27 63.94,97.27 66.21,95 66.21,94.49 67.07,93.64 67.07,93.38 73.21,87.24 80.36,87.24 83.12,84.47 83.12,83.3 86.55,79.87 86.55,79.65 89.68,76.52 90.79,76.52 91.52,75.78 91.52,74.78 93.36,72.95 93.36,71.66 93.79,71.23 94.17,71.23 94.85,70.55 95.1,70.55 95.39,70.83 95.83,70.83 v1(96,71)
  BOTTOM w0.102: v1(96,71) 95.7,70.71 U2030.F11 ; U26.32 21.06,81.94 v2(21.65,82.54)
INT_HDMI_AUXP: length 103.6
  TOP w0.102: v2(20.92,82.54) 20.99,82.61 R107.1 20.99,83.67 21.24,83.92 21.24,84.33 21.56,84.66 23.59,84.66 24.61,85.67 24.61,88.09 25.33,88.81 25.33,89.31 25.21,89.43 25.05,89.43 v2(24.86,89.23)
  IN1 w0.089: v2(24.86,89.23) 25.19,89.57 25.64,89.57 26.1,90.03 26.1,90.79 26.48,91.17 27.75,91.17 28.38,90.54 30.45,90.54 31.01,91.1 41.01,91.1 45.46,95.55 47.45,95.55 50.31,98.41 53.15,98.41 53.58,98.84 55.87,98.84 56.3,99.27 59.49,99.27 60.43,98.33 61.86,98.33 63.13,97.06 63.86,97.06 66,94.93 66,94.89 66.01,94.88 66.01,94.41 66.86,93.55 66.86,93.3 73.13,87.03 80.28,87.03 82.92,84.39 82.92,83.21 86.35,79.78 86.35,79.56 89.6,76.31 90.71,76.31 91.32,75.7 91.32,74.7 93.15,72.86 93.15,71.58 93.7,71.03 94.08,71.03 94.77,70.34 95.18,70.34 95.47,70.63 95.89,70.63 96.02,70.5 v1(96.02,70.31)
  BOTTOM w0.102: U26.31 20.66,81.87 20.92,82.13 v2(20.92,82.54) ; U2030.G11 95.51,70.2 95.62,70.31 v1(96.02,70.31)
INT_HDMICLK+_OUT: length 2.7
  BOTTOM w0.102: U26.19 18.22,77.27 18.13,77.18 17.89,77.18 17.59,76.88 17.59,76.17 17.46,76.05 17.32,76.05 R2706.2
INT_HDMICLK-_OUT: length 2.7
  BOTTOM w0.102: R2705.2 17.05,75.56 17.32,75.83 17.55,75.83 17.8,76.08 17.8,76.79 17.98,76.96 18.13,76.96 18.22,76.87 U26.18
INT_HDMITX0N_OUT: length 2.2
  BOTTOM w0.102: U26.21 18.34,78.07 18.25,78.17 17.97,78.17 17.84,78.04 17.84,77.86 17.59,77.61 17.33,77.61 R2699.2
INT_HDMITX0P_OUT: length 2.2
  BOTTOM w0.102: R2700.2 17.32,77.82 17.5,77.82 17.63,77.95 17.63,78.13 17.88,78.38 18.29,78.38 18.38,78.47 U26.22
INT_HDMITX1N_OUT: length 2
  BOTTOM w0.102: R2701.2 17.31,79.24 17.5,79.24 17.77,78.98 18.22,78.98 18.33,78.87 U26.23
INT_HDMITX1P_OUT: length 2
  BOTTOM w0.102: R2702.2 17.33,79.46 17.59,79.46 17.85,79.2 18.18,79.2 18.26,79.27 U26.24
INT_HDMITX2N_OUT: length 3.1
  BOTTOM w0.102: R2703.2 17.31,81.69 17.41,81.79 17.63,81.79 17.75,81.66 17.75,80.4 17.98,80.17 18.22,80.17 18.32,80.07 U26.26
INT_HDMITX2P_OUT: length 3.1
  BOTTOM w0.102: R2704.2 17.31,82.13 17.43,82 17.72,82 17.97,81.75 17.97,80.49 18.07,80.39 18.24,80.39 18.32,80.47 U26.27
ISOLATEB: length 5
  TOP w0.102: U1.20 47.34,105.2 47.67,104.86 48.4,104.86 49.06,105.52 49.72,105.52 49.98,105.26 R30.2 50.35,105.02 50.58,105.24 R31.1
JTAG_TCK: length 6.6
  BOTTOM w0.102: TP8075.1 110.29,120.89 110.29,116.85 110.11,116.66 110.11,115.33 U2029.AE41
JTAG_TDI: length 9.7
  BOTTOM w0.102: TP8073.1 112.25,122.21 112.25,121.83 110.75,120.33 110.75,115.88 110.58,115.71 110.58,114.89 110.66,114.82 110.66,114.52 110.35,114.21 U2029.AD40
JTAG_TDO: length 4.3
  TOP w0.102: v2(109.49,115.94) 110.68,117.13 TP8074.1
  BOTTOM w0.102: v2(109.49,115.94) 109.49,115.43 109.25,115.2 U2029.AF41
JTAG_TESTEN: length 6.4
  BOTTOM w0.102: R2600.1 R2619.1 110.02,119.08 109.79,118.86 TP8007.1 109.89,118.5 109.89,115.54 109.48,115.13 109.48,114.87 109.56,114.8 109.56,114.57 U2029.AE40
JTAG_TMS: length 7.4
  BOTTOM w0.102: U2029.AD41 110.31,114.72 110.31,116.58 110.52,116.79 110.52,120.99 TP8076.1
JTAG_TRSTB: length 6.9
  BOTTOM w0.102: R2599.1 108.29,119.78 108.17,119.65 R2618.1 108.17,118.7 108.27,118.6 TP8010.1 108.27,116.32 108.9,115.68 108.9,115.47 109.05,115.32 109.05,114.92 108.93,114.8 108.93,114.56 109.25,114.24 U2029.AF40
JW5222LX1.5V:
  vias: v2(196.53,23.99)
KB_BL_LED: length 32.4
  TOP w0.102: v2(175.99,26.4) 175.55,25.97 174.92,25.97 173.65,27.24 173.65,28.63 173.22,29.07 U13.113
  IN2 w0.089: v2(175.99,26.4) 176.13,26.55 176.87,26.55 177.79,25.63 183.37,25.63 183.82,26.09 186.91,26.09 188.05,24.95 191.04,24.95 191.58,24.42 191.58,23.53 191.86,23.25 192.37,23.25 192.61,23 192.61,22.61 192.21,22.21 v2(192.21,21.95)
  BOTTOM w0.102: v2(192.21,21.95) 192.56,21.95 192.67,21.84 192.67,21.75 193.47,20.95 193.47,17.63 194.23,16.86 Q44.2
KBC_RST#_C: length 5.5
  BOTTOM w0.102: U2030.BD11 95.49,40.69 95.49,39.82 97.01,38.3 97.01,37.58 97.69,36.91 97.89,36.91 98.11,36.69 R2421.2
KBRST#: length 63.4
  TOP w0.102: v2(146.93,18.71) 146.93,19.22 150.58,22.87 154.81,22.87 155.7,23.76 157.42,23.76 160.36,26.7 161.96,26.7 162.49,27.23 163.79,27.23 164.06,26.96 U13.4 ; Q6565.3 112.62,17.53 113.14,17 113.14,16.36 115.16,14.34 v2(118.17,14.34) 141.41,14.34 v2(142.3,13.45)
  BOTTOM w0.102: v2(142.3,13.45) 142.3,15.61 142.81,16.12 142.81,17.26 144.26,18.71 v2(146.93,18.71)
KL_NO_EC: length 149.7
  TOP w0.102: v2(142.56,27.57) 142.2,27.93 141.54,27.93 141.04,28.43 PR96.2 ; v2(54.29,24.12) 54.29,22.97 v2(53.15,21.83) 52.84,21.53 52.84,19.6 51.74,18.5 PR122.2 ; v2(169.58,24.6) 169.58,23.51 171.51,21.58 174.35,21.58 177.65,18.28 179.02,18.28 179.4,17.89 180.07,17.89 180.2,17.76 U13.70
  IN2 w0.089: v2(169.58,24.6) 168.62,25.56 168.13,25.56 167.55,26.14 165.94,26.14 165.55,25.75 159.84,25.75 158.73,24.64 155.83,24.64 154.86,25.61 154.58,25.61 153.37,26.82 142.77,26.82 142.56,27.04 v2(142.56,27.57) 141.84,27.57 141.79,27.61 141.02,27.61 139.48,26.07 132.24,26.07 131.77,26.54 120.76,26.54 120.47,26.84 115.65,26.84 115.46,27.03 110.8,27.03 109.6,25.83 97.83,25.83 96.18,24.19 91.97,24.19 90.98,25.17 88.56,25.17 87.99,25.74 86.64,25.74 85.07,24.18 78.55,24.18 77.6,23.23 75.47,23.23 75.28,23.04 71.11,23.04 70.45,22.38 55.73,22.38 54.29,23.82 v2(54.29,24.12)
L_SPK+: length 96.1
  IN2 w1.016: 202.63,18.31 202.63,17.05 200.93,15.35 199.88,15.35 197.06,12.53 190.33,12.53 189.22,13.65 187.34,13.65 186.12,12.43 184.59,12.43 182.93,10.77 165.3,10.77 164.81,11.26 146.01,11.26 142.79,14.48 118.32,14.48 117.79,13.96 115,13.96 114.62,14.34
  BOTTOM w0.203: U30.42 203.33,22.41 v3(203.13,22.21)
  vias: v2(114.93,16.24) v2(115.57,16.24)
L_SPK+_1:
  vias: v2(115.38,20.43) v2(115.5,19.66) v2(116.14,19.66)
L_SPK-: length 92.8
  IN2 w1.016: 200.85,19.67 200.85,18.91 199.96,18.02 197.9,18.02 196.12,16.24 193.49,16.24 192.49,15.25 191.78,15.25 191.32,15.71 186.64,15.71 185.52,14.59 184.08,14.59 183.45,13.96 183.45,13.32 182.22,12.09 166.05,12.09 165.56,12.58 147.48,12.58 145.98,14.08 145.06,14.08 143.34,15.8 116.96,15.8
  BOTTOM w0.203: v3(201.67,21.23) 202.06,21.23 202.63,21.8 202.63,22.54 202.94,22.85 U30.43
  vias: v2(116.38,16.75) v2(117.02,16.75)
L_SPK-_1:
  vias: v2(116.77,19.66) v2(117.05,20.2) v2(117.41,19.66)
LAD0: length 124.2
  TOP w0.102: v2(151.29,19.06) 151.27,19.04 151.27,18.83 152.09,18.01 153.3,18.01 153.55,18.26 153.55,18.58 153.83,18.86 157.36,18.86 157.95,19.45 R6564.2
  IN1 w0.102: v2(151.29,19.06) 151.27,19.09 151.27,19.57 152.72,21.02 155.08,21.02 155.81,20.28 158.2,20.28 158.96,21.04 162.65,21.04 163.23,20.46 164.83,20.46 165.24,20.05 165.24,17.83 168.56,14.5 175.6,14.5 175.99,14.11 179.35,14.11 179.81,14.57 186.34,14.57 186.92,15.15 187.59,15.15 188.28,14.46 189.65,14.46 189.85,14.67 190.89,14.67 191.7,13.85 192.39,13.85 192.8,14.26 v1(192.9,14.26)
  IN3 w0.102: v2(151.29,19.06) 151.29,18.93 151.01,18.66 150.3,18.66 148.15,20.81 144.85,20.81 143.67,21.98 134.08,21.98 132.02,19.93 124.14,19.93 123.94,20.13 112.71,20.13 108.39,24.44 108.39,29.56 v1(108.01,29.94)
  BOTTOM w0.102: R6553.2 98.99,31.1 99.33,30.77 100.58,30.77 101.08,30.26 103.97,30.26 104.35,29.88 107.96,29.88 v1(108.01,29.94) ; R830.1 193.33,16.8 193.33,16.22 193.86,15.68 193.86,14.92 193.56,14.62 193.25,14.62 v1(192.9,14.26)
LAD0_R: length 2.6
  BOTTOM w0.102: R830.2 192.18,17.86 191.93,17.61 191.93,17.16 191.66,16.88 CN9.58
LAD0_TP: length 2.7
  TOP w0.102: v1(189.04,14.87) 189.04,14.51 TP9111.1
  BOTTOM w0.102: CN9.64 189.55,15.38 v1(189.04,14.87)
LAD1: length 114.3
  TOP w0.102: v1(150.55,20.87) 151.57,19.85 v2(151.83,19.85) 155.84,19.85 R6565.2
  IN1 w0.102: v1(188.43,14.87) 187.79,15.51 186.81,15.51 186.2,14.9 179.67,14.9 179.21,14.44 176.13,14.44 175.74,14.83 170.19,14.83 168.55,16.47 167.12,16.47 165.57,18.02 165.57,20.61 164.76,21.42 164.15,21.42 164.02,21.3 162.93,21.3 162.77,21.45 161.15,21.45 160.59,22.01 159.37,22.01 158.08,20.71 156.04,20.71 155.41,21.35 151.03,21.35 v1(150.55,20.87)
  IN3 w0.102: v1(150.55,20.87) 148.96,22.47 146.33,22.47 145.69,23.1 145.07,23.1 144.52,23.65 133.29,23.65 132.66,23.02 123.64,23.02 122.96,22.34 120.11,22.34 119.55,21.78 113.39,21.78 110.4,24.77 110.4,28.53 109.03,29.91 v1(109.03,30.09)
  BOTTOM w0.102: v1(188.43,14.87) 188.83,14.46 189.39,14.46 189.81,14.88 CN9.66 ; v1(109.03,30.09) 108.77,30.34 107.51,30.34 107.39,30.23 104.76,30.23 104.39,30.59 101.22,30.59 100.09,31.73 100.09,32.57 99.45,33.21 R6554.2
LAD2: length 118.1
  TOP w0.102: R6566.2 154.73,20.23 v2(154.68,20.28)
  IN1 w0.102: v2(154.68,20.28) 155.51,19.44 158.81,19.44 159.55,20.18 159.55,20.59 159.68,20.71 162.49,20.71 163.08,20.13 164.6,20.13 164.91,19.82 164.91,17.69 168.43,14.17 175.46,14.17 175.86,13.78 179.49,13.78 179.94,14.24 186.47,14.24 186.85,14.62 v1(187.51,14.62)
  IN3 w0.102: v2(154.68,20.28) 154.22,19.83 150.06,19.83 148.42,21.47 145.24,21.47 144.05,22.66 133.7,22.66 132.36,21.32 123.34,21.32 122.81,20.79 112.98,20.79 109.41,24.36 109.41,27.49 v1(109.03,27.88)
  BOTTOM w0.102: v1(109.03,27.88) 109.43,27.47 109.43,27.06 108.97,26.59 96.54,26.59 96.27,26.86 94.32,26.86 93.59,27.59 93.59,27.77 93,28.36 92.31,28.36 91.27,29.4 90.81,29.4 v2(90.08,30.14) R6555.2 ; v1(187.51,14.62) 188.02,14.11 189.6,14.11 189.87,14.38 CN9.68
LAD3: length 128.9
  TOP w0.102: v2(157.54,21.6) 158.06,21.6 159.49,23.02 161.1,23.02 162.22,24.14 R6567.2
  IN1 w0.102: v2(157.54,21.6) 157.8,21.6 159.02,22.82 160.86,22.82 161.5,22.18 162.37,22.18 162.84,22.64 163.68,22.64 164.17,22.15 165.15,22.15 166.23,21.07 166.23,18.29 167.29,17.23 171.5,17.23 173.24,15.49 176.01,15.49 176.4,15.1 178.94,15.1 179.4,15.56 185.92,15.56 186.53,16.17 188.12,16.17 v1(188.53,16.57)
  IN3 w0.102: v1(108.01,27.37) 108.01,24.36 112.57,19.8 114.79,19.8 115.34,19.25 120.27,19.25 120.76,19.74 123.81,19.74 123.96,19.59 132.16,19.59 134.21,21.65 143.5,21.65 144.67,20.48 148.01,20.48 150.32,18.17 152.94,18.17 153.62,18.84 154.38,18.84 155.43,19.9 155.84,19.9 v2(157.54,21.6)
  BOTTOM w0.102: v1(108.01,27.37) 107.57,26.92 96.87,26.92 96.55,27.24 94.4,27.24 93.97,27.67 93.97,27.85 93.14,28.69 92.53,28.69 91.76,29.46 91.76,29.68 91.09,30.34 R6556.2 ; v1(188.53,16.57) 188.3,16.57 187.06,15.33 187.06,14.01 187.46,13.6 189.6,13.6 189.88,13.88 CN9.70
LAN_AMBLED#: length 1.6
  TOP w0.102: U1.27 45.24,108.28 45.65,108.7 TP4.1
LAN_LED1: length 3.6
  TOP w0.102: TP2.1 46.42,110.48 46.16,110.22 46.16,108.83 45.64,108.3 U1.26
LAN_LED2: length 1.9
  TOP w0.102: U1.25 46.04,108.19 TP3.1
LAN_MCTG0: length 4.4
  TOP w0.102: v2(37.78,108.83) 37.53,109.08 v2(37.53,109.56)
  TOP w0.508: R11.2 v2(37.53,109.56)
  BOTTOM w0.508: U21.24 37.9,110.77 37.53,110.4 v2(37.53,109.56)
LAN_MCTG1: length 5.1
  TOP w0.508: v2(35.11,108.85) 34.73,109.23 v2(34.73,109.46) R10.2
  BOTTOM w0.508: U21.21 34.9,109.93 35.11,109.71 v2(35.11,108.85)
LAN_MCTG2: length 4.4
  TOP w0.102: v2(31.9,109.64) v2(31.9,108.86)
  TOP w0.508: R8.2 31.68,109.85 v2(31.9,109.64)
  BOTTOM w0.508: U21.18 v2(31.9,109.64)
LAN_MCTG3: length 4.4
  TOP w0.102: v2(28.64,108.83) 28.9,109.09 v2(28.9,109.64)
  TOP w0.508: R9.2 28.76,109.77 v2(28.9,109.64)
  BOTTOM w0.508: v2(28.9,109.64) U21.15
LAN_XTAL1: length 4
  TOP w0.102: R16.1 45.43,110.07 45.04,110.46 C33.2 44.64,111.38 44.64,112.48 Y1.1
LANPWR#: length 184.7
  TOP w0.102: U13.16 166.63,22.16 166.97,22.5 167.54,22.5 167.83,22.78 167.83,25.24 168.03,25.44 168.03,28.2 v2(168.02,28.21)
  TOP w0.203: v2(52,106.29) R5.2 R14.1
  IN3 w0.089: v2(168.02,28.21) 167.54,28.69 165.57,28.69 164.68,29.58 162.85,29.58 161.73,30.71 156.59,30.71 155.71,29.82 148.64,29.82 144.83,33.64 144.83,37.27 144.17,37.93 136,37.93 135.48,37.41 131.68,37.41 131.07,38.02 130.63,38.02 129.77,37.16 124.5,37.16 123.98,37.69 123.59,37.69 120.9,40.38 120.9,41.88 118.49,44.29 118.49,49.08 116.12,51.45 116.12,53.11 114.65,54.57 114.65,57.7 114.94,58.39 116.57,60.02 116.57,64.49 117.92,65.85 117.92,66.42 117.36,66.98 117.1,66.98 114.82,69.26 114.82,69.68 113.82,70.68 113.82,71.63 112.68,72.77 111.74,72.77 110.64,73.87 109.11,73.87 108.54,74.44 108.54,75.95 106.13,78.36 106.13,79.89 104.22,81.8 103.45,81.8 101.62,83.63 101.62,84.44 99.99,86.08 99.99,88.08 99.99,88.55 99.99,91.45 97.54,93.9 95.48,93.9 94.82,94.56 93.28,94.56 91.54,96.3 84.73,96.3 83.08,97.95 75.57,97.95 74.45,99.07 71.59,99.07 64.65,106.01 61.99,106.01 61.12,106.88 52.6,106.88 v2(52,106.29)
LCD_BL_PWM: length 7.8
  TOP w0.102: R2230.1 115.12,118.24 111.45,114.57 111.45,114.04 111.45,114.04 v2(111.45,113.11)
  BOTTOM w0.102: U2029.AC38 111.26,112.92 v2(111.45,113.11)
LCD_BLEN: length 8.4
  TOP w0.102: v2(111.47,112.43) 111.01,112.89 111.01,114.45 113.85,117.3 R2229.1
  BOTTOM w0.102: v2(111.47,112.43) 111.16,112.12 U2029.AC37
LCD_VDD: length 6.9
  BOTTOM w0.102: R2601.1 112.23,120.33 111.85,119.95 111.49,119.95 111.21,119.67 111.21,114.9 110.9,114.59 U2029.AC40
LDO_3V3: length 18.1
  TOP w0.203: v2(15.43,12.03) 15.71,11.74 R6524.2 ; v2(17.45,12.02) 17.18,11.75 R6522.2 ; R6525.2 16.04,13.9 v2(16.32,14.18) ; v2(14.26,14.24) 14.29,14.24 14.55,13.97 14.57,13.93 R6526.2
  TOP w0.305: U2034.20 v2(20.62,19.04)
  TOP w0.381: R6512.2 20.38,19.28 v2(20.62,19.04) ; R6513.2 v2(19.24,21.2)
  IN1 w0.508: v2(17.45,12.02) 18.1,12.67 18.1,16.51 v2(20.62,19.04) 20.62,19.81 v2(19.24,21.2)
  BOTTOM w0.381: v2(20.62,19.04) 20.63,19.03 C2783.2
LFRAME_L: length 121.1
  TOP w0.102: R6571.2 162.93,25.79 160.82,23.68 159.21,23.68 157.92,22.39 156.54,22.39 155.89,21.74 v2(155.75,21.74)
  IN1 w0.102: v2(155.75,21.74) 156.36,21.13 157.94,21.13 159.17,22.36 160.79,22.36 161.35,21.8 162.62,21.8 162.95,22.13 163.46,22.13 163.77,21.82 165.01,21.82 165.9,20.93 165.9,18.16 167.18,16.88 169.38,16.88 171.09,15.16 175.87,15.16 176.27,14.77 179.08,14.77 179.53,15.23 186.06,15.23 186.67,15.84 191.48,15.84 191.93,15.38 v1(191.93,14.41)
  IN3 w0.102: v2(155.75,21.74) 155.25,21.25 153.06,21.25 152.3,20.49 150.34,20.49 148.69,22.13 146.19,22.13 145.61,22.72 144.97,22.72 144.37,23.32 133.42,23.32 132.8,22.69 123.78,22.69 123.09,22.01 120.25,22.01 119.69,21.45 113.25,21.45 110.07,24.63 110.07,28.23 v1(109.03,29.27)
  BOTTOM w0.102: v1(109.03,29.27) 108.77,29.53 104.2,29.53 103.85,29.88 101,29.88 100.44,30.44 98.64,30.44 97.44,31.64 R6560.2 ; v1(191.93,14.41) 192.54,15.02 R712.1
LID#: length 208.2
  TOP w0.102: C498.1 37.15,122.16 37.53,122.54 42.95,122.54 HE2.1 ; C498.1 37.68,121.62 37.78,121.53 D21.2 38.32,120.76 v2(38.35,120.74) ; C498.1 36.79,121.62 36.59,121.83 36.06,121.83 HE1.1 ; v2(52.51,102.93) 52.38,103.07 D1.1 52.38,104.37 52.77,104.76 v2(52.77,105.14) R23.2 ; R368.2 161.25,35.21 v2(161.18,35.28)
  IN2 w0.089: v2(52.51,102.93) 51.5,103.95 51.5,106.79 51.22,107.07 51.22,110.13 51.69,110.6 v2(52.77,110.6)
  IN3 w0.089: v2(161.18,35.28) 160.48,35.28 160.29,35.47 157.02,35.47 152.49,37.35 151.7,38.13 151.7,39.43 149.38,41.75 149.38,42.78 148.58,43.58 148.58,44.05 147.7,44.93 147.7,46.42 146.83,47.29 145.73,47.29 144.13,48.9 142.54,48.9 142.35,48.71 126.57,48.71 122.94,52.34 122.94,53.19 121.91,54.22 121.91,58.02 122.94,59.05 122.94,68.17 119.81,71.3 118.94,71.3 114.91,75.33 113.75,75.33 112.94,76.14 112.94,80.02 111.19,81.77 111.19,83.05 102.74,91.5 102.74,92.77 99.42,96.09 97.43,96.09 95.32,98.2 92.09,98.2 91.47,98.82 87.69,98.82 87.48,99.03 85.02,99.03 83.95,100.1 83.95,103.77 82.13,105.58 77.85,105.58 77.46,105.19 76.94,105.19 74.47,107.66 69.53,107.66 66.83,110.37 63.67,110.37 61.89,112.15 54.31,112.15 v2(52.77,110.6)
  BOTTOM w0.102: v2(52.77,110.6) 50.99,112.38 47.05,112.38 46.11,113.32 46.11,113.57 45.78,113.91 43.9,113.91 42.86,114.94 42.86,115.68 38.35,120.19 v2(38.35,120.74)
LID#_C: length 12.5
  TOP w0.102: R368.1 161.86,34.53 161.87,34.52 D10.1 C381.1 163.77,34.52 164.63,33.67 v2(167.42,33.67) 167.96,33.13 169.73,33.13 170.88,31.99 170.88,30.97 171.22,30.63 U13.118
LINE1-L: length 6.9
  BOTTOM w0.203: U30.22 204.54,30.47 204.69,30.62 205.7,30.62 206.06,30.97
  BOTTOM w0.381: 206.06,30.97 206.18,31.1 206.18,33.39 v2(206.73,33.93) C333.1
LINE1-R: length 6.8
  BOTTOM w0.203: U30.21 204.13,30.96
  BOTTOM w0.381: C334.1 206.44,34.53 205.55,33.64 205.55,31.48 205.29,31.23 v2(205.04,31.23) 204.4,31.23 204.13,30.96
LINE1-VREFO-L: length 13.6
  IN2 w0.381: v2(207.96,26.4) 207.96,26.43 208.6,27.06 208.6,30.26 208.18,30.68 208.18,32.46 208.31,32.6 208.31,34.3 209.1,35.09 v2(209.1,36.94)
  BOTTOM w0.203: v2(207.96,26.4) 207.83,26.4 207.78,26.46 U30.31 ; R248.1 v2(209.1,36.94)
LINE1-VREFO-R: length 15.3
  IN2 w0.381: v2(205.67,37.17) 206.16,37.17 206.44,37.45 207.69,37.45 208.09,37.06 208.09,35.33 207.42,34.67 207.42,32.98 207.28,32.83 207.28,30.31 207.71,29.88 207.71,27.29 v2(207.45,27.04)
  BOTTOM w0.203: v2(207.45,27.04) 207.27,26.86 U30.30
  BOTTOM w0.381: v2(205.67,37.17) 205.93,37.17 R227.1
LLB#: length 3.1
  TOP w0.102: TP2038.1 97.98,49.58 v1(97.92,49.52)
  BOTTOM w0.102: v1(97.92,49.52) 98.11,49.33 98.11,48.88 98.49,48.5 98.72,48.5 U2030.AN6
LPC_PD_L: length 80.6
  TOP w0.102: v2(161.48,20.31) 161.35,20.43 R6563.2
  IN3 w0.102: v1(108.01,28.18) 107.63,27.8 107.63,24.27 112.43,19.47 114.66,19.47 115.2,18.92 132.92,18.92 134.71,20.71 143.93,20.71 144.49,20.15 147.87,20.15 150.18,17.84 154.1,17.84 155.44,19.19 157.19,19.19 159.04,21.04 160.74,21.04 v2(161.48,20.31)
  BOTTOM w0.102: R6552.2 93.12,31.03 93.51,30.64 94.78,30.64 95.26,30.16 95.66,30.16 96.75,29.07 99.94,29.07 100.68,28.33 105.45,28.33 105.65,28.54 107.4,28.54 107.76,28.18 v1(108.01,28.18)
LPC_RST#: length 84.8
  IN1 w0.102: v2(159.08,20.39) 158.62,19.93 155.6,19.93 154.84,20.69 153.2,20.69 152.92,20.41 152.92,18.33 152.43,17.84 145.49,17.84 143.96,19.37 137.69,19.37 136.84,18.53 129,18.53 128.73,18.26 115.78,18.26 115.48,17.97 105.72,17.97 104.74,18.96 104.74,24.06 104.28,24.52 104.28,30.17 v1(103.32,31.13)
  BOTTOM w0.102: v1(103.32,31.13) 103.12,30.92 102.19,30.92 101.53,31.58 100.98,31.58 100.42,32.14 100.42,32.76 99.46,33.72 98.75,33.72 98.36,34.11 98.36,34.53 98.08,34.81 C2573.1 98.08,35.55 98.11,35.57 R2421.1 ; R6572.2 162.98,19.67 162.77,19.87 159.59,19.87 v2(159.08,20.39)
LPCCLK: length 82.4
  TOP w0.102: v2(160.08,21.6) 160.1,21.62 162.51,21.62 163,22.12 R6568.2
  IN3 w0.102: v1(109.03,27.29) 109.03,24.27 112.84,20.46 122.95,20.46 123.48,20.99 128.41,20.99 129.02,20.38 131.89,20.38 133.84,22.33 143.91,22.33 145.1,21.14 148.29,21.14 149.93,19.5 154.56,19.5 156.5,21.43 156.5,21.8 156.79,22.08 157.67,22.08 158.15,21.6 v2(160.08,21.6)
  BOTTOM w0.102: R6557.2 92.11,30.37 92.61,29.87 92.61,29.65 92.91,29.35 93.9,29.35 94.69,28.56 95.46,28.56 95.95,28.08 98.89,28.08 99.38,28.56 99.98,28.56 100.54,28 106.28,28 106.61,27.67 107.6,27.67 107.7,27.77 108.55,27.77 v1(109.03,27.29)
LPCCLK_RUN_L: length 114.1
  TOP w0.102: R6569.2 184.03,27.04 184.29,27.29 184.72,27.29 185.1,26.91 v2(185.1,26.86)
  IN3 w0.102: v1(109.04,28.46) 109.74,27.76 109.74,24.5 113.12,21.12 122.67,21.12 123.92,22.36 132.93,22.36 133.56,22.99 144.18,22.99 145.38,21.8 148.56,21.8 150.2,20.16 152.44,20.16 153.2,20.92 155.5,20.92 156.17,21.59 156.17,21.93 156.65,22.41 157.81,22.41 158.21,22.01 160.24,22.01 161.44,20.81 162.36,20.81 163,20.17 163,18.66 163.64,18.02 164.72,18.02 165.62,17.12 169.11,17.12 170.11,16.12 170.57,16.12 170.8,16.34 170.8,17 171.49,17.7 172.29,17.7 173.13,18.53 174.4,18.53 174.64,18.77 174.64,19.1 175.28,19.73 176.63,19.73 176.85,19.95 178.14,19.95 179.44,18.66 180.26,18.66 180.53,18.93 180.53,20.23 v2(180.1,20.66)
  BOTTOM w0.102: v2(185.1,26.86) 184.85,26.61 184.85,25.49 184.26,24.9 183.75,24.9 182.18,23.33 182.18,22.74 v2(180.1,20.66) ; R6558.2 94.42,31.1 94.55,30.97 94.96,30.97 95.44,30.49 R2451.1 95.79,30.49 96.89,29.4 100.08,29.4 100.82,28.66 105.14,28.66 105.35,28.87 107.64,28.87 107.84,28.66 108.84,28.66 v1(109.04,28.46)
LPCCLK_RUN_L_R: length 2.1
  TOP w0.102: U13.93 182.99,26.96 183.07,27.04 R6569.1
M0_5441: length 2.2
  TOP w0.102: U2034.22 19.62,18.91 19.24,19.29 R6513.1
M1_5441: length 4.3
  TOP w0.102: U2034.21 20.12,18.79 19.87,19.04 19.87,20.06 R6512.1 R6511.2
M_A_A0: length 37.1
  TOP w0.165: v1(55.39,57.09) 55.39,56.92 55.71,56.6 60.54,56.6 63.28,53.86 80.99,53.86 81.14,54.01 81.65,54.01 81.89,53.77 81.89,53.29 82.12,53.05 82.48,53.05 v1(82.99,53.56)
  BOTTOM w0.165: CN2019.144 51.1,60.46 51.5,60.06 52.26,60.06 55.23,57.09 v1(55.39,57.09) ; v1(82.99,53.56) 83.31,53.88 U2030.AF25
M_A_A1: length 36.9
  TOP w0.165: v1(84.54,55.55) 84.32,55.55 83.78,56.09 80.73,56.09 79.94,56.88 63.09,56.88 57.37,62.6 v2(56.07,62.6) 55.56,62.6 55.31,62.85 55.31,63.19 v1(55.69,63.57)
  BOTTOM w0.165: v1(55.69,63.57) 55.69,63.36 55.94,63.11 57.34,63.11 57.44,63.21 CN2019.133 ; U2030.AE23 84.91,55.18 v1(84.54,55.55)
M_A_A2: length 36.1
  IN1 w0.14: v1(81.51,56.54) 81.06,56.98 80.15,56.98 78.6,58.53 67.37,58.53 64.58,61.33 57.47,61.33 57.2,61.59 54.91,61.59 v1(54.16,60.84)
  BOTTOM w0.165: CN2019.132 51.78,63.46 52.21,63.02 53.16,63.02 54.16,62.02 v1(54.16,60.84) ; U2030.AD27 81.81,56.23 v1(81.51,56.54)
M_A_A3: length 37.1
  TOP w0.165: v1(86.07,55.56) 85.63,55.99 84.39,55.99 83.37,57.01 81.85,57.01 81.47,57.39 67.76,57.39 67.6,57.56 67.6,58.08 67.43,58.24 67.1,58.24 66.94,58.08 66.94,57.56 66.77,57.39 66.44,57.39 66.27,57.56 66.27,58.08 66.11,58.24 65.78,58.24 65.61,58.08 65.61,57.56 65.45,57.39 63.28,57.39 57.11,63.57 v1(57.08,63.57)
  BOTTOM w0.165: v1(86.07,55.56) 86.07,55.45 U2030.AE21 ; CN2019.131 57.2,63.71 57.08,63.59 v1(57.08,63.57)
M_A_A4: length 37.4
  IN1 w0.14: v1(53.08,63.53) 54.65,61.96 57.47,61.96 57.72,61.71 64.84,61.71 67.65,58.9 78.75,58.9 80.29,57.36 81.49,57.36 81.85,57.01 83.25,57.01 83.64,57.41 v1(83.64,57.47)
  BOTTOM w0.165: CN2019.128 52.16,64.46 v1(53.08,63.53) ; v1(83.64,57.47) 84.1,57.01 U2030.AC24
