# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USBP7+_FP_HUB: length 6.6
  BOTTOM w0.102: U2033.13 93.68,86.84 93.55,86.71 93.38,86.71 91.35,88.74 89.42,88.74 89.3,88.86 89.3,89.09 89.4,89.2 R77846.1
USBP7+_FP_R: length 97.5
  BOTTOM w0.102: CN13.7 57.45,21.43 57.57,21.56 57.57,21.81 57.72,21.96 57.72,22.14 EC6.2 57.34,23.59 58.5,24.75 59.12,24.75 60.77,26.4 60.77,36.58 59.75,37.6 59.75,41.64 60.39,42.28 60.39,52.31 61.02,52.94 61.02,64.61 62.67,66.26 62.67,77.56 65.36,80.25 72.2,80.25 73.71,81.76 73.71,84.96 76.74,88 80.86,88 81.85,88.99 81.85,90.39 82.4,90.94 86.59,90.94 87.08,91.43 89.07,91.43 89.47,91.02 89.47,89.8 89.51,89.8 89.66,89.65 R77844.2
USBP7-_FP: length 19.8
  IN1 w0.089: v2(88.78,90.59) 89.47,91.27 90.83,91.27 91.25,90.86 91.25,90.33 93.92,87.65 93.92,85.14 95.79,83.27 97.24,83.27 98.13,82.38 98.13,79.31 v2(98.54,78.9)
  BOTTOM w0.102: v2(98.54,78.9) 98.49,78.95 R77841.1 ; R77845.1 88.83,90.54 v2(88.78,90.59)
USBP7-_FP_APU: length 34.1
  IN3 w0.089: v1(95.62,52.44) 95.47,52.3 95.47,52.03 95.21,51.77 94.63,51.77 94.27,52.13 94.27,58.81 94.07,59.02 94.07,62.76 93.53,63.29 93.53,65.33 94.42,66.22 94.42,72.62 95.72,73.92 95.72,76.79 96.37,77.44 97.26,77.44 97.91,78.1 98.4,78.1 98.43,78.12 98.43,78.12 v2(98.53,78.22)
  BOTTOM w0.102: v2(98.53,78.22) 98.46,78.16 98.21,78.16 98.11,78.26 98.11,79.64 98.33,79.87 R77843.2 ; v1(95.62,52.44) 95.62,52.32 U2030.AJ11
USBP7-_FP_HUB: length 6.6
  BOTTOM w0.102: R77847.1 89.04,88.99 89.04,88.76 89.32,88.48 91.25,88.48 93.27,86.46 93.56,86.46 93.68,86.34 U2033.12
USBP7-_FP_R: length 97.5
  BOTTOM w0.102: R77845.2 89.09,89.65 89.22,89.78 89.22,90.92 88.96,91.17 87.18,91.17 86.7,90.69 82.51,90.69 82.1,90.28 82.1,88.89 80.96,87.74 76.85,87.74 73.96,84.86 73.96,81.65 72.3,80 65.47,80 62.93,77.46 62.93,66.15 61.28,64.5 61.28,52.84 60.64,52.2 60.64,42.17 60.01,41.54 60.01,37.71 61.02,36.69 61.02,26.3 59.22,24.5 58.61,24.5 57.66,23.55 57.66,23.23 57.79,23.1 58.46,23.1 58.58,22.97 58.58,22.74 EC7.1 57.97,22.13 57.97,21.85 57.83,21.7 57.83,21.55 57.95,21.42 CN13.6
USBP8+_TS: length 68.5
  IN3 w0.089: v2(96.71,82.28) 96.89,82.46 96.89,82.92 95.71,84.1 95.71,88.74 93.93,90.52 92.39,90.52 91.51,91.41 88.81,91.41 87.02,93.2 82.64,93.2 81.61,94.23 74.76,94.23 73.98,95 70.53,95 67.88,97.65 67.01,97.65 64.7,99.96 61.31,99.96 61.01,100.26 51.53,100.26 51.14,99.87 48.26,99.87 47.86,100.27 46.67,100.27 46.55,100.14 46.55,99.96 46.7,99.81 v2(46.81,99.81)
  BOTTOM w0.102: U2033.4 v2(96.71,82.28) ; v2(46.81,99.81) 47.13,100.13 47.13,100.32 47.01,100.45 46.75,100.45 46.62,100.58 46.62,101.92 45.81,102.73 44.92,102.73 44.77,102.88 44.77,103.27 44.89,103.39 R520.2
USBP8-_TS: length 68.5
  IN3 w0.089: v2(97.34,82.28) 97.12,82.51 97.12,83.02 95.94,84.19 95.94,88.84 94.03,90.75 92.48,90.75 91.6,91.64 88.91,91.64 87.11,93.43 82.73,93.43 81.7,94.46 74.85,94.46 74.08,95.23 70.62,95.23 67.97,97.88 67.1,97.88 64.8,100.18 61.41,100.18 61.1,100.49 51.44,100.49 51.05,100.1 48.36,100.1 47.96,100.49 46.58,100.49 46.32,100.23 46.32,99.95 v2(46.18,99.81)
  BOTTOM w0.102: v2(97.34,82.28) 97.21,82.42 U2033.3 ; v2(46.18,99.81) 46.37,100 46.37,101.81 45.71,102.48 44.81,102.48 44.51,102.78 44.51,103.27 R519.2
USBP8_TS+_C: length 3.7
  BOTTOM w0.102: CN2.5 45.72,106.63 45.6,106.51 45.6,106.26 45.2,105.85 45.2,104.43 44.92,104.15 44.92,104.07 R520.1
USBP8_TS-_C: length 3.7
  BOTTOM w0.102: CN2.4 45.22,106.62 45.35,106.49 45.35,106.36 44.94,105.96 44.94,104.54 44.66,104.26 44.66,104.12 R519.1
USBP_TYPC+_C: length 14.4
  TOP w0.102: R486.1 10.96,11.92 RV8.2 10.24,11.83 10.24,11.55 v2(10.5,11.29)
  IN1 w0.089: v2(10.5,11.29) 10.3,11.49 10.3,11.92 9.38,12.84 9.38,16.14 v2(9.58,16.34) 9.43,16.49 9.43,16.81 9.15,17.09 8.46,17.09 8.35,16.98 7.71,16.98 7.04,16.3 CN14.B6
  BOTTOM w0.102: CN14.A6 7.79,15.65 7.88,15.56 9.05,15.56 9.41,15.92 9.41,16.17 v2(9.58,16.34)
USBP_TYPC-_C: length 14.4
  TOP w0.102: R489.1 10.36,10.63 RV9.2 10.34,10.82 v2(9.87,11.29)
  IN1 w0.089: CN14.B7 6.12,15.66 6.53,16.07 7.13,16.07 7.81,16.75 8.44,16.75 8.56,16.86 9.05,16.86 9.21,16.71 9.21,16.6 v2(8.95,16.34) 9.15,16.14 9.15,12.75 10.07,11.83 10.07,11.49 v2(9.87,11.29)
  BOTTOM w0.102: CN14.A7 7.45,16.15 7.59,16.29 7.81,16.29 7.89,16.22 7.89,15.91 7.99,15.81 8.94,15.81 9.16,16.02 9.16,16.13 v2(8.95,16.34)
USBPWRD2:
  vias: v2(210.37,26.66) v2(214.69,29.96) v2(214.69,29.32) v2(214.69,28.69) v2(214.69,28.05)
VA: length 177.5
  TOP w0.305: v2(135.95,36.18) 135.49,36.64 132.06,36.64 131.81,36.89 PR71.1 131.4,37.36 129.2,35.17 127.06,35.17 126.57,34.68 PD4.2
  IN1 w0.254: v2(111.19,90.92) 111.82,90.92 113.22,89.52 113.22,88.38 113.96,87.64 113.96,87.05 115.38,85.63 115.38,83.68 114.64,82.94 114.64,80.78 115.92,79.5 115.92,78.27 117.82,76.38 117.82,72.74 118.88,71.67 118.88,67.46 123.25,63.09 123.25,60.82 125.28,58.79 125.28,47.48 126.55,46.21 126.55,43.29 129.22,40.63 132.52,40.63 134.68,38.47 134.68,37.57 135.95,36.31 v2(135.95,36.18)
  IN3 w0.254: v2(40.75,120.51) 41.11,120.86 45.68,120.86 46.42,120.13 46.42,119.11 46.8,118.73 49.81,118.73 52.18,121.1 66.35,121.1 66.81,120.64 71.23,120.64 72.45,119.42 73.39,119.42 74.13,118.68 77.35,118.68 78.05,119.38 79.02,119.38 80.43,117.97 84.01,117.97 85.29,116.69 88.72,116.69 89.52,115.89 95.66,115.89 96.51,115.04 96.51,113.39 97.24,112.65 97.24,111.72 97.37,111.6 97.37,109.56 97.85,109.08 97.85,106.84 97.37,106.36 97.37,101.56 99.94,98.99 100.75,98.99 101.9,97.85 101.9,97.16 102.37,96.69 103.07,96.69 105.37,94.39 105.37,94.07 107.07,92.37 109.97,92.37 110.3,92.04 110.3,91.81 v2(111.19,90.92)
  BOTTOM w0.305: PR245.1 136.25,35.81 135.95,36.11 v2(135.95,36.18)
  BOTTOM w0.381: PC143.1 40.25,120.01 v2(40.75,120.51)
  vias: v2(29.53,114.79) v3(11.49,115.43) v3(12.25,115.43) v3(13.14,115.43) v3(13.9,115.43) v3(34.48,117.21) v3(35.24,118.22) v3(35.24,117.49) v3(36.76,115.15) v3(37.22,114.54) v3(37.65,115.15) v3(38.16,114.54)
VA2: length 155.9
  IN1 w0.254: v2(133.58,36.07) 133.13,36.07 130.36,38.85 128.84,38.85 125.18,42.51 125.18,45.43 123.79,46.83 123.79,52.04 121.6,54.22 121.6,58.79 121.85,59.04 121.85,62.65 117.56,66.94 117.56,71.1 114.34,74.32 114.34,76.26 113.58,77.02 113.58,84.19 112.15,85.61 112.15,88.55 109.87,90.83 v2(109.87,91.25)
  IN3 w0.254: v2(45.67,119.75) 45.67,119.09 46.42,118.35 49.97,118.35 52.34,120.72 66.23,120.72 67.43,119.52 68.16,119.52 68.88,120.23 71.14,120.23 72.31,119.06 73.25,119.06 73.98,118.32 77.51,118.32 78.21,119.02 78.87,119.02 80.28,117.61 83.87,117.61 85.95,115.53 86.93,115.53 87.59,116.19 88.71,116.19 89.37,115.53 95.51,115.53 96.15,114.89 96.15,113.24 96.89,112.5 96.89,111.56 97.01,111.43 97.01,109.41 97.47,108.95 97.47,106.96 97.01,106.51 97.01,101.36 99.74,98.64 100.61,98.64 101.54,97.7 101.54,97 102.21,96.33 102.92,96.33 104.4,94.85 104.4,93.79 105.27,92.93 106.01,92.93 107.68,91.25 v2(109.87,91.25)
  BOTTOM w0.203: PR248.1 133.62,36.04 v2(133.58,36.07)
VADJ1: length 4.3
  TOP w0.102: v2(56.83,106.16) 56.83,106.18 56.7,106.31 C61.1 56.54,106.95 R27.1 R26.2
  BOTTOM w0.102: CN2.27 56.72,106.29 56.83,106.18 v2(56.83,106.16) 57.08,105.9 v2(57.59,105.9)
VGA_AC_BATT: length 23.5
  TOP w0.102: R8103.2 125.79,122.03 125.89,121.93 R8107.2 R8104.1 126.3,120.76 126.5,120.96 D8001.2 127.09,120.46 v1(126.78,120.15)
  IN1 w0.089: v1(126.78,120.15) 126.41,119.78 123.42,119.78 123.05,119.41 121.77,119.41 121.16,118.8 118.62,118.8 112.96,113.14 112.96,111.39 v2(112.53,110.96)
  BOTTOM w0.102: U2029.AA34 112.44,110.96 v2(112.53,110.96)
VGA_ALERT: length 13.9
  TOP w0.102: R8069.2 123.86,118.83 TP8529.1 123.38,118.35 120.97,118.35 119.49,116.88 118.26,116.88 116.26,114.88 116.26,112.25 v2(115.76,111.75)
  BOTTOM w0.102: U2029.R37 115.68,111.75 v2(115.76,111.75)
VGA_RSTB: length 12.6
  BOTTOM w0.102: R8134.2 82.99,88.08 82.99,85.97 v2(86.8,82.16) 89.41,79.55 89.41,79.17 89.31,79.08 R2444.1
VGPU_CORE_PG: length 176.2
  IN1 w0.089: v2(88.68,124.6) 88.68,123.66 88.23,123.2 87.84,123.2 87.56,122.92 75.37,122.92 74.31,121.86 74.31,116.9 73.87,116.47 73.87,116.06 73.3,115.49 72.18,115.49 70.67,113.99 70.67,108.19 72.32,106.54 74.99,106.54 75.94,105.59 v2(77.1,105.59)
  IN3 w0.089: v2(112.56,123.68) 112.56,123.15 112,122.59 111.6,122.59 109.54,120.53 108.4,120.53 107.98,120.95 106.91,120.95 106.67,120.71 101.99,120.71 101.87,120.59 101.15,120.59 100.58,120.01 96.18,120.01 95.72,120.48 95.53,120.48 94.33,121.68 94.33,122.5 93.03,123.8 93.03,124.7 92.26,125.46 89.55,125.46 v2(88.68,124.6) ; v1(149.1,61.62) 148.37,62.34 146.62,62.34 145.85,63.12 142.36,63.12 141.74,63.74 141.74,71.54 140.49,72.8 119.57,72.8 118.01,74.35 118.01,76.49 115.91,78.59 115.27,78.59 114.88,78.99 114.88,79.27 114.04,80.1 114.04,82.13 112.33,83.84 110.77,83.84 104.08,90.53 104.08,91.7 99.5,96.28 97.51,96.28 95.4,98.39 92.17,98.39 91.55,99.01 87.77,99.01 87.56,99.22 85.11,99.22 84.14,100.19 84.14,103.85 82.21,105.77 77.28,105.77 v2(77.1,105.59)
  BOTTOM w0.102: U8023.1 112.92,124.05 v2(112.56,123.68)
  BOTTOM w0.152: PR9046.2 74.92,107.2 74.71,107 74.71,105.91 74.93,105.69 75.21,105.69 75.59,105.32 PR9043.2 75.73,105.63 75.88,105.77 76.78,105.77 76.95,105.59 v2(77.1,105.59)
  BOTTOM w0.203: v1(149.1,61.62) 149.3,61.42 PR9118.1
VGPU_CORE_SENSE: length 25.4
  IN2 w0.254: v2(83.74,92.12) 85.78,94.16 91.19,94.16 92,94.97 93.65,94.97 95.17,96.49 96.01,96.49 97.86,98.33 103.36,98.33 103.69,98.67 103.69,99.65 v2(103.89,99.84)
  BOTTOM w0.152: v2(83.74,92.12) 84.02,91.85 PR9055.1
  BOTTOM w0.254: v2(103.89,99.84) 104.4,99.32 U2029.AR13
VL: length 85.5
  TOP w0.254: v2(50.71,20.08) 50.18,19.54 v2(47.31,19.54) 46.41,18.65 PR117.1
  BOTTOM w0.254: v2(50.71,20.08) 50.35,19.72 50.35,18.53 50.54,18.34 51.81,18.34 52.39,17.77 52.39,15.86 52.67,15.58 55.15,15.58 56.6,17.03 59.02,17.03 61.4,19.42 63.94,19.42 66.48,16.88 75.75,16.88 77.02,18.15 77.02,19.42 78.98,21.37 80.67,21.37 81.14,21.84 88.54,21.84 89.36,21.02 91.07,21.02 91.73,20.36 93.23,20.36 93.91,19.67 94.55,19.67 94.92,20.04 94.92,24.36 96.75,26.19 109.13,26.19 109.84,26.89 109.84,28.64 109.54,28.94 109.54,30.34 110.04,30.84 PR191.1
VMON: length 4
  TOP w0.102: U2034.17 22.71,16.36 23.2,16.85 24.19,16.85 24.29,16.75 R6527.2 R6521.2
VQQD_VPPSNS: length 3.7
  TOP w0.229: PU1.12 65.76,123.42 v2(65.79,123.45)
  BOTTOM w0.152: PR123.2 64.04,125.2 v2(64.62,124.62) v2(65.79,123.45)
VREF_PINSET_CPU: length 16.5
  TOP w0.102: v2(152.97,53.45) 153.05,53.37 PR6011.1
  TOP w0.203: PR6011.1 153.22,52.57 154.16,51.62 154.16,51.24 154.49,50.91 PR6059.1 154.35,50.52 154.18,50.52 v1(153.93,50.28) 153.51,49.86 PR6004.1 ; PU6000.15 149.83,53.5 149.88,53.56 v2(149.88,53.56)
  BOTTOM w0.203: PR6058.1 150.58,52.67 ; 150.58,52.67 151.05,53.14 151.65,53.14 151.67,53.12 153.16,53.12 153.62,52.66 153.62,52.04 154.16,51.5 154.16,50.51 v1(153.93,50.28) 153.61,50.28 153.48,50.41 PR6019.1 153.23,50.01 153.36,49.89 PR6062.2 ; 150.58,52.67 PR6063.1 150.58,53.65 149.98,53.65 v2(149.88,53.56) 149.84,53.6 149.28,53.6 PR6060.1
VREF_PINSET_GPU: length 21.9
  IN2 w0.203: v2(64.05,114.67) 64.05,113.54 65.72,111.87 v2(65.72,110.86)
  BOTTOM w0.203: PU9000.15 70.4,111.48 69.47,112.41 68.83,112.41 PR9058.1 68.2,111.78 66.43,111.78 65.72,111.06 v2(65.72,110.86) 65.72,110.7 66.89,109.52 PR9004.1 66.89,109.37 67.29,108.97 67.3,108.97 67.67,108.6 PR9060.2 PR9056.2 ; PR9057.1 PR9061.1 66.75,118.8 66.38,118.43 66.38,118.43 66.1,118.16 PR9008.1 PR9014.1 65.7,117.06 64.05,115.41 v2(64.05,114.67)
VREFC_A0: length 1
  TOP w0.508: C2216.2 140.25,116.83 v2(140.38,116.95)
VREFC_A1:
  vias: v2(140.65,80.89)
VREFD1_A0: length 0.9
  TOP w0.102: v2(149.03,114.79) 148.76,114.52 R2642.2
  vias: v2(147.99,112.68)
VREFD1_A1:
  vias: v2(131.89,88.38)
VREFD2_A0:
  vias: v2(131.38,112.13)
VREFD2_A1: length 5.9
  IN1 w0.508: v2(147.39,86.19) 147.39,84.56 147.84,84.11 147.84,81.28 v2(147.28,80.73)
VRM_PWRGD: length 126
  TOP w0.102: R131.1 106.7,27.72 107.09,27.72 107.5,28.14 107.5,28.25 107.89,28.64 108.34,28.64 108.57,28.87 v2(110.3,28.87) 110.66,28.87 115.63,33.84 115.63,34.4 115.39,34.65 R128.2 115.44,34.91 116.43,35.9 116.93,35.9 117.44,36.4 117.44,38.04 116.99,38.49 116.24,38.49 115.96,38.77 115.96,39.71 116.88,40.63 R130.2 117.15,39.98 117.02,39.85 v1(117.02,39.49) 117.22,39.29 D2025.2 ; PR6049.2 PR6048.2 143.83,48.49 144.08,48.25 144.08,44.67 144.89,43.85 148.98,43.85 v2(149.29,43.55) ; D8.1 155.07,13.27 154.24,12.43 147.13,12.43 143.14,16.42 143.14,17.44 146.21,20.51 146.21,22.89 145.74,23.36 145.4,23.69 145.4,24.44 142.71,27.13 141.95,27.13 140.65,28.43 140.65,31.05 v2(140.83,31.23)
  IN1 w0.089: v2(140.83,31.23) 141.4,31.23 144.32,28.31 146.55,28.31 147.02,28.78 147.02,29.11 146.49,29.63 146.49,33.88 145.84,34.53 145.84,41.25 148.14,43.55 v2(149.29,43.55)
  IN2 w0.089: v2(140.83,31.23) 140.81,31.21 138.66,31.21 137.22,32.65 137.22,34.15 136.97,34.4 130.62,34.4 129.98,35.04 125.41,35.04 124.9,35.55 124.9,40.63 124.65,40.88 123.25,40.88 121.17,38.8 117.71,38.8 v1(117.02,39.49)
VRON: length 79.7
  TOP w0.102: v2(179.92,17.43) 180,17.36 U13.69 182.2,17.36 182.43,17.59 182.43,18.02 182.94,18.53 R459.1
  TOP w0.203: v2(144.47,59.75) PR6028.1
  IN3 w0.089: v2(182.04,30.54) 181.61,30.97 179.98,30.97 179.8,30.79 175.94,30.79 175.31,31.42 174.01,31.42 173.18,32.25 173.18,33.02 172.87,33.33 168.14,35.29 161.99,35.29 161.6,35.68 157.01,35.68 152.59,37.51 151.89,38.21 151.89,39.51 149.69,41.71 149.69,43.78 148.27,45.2 148.27,46.41 150.31,48.45 150.31,51.03 149.16,52.18 149.16,54.6 146.62,57.14 146.62,57.6 v2(144.47,59.75)
  BOTTOM w0.102: v2(182.04,30.54) 182.04,30.2 181.42,29.58 181.42,26.4 181.65,26.17 181.65,23.33 179.51,21.2 179.17,21.2 178.88,20.9 178.88,19.42 179.28,19.01 179.28,18.07 v2(179.92,17.43)
VSEN_CPU: length 1.8
  TOP w0.203: PU6000.8 147.35,50.14 v2(147.37,50.12)
  BOTTOM w0.203: v2(147.37,50.12) 147.53,50.28 PR6056.1
VSYNC: length 17.9
  TOP w0.102: v2(113.68,111.7) 114.29,112.31 114.29,113.88 119.09,118.68 120.33,118.68 120.71,119.06 121.12,119.06 121.83,119.77 121.83,122.64 122.13,122.94 122.39,122.94 122.49,123.05 R2220.2 R2213.2
  BOTTOM w0.102: v2(113.68,111.7) 113.3,111.32 U2029.W35
WCKA0_0: length 33.7
  IN1 w0.089: v2(120.83,109.77) 120.6,109.53 120.6,109.4 120.69,109.31 122.26,109.31 123.12,108.44 123.12,105.72 124.72,104.13 130.81,104.13 132.02,102.92 136.85,102.92 138.82,104.89 138.82,106.23 139.35,106.76 142.78,106.76 144.29,108.27 144.29,108.51 144.2,108.6 v2(143.98,108.6)
  BOTTOM w0.102: U2029.D33 120.96,110.32 120.74,110.1 120.74,109.87 v2(120.83,109.77) ; v2(143.98,108.6) 144.24,108.6 144.38,108.46 VRAM2001.D4
WCKA0_1: length 17.9
  IN1 w0.089: v2(125.19,110.6) 124.9,110.89 124.9,111.01 125.25,111.37 133.67,111.37 134.9,110.13 135.54,110.13 136.29,109.38 136.29,108.89 v2(135.98,108.58)
  BOTTOM w0.102: v2(135.98,108.58) 136.27,108.58 136.38,108.47 VRAM2001.P4 ; U2029.A34 122.85,110.98 122.85,111.09 122.95,111.19 123.1,111.19 123.2,111.1 123.42,111.1 123.68,111.37 124.55,111.37 124.84,111.08 124.84,110.67 124.91,110.6 v2(125.19,110.6)
WCKA0B_0: length 33.7
  IN1 w0.089: v2(144.78,108.6) 144.47,108.29 144.47,108.2 142.85,106.58 139.42,106.58 139,106.16 139,104.82 136.92,102.74 131.95,102.74 130.74,103.95 124.64,103.95 122.95,105.65 122.95,108.37 122.18,109.14 120.61,109.14 120.42,109.33 120.42,109.53 v2(120.18,109.76)
  BOTTOM w0.102: VRAM2001.D5 144.39,108.98 v2(144.78,108.6) ; v2(120.18,109.76) 120.4,109.99 U2029.E33
WCKA0B_1: length 18.3
  IN1 w0.089: v2(136.78,108.58) 136.47,108.89 136.47,109.45 135.61,110.31 134.97,110.31 133.74,111.54 125.18,111.54 124.72,111.09 124.72,110.89 v2(124.43,110.6)
  BOTTOM w0.102: v2(136.78,108.58) 136.78,108.58 VRAM2001.P5 ; U2029.B34 122.53,110.87 122.83,110.57 123.08,110.57 123.4,110.89 123.5,110.89 123.77,111.16 124.46,111.16 124.63,110.99 124.63,110.8 v2(124.43,110.6)
WCKA1_0: length 26.5
  IN3 w0.089: v2(125.69,103.24) 125.42,102.97 125.43,102.85 125.97,102.31 126.85,102.31 127.31,101.85 128.6,101.85 128.64,101.8 129.03,101.8 129.07,101.85 129.81,101.85 130.35,101.3 130.35,101.26 131.75,99.85 131.75,98.12 132.33,97.54 132.33,94.24 132.54,94.03 132.54,92.11 133.67,90.99 133.67,90.51 133.69,90.48 133.69,90.38 134.3,89.78 135.82,89.78 135.95,89.9 135.95,90.36 136.27,90.68 136.47,90.68 v2(136.78,90.99)
  BOTTOM w0.102: v2(125.69,103.24) 125.54,103.24 125.31,103.47 125.31,103.62 125.09,103.85 124.09,103.85 123.71,104.23 123,104.23 U2029.A22 ; VRAM2002.D4 136.38,91.08 136.47,90.99 v2(136.78,90.99)
WCKA1_1: length 28.1
  IN1 w0.089: v2(128.06,93.43) 128.43,93.43 128.51,93.51 133.62,93.51 134.93,92.19 136.58,92.19 137.98,90.79 138.36,90.79 138.75,90.41 138.75,89.83 139.03,89.55 143.4,89.55 144.03,90.18 144.03,90.44 144.27,90.68 144.47,90.68 v2(144.78,90.99)
  BOTTOM w0.102: U2029.A8 123.47,96.57 123.76,96.29 124.61,96.29 126.24,94.65 128.5,94.65 128.64,94.52 128.64,93.65 128.42,93.43 v2(128.06,93.43) ; v2(144.78,90.99) VRAM2002.P4
WCKA1B_0: length 26.6
  IN3 w0.089: v2(124.98,103.24) 125.25,102.97 125.25,102.91 125.25,102.85 125.25,102.77 125.84,102.18 125.89,102.13 126.77,102.13 127.24,101.67 128.53,101.67 128.57,101.63 129.1,101.63 129.14,101.67 129.73,101.67 130.17,101.23 130.17,101.18 131.58,99.78 131.58,98.04 132.15,97.46 132.15,94.17 132.36,93.96 132.36,92.04 133.49,90.91 133.49,90.43 133.51,90.41 133.51,90.31 134.23,89.6 135.9,89.6 136.13,89.83 136.13,90.29 136.34,90.51 136.47,90.51 v2(136.78,90.19)
  BOTTOM w0.102: v2(136.78,90.19) VRAM2002.D5 ; v2(124.98,103.24) 125.11,103.36 125.11,103.54 125,103.64 124.01,103.64 123.62,104.03 123.15,104.03 123.07,103.95 122.83,103.95 U2029.B21
WCKA1B_1: length 28.9
  IN1 w0.089: v2(144.78,90.19) 144.47,90.51 144.34,90.51 144.21,90.37 144.21,90.1 143.47,89.37 138.95,89.37 138.57,89.75 138.57,90.33 138.29,90.61 137.91,90.61 136.51,92.02 134.86,92.02 133.54,93.33 128.67,93.33 128.56,93.22 v2(128.56,92.92)
  BOTTOM w0.102: v2(144.78,90.19) VRAM2002.P5 ; U2029.B9 122.84,97.12 123.19,96.78 123.55,96.78 123.84,96.49 124.69,96.49 126.33,94.86 128.59,94.86 128.84,94.6 128.84,93.57 128.56,93.29 v2(128.56,92.92)
WEA0B: length 26.8
  TOP w0.102: v2(119.26,107.68) 119.44,107.68 120,108.24
  TOP w0.127: 120,108.24 121.75,108.24 123.02,109.51 123.02,110.58 123.51,111.06 129.07,111.06 v2(131.27,113.26) 131.61,113.6 132.24,113.6 132.36,113.72 132.36,114.53 132.49,114.65 132.75,114.65 132.87,114.53 132.87,113.72 133,113.6 135.58,113.6 135.71,113.72 135.71,114.34 135.84,114.46 136.07,114.46 136.22,114.31 136.22,113.72 136.34,113.6 137.79,113.6 v2(138.38,114.18)
  BOTTOM w0.102: U2029.G29 119.6,108.02 v2(119.26,107.68)
  BOTTOM w0.127: v2(138.38,114.18) 138.78,114.58 VRAM2001.L12
WEA1B: length 28
  TOP w0.102: 124.93,94.73 122.5,97.15 120.99,97.15 120.76,97.38 v2(120.76,97.7)
  TOP w0.127: 124.93,94.73 124.93,94.63 127.49,92.06 v2(129.6,92.06) 129.87,92.06 131.38,90.55 131.38,89.7 132.7,88.38 134.05,88.38 134.3,88.12 135.49,88.12 135.95,87.67 136.92,87.67 137.09,87.49 137.09,86.8 137.25,86.65 139.48,86.65 139.61,86.52 139.61,86.15 139.46,85.99 138.68,85.99 138.43,85.74 v2(138.43,85.39)
  BOTTOM w0.102: v2(120.76,97.7) 121.2,98.14 U2029.D11
  BOTTOM w0.127: v2(138.43,85.39) 138.78,85.04 VRAM2002.G12
WIGIG_LED: length 4.8
  TOP w0.102: v2(187.26,30.44) 186.4,30.44 TP83.1
  BOTTOM w0.102: CN9.6 189.62,29.88 188.91,30.59 187.41,30.59 v2(187.26,30.44)
WLAN_RST#: length 103.1
  TOP w0.102: v2(192.39,21.34) 192.04,20.99 R77877.1
  IN2 w0.089: v1(108.02,31.66) 108.28,31.91 109.84,31.91 110.04,32.12 110.85,32.12 113.01,29.96 119.62,29.96 121.45,28.13 131.53,28.13 132.64,27.02 136.06,27.02 137.84,28.8 139.83,28.8 140.14,29.11 143.61,29.11 144.57,28.15 155.69,28.15 156.76,27.08 164.93,27.08 165.74,27.89 167.41,27.89 168.6,26.7 169.09,26.7 169.42,27.03 173.22,27.03 174.37,28.18 177.1,28.18 178.01,29.09 181.32,29.09 181.79,29.57 183.71,29.57 184.08,29.2 184.72,29.2 184.97,29.45 185.74,29.45 187.89,27.29 187.89,25.86 188.39,25.37 191.27,25.37 191.82,24.81 192.29,24.81 193.1,24 193.1,22.59 192.66,22.15 192.66,21.62 v2(192.39,21.34)
  BOTTOM w0.102: v2(192.39,21.34) 192.04,20.99 192.04,20.43 192.29,20.18 192.87,20.18 193,20.05 193,19.16 R819.1 ; D6543.3 107.13,30.76 v1(108.02,31.66)
WLAN_RST#_R: length 2
  BOTTOM w0.102: R819.2 192.37,18.43 192.32,18.38 CN9.52
WLANPWR#: length 3.2
  TOP w0.102: U13.35 168.02,13.31 167.89,13.18 166.7,13.18 166.3,13.58 TP48.1
WRST#: length 8.5
  TOP w0.102: v2(166.74,22.88) 166.71,22.88 166.64,22.96 U13.14
  BOTTOM w0.102: v2(166.74,22.88) 166.74,22.67 v2(167.19,22.21) 167.19,21.7 167.46,21.44 168.2,21.44 168.4,21.64 168.4,21.89 168.73,22.22 C435.1 169.98,22.22 170.11,22.08 D13.2 170.7,21.49 R399.1
XIN: length 6.6
  BOTTOM w0.102: Y2005.1 89.29,85.58 90.77,85.58 C2765.1 91.65,85.46 92.9,85.46 93.02,85.34 U2033.10
XOUT: length 4.4
  BOTTOM w0.102: U2033.11 93.41,85.84 93.16,86.08 C2766.1 90.84,86.08 Y2005.3
XTAL1: length 2.7
  TOP w0.102: R16.2 45.3,109.62 45.17,109.48 45.17,108.62 44.84,108.29 U1.28
XTAL2: length 1.7
  TOP w0.102: U1.29 44.44,108.74 R15.1
XTAL2_R: length 3.4
  TOP w0.102: R15.2 44.38,109.85 44.27,109.96 44.27,110.1 44.52,110.35 44.52,110.48 44.42,110.58 44.13,110.58 44.01,110.7 C32.1 44.23,111.2 44.23,111.39 43.94,111.68 Y1.3
XTALIN: length 14.2
  TOP w0.102: v2(103.85,118.48) 102.68,118.48 102.55,118.6 102.55,118.82 105.01,121.27 105.34,121.27 105.58,121.5 R77829.1
  BOTTOM w0.102: R2652.1 104.36,118.99 v2(103.85,118.48) 103.47,118.1 101.71,118.1 100.19,116.58 100.19,114.19 U2029.BA39
XTALOUT: length 13.5
  TOP w0.102: R77830.2 104.94,122.49 TP9079.1 104.46,122.01 104.46,121.29 102.02,118.86 101.66,118.86 v2(101.03,118.22)
  BOTTOM w0.102: U2029.AY39 101.18,113.62 100.88,113.32 100.56,113.32 99.76,114.12 99.76,116.83 101.03,118.1 v2(101.03,118.22)
ZQ_A0: length 6.4
  BOTTOM w0.102: VRAM2001.J13 139.91,115.85 139.91,118.33 v2(139,119.24) R2640.2
ZQ_A1: length 4.5
  BOTTOM w0.102: VRAM2002.J13 140.37,84.19 140.04,83.86 140.04,83.33 139.92,83.2 R2679.2
N06325: length 4.1
  BOTTOM w0.102: v2(70.17,26.66) 70.65,26.18 R807.2 70.65,25.62 71.05,25.21 R820.2 R798.1 70.58,24.34 70.34,24.57 Q43.3
N301427: length 2.2
  TOP w0.102: R2222.1 124.87,119.9 124.66,120.12 C2185.1 124.66,120.75 124.52,120.89 R2223.1
N9111136: length 0.8
  TOP w0.102: R2215.2 R2226.1
N9111150: length 0.8
  TOP w0.102: R2216.2 R2231.1
N17002655: length 3.2
  BOTTOM w0.102: C629.2 205.56,21.06 205.29,21.32 205.29,22.24 204.54,23 U30.39
N17002661: length 6.7
  BOTTOM w0.102: C615.2 208.72,21.32 208.49,21.09 207.61,21.09 207.23,20.71 206.87,20.71 206.61,20.96 206.61,22.54 206.18,22.97 205.46,22.97 205.33,23.1 U30.37
N17002676: length 1.9
  BOTTOM w0.102: U30.34 206.82,25.26 207.45,24.62 C622.1
N17002678: length 2.1
  BOTTOM w0.102: U30.19 203.33,30.41 203.39,30.47 C635.1
N17002722: length 3.8
  TOP w0.102: v2(199.58,22.97) 199.78,22.77 v2(200.21,22.77) 200.42,22.97 200.82,22.97 200.95,23.1 R338.2 R366.1
  BOTTOM w0.102: v2(200.21,22.77) 200.42,22.97 200.81,22.97 200.94,23.1 U30.48
N17002952: length 2.3
  BOTTOM w0.102: U30.7 199.4,26.86 199.35,26.81 198.47,26.81 C659.1
N17002968: length 4.5
  BOTTOM w0.102: U30.11 199.43,28.46 199.1,28.79 198.05,28.79 R782.2 R754.1 198.03,29.83 197.9,29.96 197.29,29.96 197.04,29.7 R772.1
N17002995: length 4.5
  BOTTOM w0.102: U30.12 199.54,28.86 199.38,29.02 199.38,30.28 C660.1 198.68,30.71 198.31,30.34 R746.1 198.03,30.69 198.15,30.82 R756.1
N17003129: length 3.5
  BOTTOM w0.102: U30.35 206.84,24.86 207.2,24.5 207.2,23.99 207.43,23.75 207.81,23.75 208.38,23.19 C615.1
N17003186: length 3
  BOTTOM w0.203: U30.20 203.73,31.28 204.21,31.76
  BOTTOM w0.381: 204.21,31.76 R695.1
N17004316: length 2.7
  BOTTOM w0.102: Q45.3 194.12,19.31 D37.1
N17047007: length 2.9
  TOP w0.152: PR18.2 52.82,114.83 52.82,116.74 52.66,116.9 PR12.1
  vias: v2(51.37,114.67)
N17047009: length 2.2
  BOTTOM w0.198: PR261.2 132.16,28.31 133.03,28.31 133.42,28.7 PU12.20
N17047028: length 2.8
  BOTTOM w0.198: PR267.2 132.06,27.88 133.08,27.88 133.82,28.62 PU12.19
N17047083: length 2.3
  BOTTOM w0.305: PJ11.5 101.28,21.45 100.61,22.12 100.61,22.66 100.22,23.05 PR113.1
N17047087: length 16.3
  TOP w0.508: v3(118.76,28.43) 118.81,28.47 PC91.1 v2(123.76,28.47) 128.89,28.47 129.01,28.36 129.64,28.36 130.35,27.65 PR108.1
  BOTTOM w0.152: PR270.1 114.11,26.16 113.81,26.46 112.12,26.46 111.94,26.64 PR266.1
  vias: v3(116.43,28.42) v3(116.71,27.67) v3(117.22,28.43) v3(117.49,27.68) v3(117.97,28.43) v3(118.25,27.68) v3(119.03,27.68)
N17047112: length 164.5
  TOP w0.381: PC8.2 41.6,120.2 PQ3.4 v2(42.86,119.87) 43.01,120.03 PC6.2 ; v2(43.37,115.05) 43.75,114.67 PQ4.4
  IN1 w0.254: v2(111.87,89.65) 112.51,89.01 112.51,86.75 113.93,85.33 113.93,77.17 114.69,76.41 114.69,74.47 117.92,71.25 117.92,67.17 122.27,62.82 122.27,58.95 121.96,58.64 121.96,54.37 124.14,52.18 124.14,46.98 125.54,45.58 125.54,42.66 128.93,39.26 130.53,39.26 133.23,36.56 133.79,36.56 134.21,36.14 v2(134.21,36.08)
  IN3 w0.254: v2(42.86,119.87) 43.76,119.87 46,117.64 50.27,117.64 52.64,120.01 65.93,120.01 67.13,118.81 71.55,118.81 72.01,118.35 72.94,118.35 74.39,116.9 83.57,116.9 86.54,113.93 92.26,113.93 94.63,111.57 95.87,111.57 96.26,111.17 96.26,109.14 96.58,108.83 96.58,107.17 96.26,106.86 96.26,100.93 104.97,92.22 105.71,92.22 107.77,90.16 110.55,90.16 111.05,89.65 v2(111.87,89.65)
  BOTTOM w0.203: PR247.1 134.22,35.81 134.22,36.07 v2(134.21,36.08)
  BOTTOM w0.381: v2(43.37,115.05) 43.37,116.57 42.86,117.08 v2(42.86,119.87)
N17047335: length 3.2
  BOTTOM w0.508: PR268.2 125.23,27.36 v2(125.6,27.74) 126.49,28.63 PC249.1
N17047399: length 1.5
  BOTTOM w0.559: PR254.2 128.86,31.12 128.86,32.48 PC243.2
N17047601: length 8.8
  TOP w0.508: PR99.2 129.89,29.6 129.04,29.6 128.69,29.25 v2(125.16,29.25) PC91.2
N17398787: length 2.6
  BOTTOM w0.198: PU12.5 134.62,33.91 135.05,34.34 135.05,35.16 135.32,35.44 PR80.1
N17424918: length 1.7
  BOTTOM w0.198: PR253.1 137.54,31.86 136.85,31.18 PU12.11
N17424920: length 1.5
  BOTTOM w0.198: PU12.12 136.92,30.78 137.38,31.24 PR255.1
N17424921: length 2.8
  BOTTOM w0.198: PU12.7 135.42,33.49 135.7,33.77 v2(136.46,33.77) 137,34.31 PR249.1
N17424925: length 2
  BOTTOM w0.198: PU12.9 136.67,31.98 136.85,32.16 136.85,32.54 137.46,33.15 PR251.1
N17424950: length 2.1
  BOTTOM w0.198: PR88.1 PR86.2 135.75,28.51 135.42,28.83 PU12.15
N17661815: length 2
  BOTTOM w0.198: PU12.8 136.22,32.46 137.54,33.77 PR250.1
N18867651:
  vias: v2(151.19,26.4)
N18867812:
  vias: v2(19.24,29.32) v3(18.98,30.24) v3(19.72,30.24) v3(20.25,29.73) v3(20.25,28.99)
N19521323: length 1.6
  TOP w0.203: PQ12.3 143.08,32.14 143.75,32.82 PR83.1
N19521733: length 3.5
  TOP w0.203: PR96.1 PR92.1 142.17,29.2 142.3,29.07 PR82.2
  TOP w0.254: PQ12.2 142.12,30.14 142.58,29.68 PR82.2
N19549602: length 6.5
  TOP w0.102: v2(49.59,17.26) 49.34,17.51 PR122.1
  TOP w0.203: PR118.2 46.68,15.68 47.15,16.16 47.37,16.16 47.83,16.61 47.83,16.94 47.95,17.07 48.41,17.07 48.43,17.1 PQ13.2 48.43,17.75 48.58,17.89 PR121.1 PR122.1
N25369938: length 4.6
  TOP w0.102: v2(69.91,15.99) 70.04,16.12 R437.1 70.7,16.21 69.55,17.36 69.55,17.91 70,18.37 Q21.1
N25369947: length 1.6
  TOP w0.102: R450.1 71.72,16.91 71.88,17.07 Q21.4
N26277307: length 45.1
  IN1 w0.127: v2(146.83,48.86) 146.41,49.28 145.37,49.28 144.22,48.13 143.23,48.13 142.72,47.62 141.17,47.62 140.02,46.47 134.9,46.47 133.75,47.62 130.35,47.62 128.46,49.51 v2(128.3,49.51)
  BOTTOM w0.127: v2(128.3,49.51) 127.84,49.96 123.72,49.96 121.3,52.38 121.3,52.55 PR6055.2 120.27,53.58 v2(120.08,53.58) 119.53,53.58 118.54,52.59 114.08,52.59 113.47,53.2 PR6000.2
  BOTTOM w0.203: PR6053.1 PC6016.1 146.62,47.46 147.13,47.97 147.13,48.56 v2(146.83,48.86) 146.83,48.9 146.86,48.93 146.86,50.31 146.75,50.42 PR6056.2 146.75,51.12 PC6018.1
N26277311: length 0.9
  TOP w0.203: PR6006.1 PR6011.2
N26277331: length 0.9
  TOP w0.203: PR6009.2 PR6010.1
N26277333: length 0.9
  TOP w0.203: PR6004.2 PR6005.1
N26277349: length 28.7
  IN1 w0.127: v1(151.8,50.19) 149.1,50.19 148.68,50.61 145.03,50.61 142.5,48.08 140.98,48.08 139.83,46.93 136.11,46.93 134.95,48.08 130.83,48.08 v2(129.52,49.39)
  BOTTOM w0.203: PR6021.2 129.91,49 v2(129.52,49.39) ; 151.18,50.75 PR6020.2 ; 151.18,50.75 151.84,51.4 151.84,52.07 152.18,52.41 PR6007.1 ; 151.18,50.75 151.24,50.75 v1(151.8,50.19)
N26277351: length 1.5
  BOTTOM w0.203: PR6007.2 153.11,52.19 152.84,51.93 152.59,51.93 152.33,51.67 PR6024.2
N26277353: length 1.8
  BOTTOM w0.203: PR6020.1 151.41,49.73 152.04,49.73 152.45,50.14 PR6019.2
N26277375: length 1.1
  BOTTOM w0.203: PC6019.1 149.06,53.03 148.89,53.2 148.88,53.2 148.48,53.6 PR6060.2
N26277377: length 2
  BOTTOM w0.203: PR6018.1 133.5,79.2 133.74,79.44 PR6012.1
  BOTTOM w0.305: PR6018.1 PR6013.1
N26277386: length 41.9
  TOP w0.203: PR6017.1 PR6006.2 150.55,52.58 151.09,53.12 152.26,53.12 152.47,53.33 152.47,54.96 150.66,58.68 v2(150.06,59.29) v2(149.3,59.29)
  IN2 w0.127: v2(149.3,59.29) 149.3,59.2 148.78,58.68 148.25,58.68 148.08,58.85 148.08,58.85 145.48,61.44 142.34,61.44 140.21,63.58 140.21,72.31 138.52,74 138.52,77.02 137.67,77.87 135.4,77.87 134.9,78.37 v2(134.02,78.37)
  BOTTOM w0.203: v2(134.02,78.37) 134.02,78.86 PR6012.2
N26277388: length 1.4
  TOP w0.305: PR6033.2 140.71,53.01 141.06,52.66 PC6009.2
N26277392: length 44.6
  IN2 w0.127: v2(151.98,54.24) 151.37,54.24 150.57,55.04 150.57,55.62 150.81,55.87 150.81,58.89 149.21,60.49 147.45,60.49 145.8,62.14 142.72,62.14 140.89,63.97 140.89,72.6 139.21,74.28 139.21,77.3 137.91,78.6 135.68,78.6 134.83,79.45 131.97,79.45 v2(131,78.47)
  BOTTOM w0.102: v2(152.59,53.83) 152.19,54.24 v2(151.98,54.24)
  BOTTOM w0.203: PR6065.2 130.7,78.77 v2(131,78.47) ; v2(151.98,54.24) 151.64,54.58 PR6066.1 PR6063.2
N26277394: length 51.4
  TOP w0.203: v1(151.17,47.48) 151.9,48.22 152.77,48.22 153.58,49.03 153.88,49.03 154.49,49.64 PR6059.2
  IN2 w0.127: v2(131.95,78.47) 132.69,79.22 134.74,79.22 135.6,78.36 137.83,78.36 138.98,77.21 138.98,74.19 140.66,72.5 140.66,63.87 142.62,61.91 145.71,61.91 147.35,60.26 149.11,60.26 150.58,58.79 150.58,55.96 150.3,55.68 150.3,54.56 150.47,54.4 150.47,48.19 v1(151.17,47.48)
  BOTTOM w0.203: v2(131.95,78.47) 131.48,78.94 PR6065.1
N26277398: length 1.2
  TOP w0.305: PC6004.2 139.52,55.35 PR6014.2
N26277400: length 2.4
  TOP w0.102: PR6043.2 141.65,48.74 v2(141.54,48.63)
  TOP w0.483: PR6043.2 141.65,50.17 141.42,50.4 PC6013.2
N26277406: length 0.9
  TOP w0.203: PR6017.2 PR6016.1
N26277420: length 3.8
  BOTTOM w0.203: PR6022.1 126.63,48.78 127.1,48.31 128.66,48.31 129.13,48.78 PR6025.1 129.37,48.55 PR6021.1
N26277422: length 42.2
  IN2 w0.127: v2(145.74,59.87) 144.39,61.22 142.19,61.22 139.98,63.43 139.98,72.22 139.74,72.45 138.29,73.9 138.29,76.92 137.57,77.64 135.3,77.64 134.99,77.95 130.89,77.95 130.58,78.26 130.58,78.82 130.91,79.14 v2(130.91,80.83)
  BOTTOM w0.127: PR6029.2 128.62,80.41 128.08,79.87 124.65,79.87 124.14,80.38 PR6030.2
  BOTTOM w0.203: v2(145.74,59.87) 145.64,59.78 145.64,59.74 145.65,59.74 PR6027.1 PC6008.1 ; PR6029.2 130.05,80.73 130.81,80.73 v2(130.91,80.83)
N26277961: length 2.5
  TOP w0.102: PR6067.2 131.17,59.85 v2(130.74,59.42)
  TOP w0.483: PR6067.2 132.44,59.85 132.56,59.97 PC6031.1
N26277963: length 1.3
  BOTTOM w0.483: PR6070.2 136.45,48.45 PC6047.1
N26277967: length 2.4
  BOTTOM w0.102: PR6073.2 140.07,72.31 v2(140.27,72.5)
  BOTTOM w0.508: PR6073.2 139.27,72.87 139.09,73.05 PC6065.1
N26418322: length 1.9
  BOTTOM w0.152: PR2008.2 130.26,37.68 130.02,37.93 130.02,38.5 PC2013.1
  vias: v2(131.76,47.79)
N26418350:
  vias: v2(142.43,42.53) v2(143.61,43.57) v2(143.62,42.74) v2(143.64,41.98)
N26418727: length 1.4
  BOTTOM w0.508: PR2007.2 138.75,37.54 PC2015.1
N26418739: length 1.3
  BOTTOM w0.457: PR2003.1 139.1,46.24 138.93,46.41 PC2005.2
N26547647: length 7.2
  BOTTOM w0.102: PR9132.2 PC9091.1 116.14,79.36 115.95,79.55 PQ9003.2 v2(112.65,79.55) 112.39,79.29 PQ9006.3
N27032306: length 2.5
  TOP w0.203: v1(145.21,57.03) 145.28,56.97 145.28,56.95 145.35,56.88 PU6000.28
  BOTTOM w0.254: PR6003.2 145.19,57.19 145.19,57.12 145.21,57.11 v1(145.21,57.03)
  BOTTOM w0.381: v1(145.21,57.03) 145.61,56.63 PC6003.1
N27032510: length 29.2
  IN1 w0.127: v2(152.56,48.73) 152.58,48.75 152.58,50.13 150.97,51.74 145.19,51.74 142.21,48.77 140.7,48.77 139.54,47.61 136.39,47.61 135.23,48.77 131.79,48.77 v2(130.57,49.99)
  BOTTOM w0.203: v2(130.57,49.99) 130.62,49.99 131.82,48.79 PR6057.1 ; PR6062.1 152.58,48.75 v2(152.56,48.73)
N27032514: length 26.1
  TOP w0.102: v2(131,48.75) 130.57,49.18 v2(130.57,49.35)
  IN1 w0.127: v2(149.77,50.9) 149.13,50.9 148.85,51.18 144.95,51.18 142.31,48.54 140.79,48.54 139.64,47.38 136.3,47.38 135.14,48.54 131.39,48.54 v2(130.57,49.35)
  BOTTOM w0.203: PR6057.2 130.57,49.25 v2(130.57,49.35) ; v2(149.77,50.9) 150.07,51.2 150.87,51.2 151.36,51.69 PR6054.1 PR6058.2
N27752748: length 2.4
  BOTTOM w0.381: R695.2 204.81,33.92 205.17,34.28 R694.2 R697.1
N28087213:
  vias: v2(25.59,112.38) v2(25.59,111.75) v2(27.11,112)
N28100067: length 2
  BOTTOM w0.102: R796.1 69.15,22.21 69.32,22.04 CN12.8
N30442036:
  vias: v2(20,25.44) v3(19.49,25.92) v3(20.23,26.12) v3(20.38,26.86) v3(20.76,25.61) v3(21.07,26.29)
N30442060: length 4.7
  TOP w0.203: PR93.1 26.89,28.69 26.76,28.82 25.03,28.82 24.82,28.6 PC93.1 24.56,28.05 PU6.4
N30442062: length 2
  TOP w0.203: PU6.12 20.74,27.65 20.51,27.42 20.01,27.42 PC98.1
N30442063: length 1.8
  TOP w0.203: PC92.1 19.95,28.45 PU6.10
N30442080: length 5
  TOP w0.203: PU6.5 23.95,28.45 PC87.1 24.82,29.7 24.95,29.83 26.73,29.83 26.89,29.68 PR89.2
N30442084: length 4.5
  TOP w0.203: PU6.3 24.46,27.65 PC99.1 25.32,27.79 26.71,27.79 26.89,27.61 PR100.1
N30568314: length 4.3
  TOP w0.305: PR78.1 PC70.2 146.44,35.68 146.96,35.16 v2(146.96,35.05)
  TOP w0.356: v2(146.96,35.05) 147.52,35.61 PR84.2
  BOTTOM w0.229: v2(146.96,35.05) 146.96,34.78 PU11.12
N30568326: length 2.2
  TOP w0.102: v2(146.62,38.34) PR72.1
  TOP w0.305: PR72.1 146.62,37.2 146.33,36.91 146.33,36.9 145.89,36.46 PC70.1
N30568332: length 1.5
  BOTTOM w0.254: PC261.2 47.41,15.3 47.93,15.83 47.93,16.56
N30568337:
  vias: v2(142.73,31.36)
N30568424: length 3.5
  BOTTOM w0.152: PU15.9 44.23,16.89 44.53,16.59 44.53,16.22 PR275.2
  BOTTOM w0.229: PR274.1 44.7,14.14 PC272.2 PR275.2
N30568429: length 1
  BOTTOM w0.229: PC272.1 45.48,14.3 PR278.1
N30568472: length 0.8
  BOTTOM w0.229: v2(42.92,16.66) 42.88,16.71 PU15.12
  vias: v2(43.11,17.51)
N30568498: length 3.7
  TOP w0.254: PR279.1 44.4,15.99 45.27,15.12 PQ13.3
N30568535: length 3.7
  TOP w0.203: PR230.2 143.06,35.17 143.26,34.97 v2(143.26,34.77) 143.17,34.68 143.17,34.12 143.01,33.97 PR234.2 143.01,33.18 PR237.1
  BOTTOM w0.203: v2(143.26,34.77) 143.17,34.87 143.17,35.6 143.32,35.75 PR244.2
N31069510:
  vias: v2(156.02,25.39)
N31161958: length 3.4
  TOP w0.203: v2(154.91,30.74) 154.93,30.73 PU7.4
  BOTTOM w0.203: PR260.1 155.38,28.94 155.36,28.92 PC251.1 154.92,30.74 v2(154.91,30.74)
N31161974: length 1.8
  TOP w0.203: PU7.12 155.33,27.17 v2(155.31,27.15)
  BOTTOM w0.254: v2(155.31,27.15) 155.87,27.71 PC111.1
N31161976: length 2.1
  TOP w0.203: v2(154.68,27.15) 154.53,27.31 PU7.10
  BOTTOM w0.254: PC110.1 153.97,27.56 154.38,27.15 v2(154.68,27.15)
N31162017: length 7.3
  TOP w0.203: PU7.5 154.53,30.43 154.28,30.68 v2(154.28,30.78)
  BOTTOM w0.102: PR259.2 152,28.23 v2(151.83,28.05)
  BOTTOM w0.203: PC250.1 153.97,29.43 154.28,29.74 v2(154.28,30.78) 153.29,30.78 152,29.5 PR259.2
N31162025: length 3.9
  TOP w0.203: v2(155.55,30.77) 155.55,30.71 155.33,30.49 PU7.3
  BOTTOM w0.203: v2(155.55,30.77) 155.55,30.17 155.89,29.83 PC252.1 156.26,30.2 156.78,30.72 PR257.1
N33761123: length 2.7
  TOP w0.102: R501.1 R498.2 30.85,3.54 v2(30.6,3.29)
  BOTTOM w0.102: CN18.38 v2(30.6,3.29)
N33761125: length 3.8
  TOP w0.102: v2(28.64,2.91) v2(29.14,3.42) R497.2
  BOTTOM w0.102: CN18.50 27.6,2.89 28.13,3.42 v2(29.14,3.42)
N33761127: length 15.4
  TOP w0.102: TP49.1 v2(18.6,4.84)
  IN1 w0.089: v2(26.22,6.59) 25.46,5.83 23.43,5.83 23.05,6.21 19.98,6.21 v2(18.6,4.84)
  BOTTOM w0.102: CN18.68 23.1,2.83 26.22,5.96 v2(26.22,6.59)
N36953746: length 3.4
  BOTTOM w0.102: Q19.2 52.04,18.87 52.9,18.02 R418.2 52.9,17.38 53,17.28 C393.2
N36954805: length 2
  TOP w0.102: U16.7 67.32,18.2 67.37,18.15 R464.2 67.73,18.89 v2(67.88,19.04)
N36977514: length 4.5
  BOTTOM w0.102: Q44.3 195.93,16.51 Q47.2 196.85,16.61 v2(197.22,16.98) 197.27,17.03 R827.2
N37139396: length 1.2
  TOP w0.102: D16.2 130.38,20.32 130.36,20.31 R423.1
N37139539: length 2.2
  TOP w0.102: U15.18 122.61,21.71 121.95,22.37 R400.2
N37162665: length 4
  TOP w0.381: R690.2 203.64,18.38 v2(203.49,18.53)
  BOTTOM w0.102: v2(204.28,17.89) L13.1
  BOTTOM w0.381: v2(203.49,18.53) 203.91,18.94 L13.1 204.88,18.94 205.03,18.79 R313.1
N37162929: length 0.9
  TOP w0.102: R366.2 TP41.1
N37164012: length 2.4
  BOTTOM w0.102: U30.16 202.13,30.25 201.79,30.59 201.79,31.57 C638.1
N37164724: length 0.6
  BOTTOM w0.102: R699.1 R707.2
N38521997: length 3.9
  BOTTOM w0.102: R430.1 174.94,18.53 175,18.47 CN10.1 176.35,17.45 176.55,17.65 D18.1
N38680042: length 4.5
  BOTTOM w0.102: D34.1 197.88,31.74 v2(198.08,31.94) 198.32,32.17 D35.1 198.32,34.03 198.69,34.4 R699.2
N38680880: length 2.1
  BOTTOM w0.102: Q16.2 176.4,21.64 177.23,22.47 R365.1
N38756738: length 5.7
  TOP w0.102: R402.1 185.53,24.62 185.41,24.75 184.08,24.75 C387.2 182.69,23.36 v2(182.69,23.1) 182.69,22.85 182.4,22.56 U13.82
N38756749: length 1.4
  TOP w0.102: TP43.1 U13.87
N38756787: length 5
  TOP w0.102: R318.1 181.84,29.83 181.72,29.7 181.72,29.47 181.57,29.32 180.66,29.32 180.52,29.46 C367.2 180.52,30.09 179.87,30.75 179.41,30.75 179.22,30.55 U13.98
N38756834: length 95.6
  TOP w0.102: v2(22.03,94.47) v2(22.92,94.47) 25.59,94.47 25.92,94.8 50.56,94.8 51.18,95.43 52.58,95.43 53.53,94.47 57.97,94.47 59.12,93.33 62.55,93.33 63.05,93.84 63.05,94.86 63.94,95.74 Q7.3
  IN1 w0.089: v2(18.02,57.64) 19.49,57.64 22.15,60.3 22.15,70.34 21.02,71.47 21.02,72.25 19.11,74.15 19.11,75.04 18.86,75.3 18.86,82.79 19.73,83.66 19.96,83.66 20.2,83.89 20.2,84.24 19.02,85.42 19.02,91.46 v2(22.03,94.47)
  BOTTOM w0.203: SW3.4 SW3.3 16.95,58.74 17.28,58.41 18.35,58.41 19.01,57.74 R622.1 18.27,57.39 v2(18.02,57.64)
N38757336: length 4.1
  TOP w0.102: R310.1 164.65,31.61 164.79,31.47 C371.1 165.16,31.23 165.67,30.72 166.94,30.72 167.22,30.44 U13.128
N38757362: length 4.8
  TOP w0.102: U13.66 182.14,16.16 182.56,15.73 182.56,15.35 182.81,15.1 R487.1 183.35,14.82 183.58,14.59 C480.2 184.35,14.09 v2(184.47,14.21)
N38757406: length 12.6
  TOP w0.102: v2(66.46,99.22) 66.46,99.02 65.81,98.37 Q7.2 64.89,98.98 65.69,99.77 C112.1
  BOTTOM w0.203: SW2.3 66.7,99.49 66.46,99.25 v2(66.46,99.22) 66.46,99.1 66.7,98.85 SW2.4 66.7,96.72 66.45,96.48 R37.2
N38758998: length 0.9
  BOTTOM w0.102: R419.1 C389.2
N38759178: length 5.3
  TOP w0.102: U13.12 166.38,23.76 166.53,23.61 167.07,23.61 167.37,23.91 167.37,25.73 v2(167.36,25.74)
  BOTTOM w0.102: v2(168.08,25.74) v2(167.36,25.74) 167.36,25.71 167.04,25.38 C388.1
N39785725: length 3.4
  BOTTOM w0.102: v2(212.91,18.4) 212.63,18.12 R834.1 R835.1 212.79,16.62 212.86,16.7 213.35,16.7 213.72,16.32 HD1.1
N40550359:
  vias: v2(111.19,124.19)
N43565507: length 157.2
  TOP w0.102: v2(127.95,121.78) 127.82,121.91 127.32,121.91 127.09,122.13 D8001.1 126.51,123.1 126.04,122.64 R8103.1 ; v2(182.21,32.71) 182.81,32.1 182.81,29.32 182.23,28.74 180.3,28.74 179.41,27.85 179.41,27.19 178.53,26.31 178.53,25.9 177.55,24.92 177.55,24.24 177.23,23.92 v2(177.23,21.35)
  IN2 w0.089: v2(148.02,80) 148.17,80.15 148.17,98.06 148.65,98.54 148.65,105.52 148.08,106.09 148.08,111.81 147.51,112.38 147.51,112.89 147.89,113.27 147.89,117.33 147,118.22 139,118.22 137.6,119.62 131.38,119.62 131,120 131,120.51 129.73,121.78 v2(127.95,121.78)
  IN3 w0.089: v2(148.02,80) 148.78,80 149.16,79.62 149.16,63.11 150.24,62.03 150.24,61.26 151.17,59 151.85,56.78 151.85,55.03 152.39,54.49 152.39,49.95 151.95,49.52 151.95,46.85 151.09,45.98 151.09,44.71 150.68,44.31 150.68,40.99 152.08,39.59 152.08,38.29 152.7,37.67 157.05,35.87 161.68,35.87 162.07,35.48 168.38,35.48 174.27,33.05 174.99,32.33 177.35,32.33 177.61,32.07 180.81,32.07 181.27,32.52 181.27,32.65 181.42,32.8 182.11,32.8 v2(182.21,32.71)
  BOTTOM w0.102: R77852.1 R77851.2 177.48,21.1 v2(177.23,21.35)
N43700942: length 2.3
  BOTTOM w0.102: CN2.24 55.22,106.62 55.38,106.46 55.38,106 R517.2
N43737419: length 3.5
  TOP w0.102: R516.2 v2(59.14,109.21)
  BOTTOM w0.102: CN2.29 57.72,108.45 57.97,108.7 58.63,108.7 v2(59.14,109.21)
N44885066: length 4.5
  TOP w0.102: v2(131.13,33.77) 130.79,33.43 PR81.2
  TOP w0.559: PR81.2 128.66,34.41 127.33,34.41 PD4.3
N45198823: length 3.6
  BOTTOM w0.152: PR123.1 v2(61.78,125.59) 60.42,125.59 60.41,125.58 v2(59.95,125.58)
  vias: v2(59.3,125.58)
N45477665: length 3.3
  TOP w0.203: R14.2 51.24,107.68 v2(51.62,108.06) 52.16,108.6 C37.2 52.63,109.22 52.58,109.27 Q2.2
N47284656:
  vias: v2(42.99,27.42)
N47284687:
  vias: v2(34.35,26.02)
N47284767: length 1.4
  TOP w0.508: PR551.2 PC551.2
N47673465: length 1
  TOP w0.102: R2684.1 43.11,92.7 43.62,93.2 TP9078.1
N47751595: length 1.6
  TOP w0.102: C2733.1 40.93,79.08 40.83,78.98 R2697.1 R2698.1
N47855937: length 2.5
  BOTTOM w0.102: C1104.1 17.47,74.67 v2(18.22,75.42) 18.75,75.96 U26.17
N47859573: length 1.4
  BOTTOM w0.102: R104.1 19.37,74.8 19.45,74.88 U26.16
N48031337: length 2
  TOP w0.203: R6519.1 23.18,17.26 22.77,16.86 U2034.18
N48031368: length 4.4
  TOP w0.102: v2(24.32,12.05) 24.06,12.31 R6523.1
  TOP w0.305: U2034.13 22.67,14.36 22.82,14.21 C2782.1
  TOP w0.381: R6523.1 C2782.1
N48041869: length 10.5
  IN1 w0.305: v2(79.62,112.65) 79.4,112.43 77.58,112.43 77.4,112.25 76.39,112.25 75.5,113.14 75.5,114.77 75.65,114.93 v2(75.65,115.44)
  BOTTOM w0.203: PC9003.1 76,115.93 75.65,115.58 v2(75.65,115.44) 75.56,115.34 75.09,115.34 74.55,114.8 PU9000.28
  BOTTOM w0.305: v2(79.62,112.65) 79.47,112.5 PR9003.2
N48041894: length 30.1
  IN2 w0.102: v2(82.68,96.84) 81.94,96.09 76.45,96.09 74.26,98.29 74.26,105.86 v2(74.21,105.9)
  BOTTOM w0.152: PR9055.2 84.47,92.04 83.91,92.6 82.6,92.6 82.4,92.81 82.4,96.56 v2(82.68,96.84)
  BOTTOM w0.203: PR9055.2 84.48,91.5 PR9052.2 ; PR9050.1 PC9017.1 73.39,104.82 73.52,104.68 74.52,104.68 74.74,104.9 PR9053.2 74.74,105.45 74.28,105.9 v2(74.21,105.9) 74.06,106.05 PC9019.1
N48041922: length 47.1
  IN2 w0.102: v2(88.28,97.95) 87.67,97.34 84.65,97.34 82.55,95.25 76.12,95.25 73.42,97.95 73.42,103.33 68.22,108.53 66.16,108.53 65.87,108.81 65.87,109.68 66.77,110.58 66.77,111.59 64.7,113.65 v2(64.7,114.67)
  BOTTOM w0.178: PR9020.2 68.6,117.05 68.21,116.66 68.2,116.66 68.11,116.56 ; 68.11,116.56 65.7,116.56 64.7,115.57 v2(64.7,114.67) ; 68.11,116.56 68.13,116.56 PR9024.1
  BOTTOM w0.203: v2(88.28,97.95) 89.16,97.95 PR9015.2
N48041929: length 32.4
  IN2 w0.102: v2(87.31,97.96) 86.89,97.55 84.56,97.55 82.47,95.45 76.21,95.45 73.63,98.03 73.63,103.45 68.15,108.93 v2(66.33,108.93)
  BOTTOM w0.152: v2(66.33,108.93) 66.38,108.93 PR9060.1
  BOTTOM w0.203: v2(87.31,97.96) 87.13,97.78 PR9054.1
N48041930: length 32.3
  IN2 w0.102: v2(69.27,111.93) 70.41,110.79 70.41,108.83 v2(70.01,108.44) 70.01,107.67 74.04,103.64 74.04,98.22 76.39,95.87 82.31,95.87 84.6,98.16 v2(86.04,98.16)
  BOTTOM w0.203: v2(69.27,111.93) 69.39,111.8 PR9051.1 ; PR9054.2 86.04,97.54 v2(86.04,98.16) ; v2(70.01,108.44) 69.99,108.42 PR9056.1
N48041941: length 1.9
  BOTTOM w0.203: PR9021.1 PR9025.1 89.13,97.23 89.36,96.99 PR9015.1
N48041971: length 29.7
  BOTTOM w0.102: PR9018.1 88.35,125.1 88.11,124.87 88.11,124.41 87.29,123.59 78.04,123.59 76.52,125.11 73.62,125.11 73.01,124.49 72.19,124.49 70.87,123.18 70.58,123.18 70.39,122.99 70.39,122.62 68.9,121.13 68.9,118.45 68.6,118.16 PR9017.2 69.02,117.6 69.02,115.56 PR9013.1
N48041975: length 2.8
  BOTTOM w0.102: PR9018.2 88.16,125.55 v2(87.95,125.34)
  BOTTOM w0.203: PR9018.2 89.37,125.55 PR9009.1 89.6,124.36 PR9019.1
N48041983: length 37.5
  IN3 w0.203: v2(91.12,117.87) 91.19,117.94 91.19,120.89 90.16,121.93 87.86,121.93 87.05,122.74 77.53,122.74 75.68,120.89 74.81,120.89 72.83,122.87 72.83,124.32 71.94,125.21 v2(71.94,125.34)
  BOTTOM w0.203: PR9061.2 65.97,119.04 66.39,119.46 66.39,119.63 PR9064.1 67.4,120.64 67.89,120.64 68.14,120.89 68.14,121.24 69.78,122.87 69.78,123.24 70.33,123.79 70.61,123.79 71.94,125.12 v2(71.94,125.34) ; v2(91.12,117.87) 91.12,117.82 91.73,117.21 PR9063.2
N48042007: length 27.8
  TOP w0.102: v2(88.07,122.8) 88.07,123.02 89.22,124.17 89.22,124.63 89.92,125.34 v2(90.36,125.34) 90.87,125.34 90.98,125.22 PR9028.2 91.92,125.66 PR77849.2
  BOTTOM w0.102: v2(88.07,122.8) 87.96,122.9 77.75,122.9 76.84,123.81 74.15,123.81 73.72,123.38 73.72,121.91 74.48,121.14 75.21,121.14 75.45,120.91 75.45,119.2 PR9027.1
  BOTTOM w0.203: PR9027.1 PC9008.1
N48042043: length 0.9
  BOTTOM w0.203: PR9008.2 PR9017.1
N48042051: length 0.9
  BOTTOM w0.203: PR9007.2 PR9016.1
N48042052: length 0.9
  BOTTOM w0.203: PR9004.2 PR9005.1
N48042059: length 0.9
  BOTTOM w0.203: PR9023.2 PR9024.2
N48042060: length 0.9
  BOTTOM w0.203: PR9014.2 PR9020.1
N48042070: length 0.8
  BOTTOM w0.203: PR9058.2 67.5,112.26 67.4,112.36 PC9000.1
N48042075: length 1.4
  BOTTOM w0.381: PC9010.2 78.52,111.14 78.18,110.8 78.18,110.28 PR9031.2
N48042078: length 36.7
  IN3 w0.203: v2(91.76,117.87) 91.5,118.12 91.5,121.02 90.28,122.24 87.99,122.24 87.17,123.05 77.4,123.05 75.55,121.19 74.94,121.19 73.18,122.96 73.18,124.41 72.58,125 v2(72.58,125.34)
  BOTTOM w0.203: v2(91.76,117.87) 92.87,117.87 93.29,117.45 PR9063.1 ; PR9057.2 68.47,121.1 70.11,122.74 70.11,123.1 70.47,123.46 70.75,123.46 72.58,125.29 v2(72.58,125.34)
N48042080: length 1.3
  BOTTOM w0.381: PR9010.2 77.46,114.86 77.55,114.76 PC9004.2
N48042081: length 1.4
  BOTTOM w0.381: PC9014.2 76.24,107.34 76.24,107.21 76.55,106.9 PR9040.2
N48042082: length 0.9
  BOTTOM w0.203: PR9012.1 PR9013.2
N48043954: length 1.2
  TOP w0.457: PR9065.2 81.48,110.87 81.39,110.78 PC9031.1
N48043955: length 1.3
  BOTTOM w0.457: PR9068.2 82.28,97.98 82.08,98.18 PC9041.1
N48044973: length 86.6
  IN2 w0.089: v2(98.74,91.11) 95.79,91.11 95.22,91.68 90.87,91.68 v2(90.49,92.06)
  IN3 w0.089: v1(113.31,33.41) 113.31,34.2 114.13,35.02 116.23,35.02 116.72,35.5 116.72,38.98 116.52,39.17 116.52,39.69 117.54,40.7 117.54,48.36 115.89,50 115.59,50 115.36,50.24 115.36,52.79 113.89,54.26 113.89,57.95 114.23,58.75 115.8,60.33 115.8,62.8 115.68,62.92 115.68,67.32 114.02,68.98 114.02,69.4 113.06,70.36 113.06,71.31 112.37,72.01 111.42,72.01 110.32,73.11 108.79,73.11 107.78,74.12 107.78,74.62 106.75,75.65 106.75,76.08 105.31,77.52 105.31,77.97 102.93,80.35 102.93,80.94 102.59,81.29 102,81.29 100.86,82.42 100.86,84.13 99.22,85.76 99.22,90.63 v2(98.74,91.11)
  BOTTOM w0.102: v2(90.49,92.06) 90.23,91.81 R2722.1 ; v1(113.31,33.41) 113.31,33.55 112.96,33.9 111.91,33.9 111.59,33.58 110.99,33.58 110.81,33.77 109.37,33.77 D8510.2
N48073638: length 8.7
  BOTTOM w0.254: PU9006.5 116.6,34.7 116.13,35.17 PC164.1 v2(114.62,35.17) 113.79,34.34 113.79,33.21 113.39,32.8 113.14,32.8 111.44,31.1 PR191.2
N48073642: length 1.5
  BOTTOM w0.102: PU9006.1 116.97,38.27 116.89,38.34 PR194.1
N48073650: length 1.4
  BOTTOM w0.102: PU9006.3 118.87,38.09 118.93,38.15 PR193.2
N48075617: length 1.7
  TOP w0.102: PR6414.2 193.48,22.72 193.52,22.76 PL14.2
  vias: v2(193.61,18.02)
N48075627:
  vias: v2(193.1,30.34)
N48075629: length 1.1
  TOP w0.102: PR9282.2 198.73,30.76 v2(198.94,30.97)
N48075639: length 8.3
  TOP w0.102: PR6414.1 192.42,22.38 191.94,22.38 191.58,22.74 v2(191.58,23.23) 191.58,27.16 191.98,27.56 PC9162.2 PR6418.1
N48075651: length 2.6
  TOP w0.102: PR6417.2 192.78,25.15 PC6229.2 193.48,26.15 193.56,26.07 PU3003.1
N48075664: length 1.6
  TOP w0.102: PU3003.5 PR284.1
N48076363: length 2.7
  BOTTOM w0.102: v2(79.32,88.77) PR9285.2
  BOTTOM w0.508: PQ7.3 78.55,90.16 78.67,90.03 PR9285.2
N48076395: length 2.9
  BOTTOM w0.102: v2(64.83,85.58) PR102.2
  BOTTOM w0.508: PR102.2 63.94,86.73 63.69,86.98 63.18,86.98
N48076401: length 3.1
  BOTTOM w0.508: PR216.2 61.15,92.57 60.51,91.93 v2(60.51,91.68) 60.51,91.17 PQ35.3
N48076451: length 1.5
  TOP w0.508: PR9286.2 127.57,37.96 127.32,37.71 PQ10.3
N48095830: length 2.8
  BOTTOM w0.254: PR9308.1 69.59,119.05 69.47,119.17 69.47,119.56 69.59,119.68 PR9310.2 69.97,120.03 70.09,120.15 70.09,120.34 PR9309.1
N48275487: length 3.2
  TOP w0.102: v2(22.9,20.43) 23.29,20.83 Q2039.2 23.88,20.24 24.04,20.08 C2789.2 R6529.1
N48413383: length 0.9
  TOP w0.102: TP9075.1 R498.1
N48413443: length 3.5
  BOTTOM w0.102: R6024.1 65.86,27.17 66.34,27.66 66.34,28.29 v2(66.88,28.83) D6542.2
N48418356: length 1.2
  BOTTOM w0.102: R6642.1 105.34,32.38 105.42,32.46 D6543.2
N48419029: length 2.9
  TOP w0.102: R6643.2 48.35,105.14 47.76,105.14 47.31,105.6 U1.21
N48419358: length 8.9
  BOTTOM w0.102: U2030.AG29 80.41,54.05 79.94,54.52 79.94,54.62 79.74,54.82 79.49,54.82 79.36,54.7 79.08,54.7 78.62,55.15 75.04,55.15 v2(74.46,54.57) 74.46,54.4 73.95,53.89 R6644.1
N48419681: length 1.5
  BOTTOM w0.381: Q5403.2 209.21,18.29 209.75,17.76 R6646.2
N48512543: length 41.4
  IN3 w0.089: v2(88.96,79.34) 89.23,79.07 89.23,73.79 87.44,72 87.44,69.52 87.12,69.2 86.93,69.2 86.67,68.94 86.67,60.41 87.28,59.8 88.52,59.8 90.1,58.22 90.1,50.53 89.34,49.77 89.34,48.75 90.04,48.06 90.04,44.6 v1(91.04,43.59)
  BOTTOM w0.102: v2(88.96,79.34) 88.86,79.24 R2444.2 ; U2030.AW15 91.23,43.59 v1(91.04,43.59)
N48547452: length 3.1
  BOTTOM w0.102: v2(71.82,81.01) PR9311.2
  BOTTOM w0.508: PR9311.2 PQ9057.3
N48626371: length 1.7
  BOTTOM w0.102: C2569.2 R2431.2 103.95,81.39 103.89,81.45 Q2030.2
N48632807: length 1.7
  BOTTOM w0.102: R67418.2 19.65,37.55 19.71,37.49 U5400.4
N48758638:
  vias: v2(145.11,65.12) v2(145.6,64.62) v2(146.15,65.11) v2(146.24,63.87) v2(146.63,64.62)
N48758645: length 16
  BOTTOM w0.203: PR9125.1 143.63,61.63 142.66,61.63 142.16,62.13 PC9095.2
  BOTTOM w0.254: 141.13,75.08 141.13,72.22 140.86,71.95 140.86,62.93 141.66,62.14 PC9095.2
  vias: v2(147.25,76.69) v3(141.03,76.69) v3(141.74,76.49) v3(143.11,76.36) v3(143.85,76.36) v3(148.4,76.82) v3(148.4,76.06)
N48758839: length 1.4
  BOTTOM w0.533: PC9068.1 141.82,68.56 PR9123.2
N48758857: length 1.3
  BOTTOM w0.508: PR9137.1 149.25,68.91 149.48,69.14 PC9072.2
N48838408: length 3.1
  BOTTOM w0.381: PR160.1 PR159.1 109.28,86.47 109.66,86.09 PU9.7
N48838426: length 3.2
  BOTTOM w0.381: PR161.2 PR77847.1 118.42,87.56 118.22,87.36 PU9.1
