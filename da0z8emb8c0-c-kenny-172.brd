# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ56: length 58
  TOP w0.102: v2(45.41,37.84) 44.96,38.94 44.9,39.1 U2013.C2
  IN3 w0.089: v2(83.88,38.01) 83.32,38.01 82.76,37.45 76.02,37.45 73.77,35.2 61.58,35.2 61.43,35.05 61.43,34.18 61.3,34.05 61.15,34.05 61.05,34.15 61.05,34.89 60.96,34.98 60.79,34.98 60.67,34.85 60.67,33.61 60.54,33.48 60.35,33.48 60.29,33.55 60.29,34.66 60.13,34.82 59.78,34.82 59.65,34.69 59.65,34.35 59.88,34.13 59.88,33.61 59.75,33.48 59.57,33.48 59.47,33.58 59.47,33.91 59.35,34.03 59.16,34.03 59.07,33.95 59.07,33.59 58.96,33.48 58.79,33.48 58.7,33.57 58.7,33.99 58.61,34.07 58.44,34.07 58.35,33.99 58.35,33.57 58.26,33.48 58.08,33.48 57.99,33.57 57.99,33.99 57.9,34.07 57.73,34.07 57.64,33.99 57.64,33.57 57.55,33.48 57.37,33.48 57.28,33.57 57.28,33.99 57.19,34.07 57.01,34.07 56.93,33.99 56.93,33.57 56.84,33.48 51.63,33.48 51.27,33.84 51.02,33.84 50.75,33.57 50.62,33.57 50.5,33.7 50.5,33.83 50.57,33.9 50.57,34.02 50.44,34.15 50.32,34.15 50.25,34.08 50.12,34.08 49.99,34.2 49.99,34.33 50.07,34.4 50.07,34.53 47.45,37.14 46.11,37.14 v2(45.41,37.84)
  BOTTOM w0.089: U2030.BC23 85.02,41.1 85.02,40.3 85.06,40.25
  BOTTOM w0.102: v2(83.88,38.01) 84.39,38.01 85.06,38.68 85.06,40.25
M_B_DQ57: length 58
  TOP w0.102: U2013.A3 46.68,38.4 v2(46.68,37.84)
  IN3 w0.089: v2(46.68,37.84) 47.04,37.49 47.59,37.49 50.64,34.44 55.8,34.44 56.15,34.78 56.15,35.03 56.27,35.16 56.56,35.16 56.65,35.07 56.65,34.49 56.74,34.4 56.92,34.4 57,34.49 57,35.07 57.09,35.16 57.27,35.16 57.36,35.07 57.36,34.49 57.45,34.4 57.63,34.4 57.72,34.49 57.72,35.07 57.8,35.16 57.98,35.16 58.07,35.07 58.07,34.49 58.16,34.4 58.34,34.4 58.43,34.49 58.43,35.07 58.52,35.16 58.69,35.16 58.78,35.07 58.78,34.49 58.87,34.4 59.05,34.4 59.14,34.49 59.14,35.07 59.23,35.16 60.49,35.16 60.88,35.55 73.63,35.55 75.88,37.8 82.62,37.8 83.16,38.34 83.16,38.47 83,38.63 83,38.77 83.1,38.87 83.26,38.87 83.41,38.72 83.54,38.72 84.35,39.53 84.72,39.53 85.16,39.09 85.16,38.23 84.31,37.37 v2(84.31,36.79)
  BOTTOM w0.089: 85.72,40.39 85.81,40.48 85.81,40.86 85.54,41.13 85.54,41.48 U2030.BB22
  BOTTOM w0.102: v2(84.31,36.79) 84.95,36.79 85.72,37.56 85.72,40.39
M_B_DQ58: length 58
  TOP w0.102: U2013.D7 43.73,35.75 v2(44.13,35.35)
  IN3 w0.089: v2(44.13,35.35) 43.71,34.94 43.71,33.59 47.91,29.4 55.63,29.4 55.75,29.28 63.12,29.28 63.21,29.37 63.21,29.74 63.3,29.83 63.48,29.83 63.57,29.74 63.57,29.37 63.66,29.28 68.84,29.28 70.59,31.03 71.25,31.03 72.4,32.18 75.02,32.18 77.09,34.25 85.76,34.25 87.84,36.33 v2(88.28,36.33)
  BOTTOM w0.089: 87.07,40.33 87.02,40.38 87.02,41.1 U2030.BC21
  BOTTOM w0.102: v2(88.28,36.33) 87.46,37.15 87.46,39.43 87.07,39.83 87.07,40.33
M_B_DQ59: length 57.7
  TOP w0.102: U2013.C8 v2(44.93,34.55)
  IN3 w0.089: v2(88.28,38.89) 88.26,38.89 87.06,37.69 87.06,36.63 85.36,34.94 76.81,34.94 74.74,32.87 72.12,32.87 70.97,31.72 70.31,31.72 68.72,30.13 66.6,30.13 65.79,30.94 60.38,30.94 60.28,30.84 60.28,30.07 60.17,29.96 59.58,29.96 59.48,30.07 59.48,30.84 59.37,30.94 59.23,30.94 59.12,30.84 59.12,30.09 59.02,29.98 58.87,29.98 58.77,30.09 58.77,30.84 58.66,30.94 58.51,30.94 58.4,30.83 58.4,30.09 58.27,29.97 58.09,29.97 57.85,30.21 57.64,30.21 57.39,29.96 56.03,29.96 55.86,30.14 55.49,30.14 55.46,30.1 48.17,30.1 45.33,32.95 45.33,34.15 v2(44.93,34.55)
  BOTTOM w0.102: U2030.BD20 87.55,40.67 87.55,39.96 88.28,39.23 v2(88.28,38.89)
M_B_DQ60: length 57.8
  TOP w0.102: v2(44.73,37.32) 44.73,37.95 U2013.D3
  IN3 w0.089: v2(44.73,37.32) 44.73,36.85 45.12,36.46 47.17,36.46 49.23,34.39 49.23,33.99 50.42,32.8 63.51,32.8 63.63,32.92 63.63,34.24 63.76,34.36 63.91,34.36 64,34.28 64,32.94 64.12,32.82 64.27,32.82 64.36,32.91 64.36,34.28 64.47,34.39 64.63,34.39 64.74,34.28 64.74,33.28 64.88,33.13 65.36,33.13 65.49,33.26 65.49,34.12 65.61,34.25 66,34.25 66.35,33.9 67.45,33.9 67.54,33.81 67.54,33.68 67.65,33.56 67.8,33.56 67.89,33.65 67.89,33.81 67.98,33.9 68.13,33.9 68.26,33.77 68.26,33.46 68.46,33.27 68.8,33.27 69.02,33.49 69.02,34.39 69.14,34.52 74.05,34.52 76.2,36.67 83.11,36.67 84.66,38.22 84.66,39.02 v2(84.63,39.05)
  BOTTOM w0.089: U2030.BB23 84.62,41.4 84.62,41.04 84.81,40.85 84.81,40.45 84.8,40.44 84.8,39.81
  BOTTOM w0.102: v2(84.63,39.05) 84.8,39.22 84.8,39.81
M_B_DQ61: length 58.2
  TOP w0.102: U2013.C3 44.53,38.66 45,38.18 45,37.62 v2(45.41,37.21)
  IN3 w0.089: v2(45.41,37.21) 45.82,36.8 47.31,36.8 49.57,34.54 49.57,34.13 50.56,33.14 60.88,33.14 61.01,33.27 61.01,33.59 61.07,33.66 61.28,33.66 61.4,33.53 61.4,33.24 61.5,33.14 61.64,33.14 61.77,33.27 61.77,34.73 61.9,34.86 62.08,34.86 62.17,34.77 62.17,33.23 62.26,33.14 62.43,33.14 62.52,33.23 62.52,34.77 62.61,34.86 62.79,34.86 62.92,34.73 62.92,33.2 62.98,33.14 63.16,33.14 63.29,33.27 63.29,34.69 63.46,34.86 64.97,34.86 65.06,34.77 65.06,34.64 65.15,34.56 65.33,34.56 65.42,34.64 65.42,34.77 65.51,34.86 73.91,34.86 76.12,37.07 v2(82.94,37.07)
  BOTTOM w0.089: 85.28,40.29 85.28,40.42 85.21,40.48 85.21,40.85 85.32,40.96 85.32,41.24 85.01,41.55 U2030.BA23
  BOTTOM w0.102: 85.28,40.29 85.28,38.39 83.96,37.07 v2(82.94,37.07)
M_B_DQ62: length 58.1
  TOP w0.102: U2013.B8 v2(45.73,34.55)
  IN3 w0.089: v2(86.29,36.44) 85.14,35.28 76.67,35.28 74.59,33.21 71.31,33.21 68.58,30.47 67.72,30.47 67.62,30.58 67.62,31.18 67.51,31.29 57.93,31.29 57.6,30.96 57.6,30.66 57.25,30.31 56.17,30.31 55.63,30.85 55.21,30.85 55.12,30.76 55.12,30.55 55.03,30.47 54.86,30.47 54.77,30.55 54.77,30.76 54.68,30.85 54.43,30.85 54.32,30.74 54.32,30.57 54.22,30.47 54.07,30.47 53.97,30.57 53.97,30.76 53.86,30.87 53.71,30.87 53.61,30.76 53.61,30.57 53.51,30.47 53.36,30.47 53.25,30.57 53.25,30.74 53.15,30.85 53,30.85 52.9,30.74 52.9,30.55 52.8,30.45 51.59,30.45 51.49,30.55 51.49,30.76 51.38,30.87 51.24,30.87 51.13,30.76 51.13,30.55 51.03,30.45 50.88,30.45 50.78,30.55 50.78,30.76 50.67,30.87 50.52,30.87 50.42,30.76 50.42,30.55 50.32,30.45 50.17,30.45 50.06,30.55 50.06,30.76 49.96,30.87 49.81,30.87 49.71,30.76 49.71,30.55 49.6,30.45 49.46,30.45 49.35,30.55 49.35,30.74 49.25,30.85 49.1,30.85 49,30.74 49,30.55 48.89,30.45 48.31,30.45 47.36,31.4 47.36,31.81 47.13,32.04 46.72,32.04 46.16,32.59 46.16,33.88 45.73,34.32 v2(45.73,34.55)
  BOTTOM w0.089: 86.81,39.78 86.81,40.86 86.6,41.07 86.6,41.42 U2030.BB21
  BOTTOM w0.102: 86.81,39.78 87.11,39.48 87.11,36.89 86.79,36.57 86.43,36.57 v2(86.29,36.44)
M_B_DQ63: length 58
  TOP w0.102: U2013.C7 v2(44.93,35.35)
  IN3 w0.089: v2(88.28,37.6) 87.48,36.8 87.48,36.5 85.57,34.59 76.95,34.59 74.88,32.52 72.26,32.52 71.11,31.37 70.45,31.37 68.86,29.79 66.46,29.79 65.64,30.6 62.92,30.6 62.83,30.51 62.83,30.4 62.74,30.31 62.56,30.31 62.47,30.4 62.47,30.51 62.38,30.6 62.21,30.6 62.12,30.51 62.12,30.38 62.03,30.29 61.85,30.29 61.76,30.38 61.76,30.51 61.67,30.6 61.3,30.6 60.32,29.62 55.89,29.62 55.75,29.76 48.03,29.76 44.53,33.26 44.53,34.95 v2(44.93,35.35)
  BOTTOM w0.089: U2030.BA21 87.01,41.55 87.34,41.22 87.34,40.99 87.21,40.86 87.21,40.52 87.29,40.44
  BOTTOM w0.102: 87.29,40.44 87.29,39.91 87.82,39.38 87.82,38.06 v2(88.28,37.6)
M_B_DQSN0: length 74.7
  TOP w0.102: U2018.F3 42.09,85.31 v2(41.71,84.93)
  IN3 w0.089: v1(84.52,80.53) 84.19,80.53 84.11,80.45 83.81,80.45 83.06,81.2 83.06,84.85 79.96,87.94 78.03,87.94 77.57,87.48 74.59,87.48 74.13,87.94 71.35,87.94 71.25,87.84 71.25,83.75 71.03,83.53 70.5,83.53 70.29,83.73 70.29,86.17 70.19,86.28 69.76,86.28 69.66,86.17 69.66,84.19 69.45,83.98 68.91,83.98 68.62,84.28 68.62,86.19 68.51,86.3 66.96,86.3 63.3,89.96 56.14,89.96 55.63,89.45 51.23,89.45 50.22,88.44 43.55,88.44 43.09,87.98 43.09,85.98 42.4,85.29 42.07,85.29 v2(41.71,84.93)
  BOTTOM w0.102: v1(84.52,80.53) 84.43,80.62 84.26,80.62 84.14,80.5 84.14,80.33 86.12,78.35 86.12,73.27 86.42,72.97 86.42,72.85 86.18,72.6 86.04,72.6 85.99,72.65 85.95,72.76 85.95,72.84 U2030.B22
M_B_DQSN1: length 57
  TOP w0.102: U2018.A7 45.94,82.11 45.81,82.23 45.81,82.92 45.94,83.04 v2(46.16,83.04)
  IN3 w0.089: v2(46.16,83.04) 45.79,83.04 45.69,82.94 45.69,82.75 45.79,82.64 46.96,82.64 47.61,83.29 49.13,83.29 49.62,83.77 54.03,83.77 54.42,83.39 54.9,83.39 55.29,83.77 56.2,83.77 56.57,83.4 56.83,83.4 57.21,83.77 59.91,83.77 60.18,83.51 60.18,82.01 60.28,81.91 60.74,81.91 60.84,82.01 60.84,83.58 61.04,83.77 61.64,83.77 61.83,83.58 61.83,81.24 61.94,81.14 62.39,81.14 62.5,81.24 62.5,83.57 62.7,83.77 63.28,83.77 63.49,83.57 63.49,79.74 63.59,79.64 73.83,79.64 75.5,77.97 78.75,77.97 80.59,76.13 80.81,76.13 81.85,75.09 81.85,74.82 81.95,74.72 82.21,74.72 82.36,74.87 v1(82.36,74.94)
  BOTTOM w0.102: U2030.B25 82.96,72.96 82.96,73.1 83.01,73.21 83.01,73.93 82.74,74.2 82.74,74.84 82.63,74.94 v1(82.36,74.94)
M_B_DQSN2: length 57.4
  TOP w0.102: U2017.F3 v2(41.73,74.33)
  IN3 w0.089: v2(41.73,74.33) 41.73,74.21 41.83,74.1 42.07,74.1 43.14,75.18 43.14,75.53 43.54,75.93 43.54,76.16 43.43,76.26 42.78,76.26 42.58,76.46 42.58,77.03 42.79,77.24 48.7,77.24 48.9,77.03 48.9,76.43 49.01,76.33 57.71,76.33 58.47,75.58 66.5,75.58 66.71,75.37 66.71,74.01 66.81,73.91 67.22,73.91 67.32,74.01 67.32,75.38 67.51,75.58 68.12,75.58 68.31,75.38 68.31,74 68.4,73.91 68.87,73.91 68.97,74.01 68.97,75.38 69.17,75.58 69.77,75.58 69.96,75.38 69.96,74 70.05,73.91 70.52,73.91 70.62,74.01 70.62,75.38 70.82,75.58 71.42,75.58 71.61,75.38 71.61,74.01 71.72,73.91 73.98,73.91 74.32,73.56 76.99,73.56 77.2,73.36 77.2,73.21 v1(77.4,73.01)
  BOTTOM w0.102: v1(77.4,73.01) 77.22,72.83 77.22,72.57 77.53,72.26 78.41,72.26 78.8,71.87 78.8,71.49 79.09,71.2 79.77,71.2 79.88,71.31 80.15,71.31 80.34,71.13 80.34,70.98 80.23,70.88 80.14,70.88 U2030.F30
M_B_DQSN3: length 57.3
  TOP w0.102: U2017.A7 45.82,71.03 45.82,71.84 45.97,72 v2(46.16,72)
  IN3 w0.089: v1(77.02,67.69) 77.19,67.69 77.3,67.59 77.3,67.44 77.17,67.31 75.53,67.31 75.37,67.16 71.76,67.16 70.73,68.19 70.02,68.19 69.91,68.3 69.91,69.98 69.7,70.19 69.13,70.19 68.92,69.98 68.92,68.3 68.82,68.19 68.38,68.19 68.28,68.3 68.28,69.98 68.07,70.19 59.83,70.19 59.73,70.29 59.73,71.62 59.52,71.83 58.94,71.83 58.74,71.62 58.74,70.29 58.63,70.19 58.21,70.19 58.1,70.29 58.1,71.62 57.89,71.83 57.31,71.83 57.1,71.62 57.1,70.29 57,70.19 56.41,70.19 56.3,70.29 56.3,71.62 56.1,71.83 55.52,71.83 55.31,71.62 55.31,70.29 55.2,70.19 54.78,70.19 54.67,70.29 54.67,71.62 54.46,71.83 53.88,71.83 53.68,71.62 53.68,70.3 53.59,70.21 52.98,70.21 52.87,70.31 52.87,71.16 52.67,71.37 45.78,71.37 45.67,71.47 45.67,71.94 45.78,72.05 46.11,72.05 v2(46.16,72)
  BOTTOM w0.102: v1(77.02,67.69) 77.21,67.5 77.21,67.32 77.43,67.11 78.75,67.11 78.97,67.32 79.37,67.32 79.48,67.2 79.67,67.2 U2030.K29
M_B_DQSN4: length 57
  TOP w0.102: v2(46.8,49.01) 46.54,48.75 46.42,48.75 46.23,48.56 46.23,48.01 45.83,47.61 45.83,47.3 46,47.13 U2014.A7
  IN3 w0.089: v2(76.32,45.56) 76.32,45.76 76.39,45.83 76.65,45.83 76.77,45.96 76.77,46.11 76.67,46.21 75.14,46.21 75.05,46.13 75.05,45.35 74.85,45.15 74.31,45.15 74.11,45.34 74.11,46.15 74.02,46.24 73.68,46.24 73.58,46.14 73.58,45.34 73.39,45.15 72.88,45.15 72.69,45.34 72.69,46.15 72.6,46.24 72.26,46.24 72.16,46.14 72.16,45.34 71.96,45.15 71.46,45.15 71.27,45.34 71.27,46.63 71.7,47.06 71.7,47.31 71.6,47.41 70.84,47.41 70.73,47.31 70.73,45.34 70.54,45.15 70.04,45.15 69.85,45.34 69.85,47.33 69.76,47.41 69.44,47.41 69.31,47.28 69.31,45.35 69.1,45.15 68.6,45.15 68.39,45.35 68.39,47.89 68.85,48.35 68.85,48.65 68.74,48.75 67.85,48.75 67.7,48.6 66.66,48.6 66.51,48.75 51.03,48.75 49.47,50.32 48.05,50.32 47.15,49.41 46.5,49.41 46.4,49.31 46.4,49.18 46.57,49.01 v2(46.8,49.01)
  BOTTOM w0.089: U2030.AR31 78.93,46.51 78.88,46.57
  BOTTOM w0.102: v2(76.32,45.56) 77.37,46.61 78.83,46.61 78.88,46.57
M_B_DQSN5: length 56.9
  TOP w0.102: U2014.F3 42.08,50.33 41.87,50.12 41.87,49.25 v2(42.13,48.99)
  IN3 w0.089: v2(76.2,39.67) 76.2,40.33 75.93,40.6 75.3,40.6 74.95,40.26 74.78,40.26 74.43,40.6 73.99,40.6 73.68,40.29 73.68,38.86 72.96,38.14 71.31,38.14 71.18,38.26 71.18,38.8 71.31,38.92 72.91,38.92 73.14,39.15 73.14,39.58 72.91,39.81 65.46,39.81 64.94,40.34 64.94,41.84 63.18,43.6 50.69,43.6 49.82,44.47 43.71,44.47 42.92,45.26 42.92,47.18 41.92,48.18 41.92,48.78 v2(42.13,48.99)
  BOTTOM w0.102: v2(76.2,39.67) 75.98,39.88 75.98,39.99 76.1,40.11 77.24,40.11 79.05,41.92 79.37,41.92 80.3,42.85 U2030.AW29
M_B_DQSN6: length 61.5
  TOP w0.102: v2(41.71,38.58) 41.75,38.58 U2013.F3
  IN3 w0.089: v2(41.71,38.58) 41.73,38.58 42.86,39.72 42.86,40.42 42.99,40.55 44.37,40.55 44.45,40.47 48.3,40.47 50.43,38.34 62.52,38.34 62.7,38.16 62.7,37.92 v2(62.49,37.71)
  BOTTOM w0.102: v2(62.49,37.71) 62.73,37.94 62.73,38.19 62.94,38.4 64.46,38.4 64.59,38.53 64.59,41.09 64.98,41.48 65.91,41.48 66.17,41.73 66.17,42.74 66.52,43.09 69.89,43.09 70.15,42.83 70.15,42.34 69.92,42.1 67.4,42.1 67.27,41.97 67.27,41.66 67.45,41.48 70.11,41.48 70.34,41.24 70.34,40.27 73.43,37.18 76.17,37.18 76.4,37.22 77.04,37.4 80.29,37.4 82.64,39.76 82.64,40.25 82.82,40.43 82.82,40.85 82.71,40.96 82.71,41.18 U2030.BA25
M_B_DQSN7: length 57
  TOP w0.102: U2013.A7 v2(46.53,35.35)
  IN3 w0.089: v2(86.66,38.33) 86.44,38.12 86.11,38.12 85.86,37.87 85.86,37.02 84.69,35.85 76.43,35.85 74.36,33.78 71.08,33.78 68.74,31.44 68.5,31.44 68.08,31.86 56.87,31.86 56.45,31.44 48.84,31.44 48.72,31.31 48.26,31.31 47.93,31.64 47.93,31.78 48.72,32.57 48.72,32.86 48.23,33.35 47.93,33.35 47.19,32.61 47.02,32.61 46.73,32.9 46.73,33.04 47.99,34.3 47.99,34.59 47.57,35.01 47.28,35.01 46.72,34.45 46.57,34.45 46.29,34.74 46.29,35.24 46.4,35.35 v2(46.53,35.35)
  BOTTOM w0.089: U2030.BA22 86.01,41.57 86.34,41.24 86.34,40.99
  BOTTOM w0.102: v2(86.66,38.33) 86.5,38.17 86.3,38.17 86.2,38.28 86.2,40.85 86.34,40.99
M_B_DQSP0: length 74.7
  TOP w0.102: U2018.G3 41.71,85.69 v2(41.71,85.73)
  IN3 w0.089: v2(41.71,85.73) 41.71,85.57 41.82,85.46 42.32,85.46 42.91,86.05 42.91,88.06 43.48,88.62 50.15,88.62 51.15,89.62 55.55,89.62 56.07,90.14 63.37,90.14 67.03,86.47 68.59,86.47 68.79,86.26 68.79,84.36 68.99,84.16 69.38,84.16 69.48,84.27 69.48,86.25 69.69,86.45 70.26,86.45 70.47,86.25 70.47,83.81 70.57,83.7 70.96,83.7 71.07,83.82 71.07,87.91 71.28,88.12 74.2,88.12 74.66,87.65 77.5,87.65 77.96,88.12 80.04,88.12 83.23,84.92 83.23,81.28 83.88,80.63 84.04,80.63 84.15,80.75 84.15,80.89 v1(84.06,80.99)
  BOTTOM w0.102: v1(84.06,80.99) 84.06,80.69 83.95,80.58 83.95,80.25 85.93,78.27 85.93,73.26 85.71,73.04 85.71,72.84 85.77,72.69 85.85,72.5 U2030.D22
M_B_DQSP1: length 57
  TOP w0.102: U2018.B7 45.53,82.11 45.62,82.2 45.62,82.94 45.52,83.04 v2(45.27,83.04)
  IN3 w0.089: v2(45.27,83.04) 45.4,83.04 45.51,82.94 45.51,82.67 45.72,82.47 47.04,82.47 47.68,83.11 49.21,83.11 49.7,83.6 53.96,83.6 54.35,83.21 54.98,83.21 55.37,83.6 56.12,83.6 56.5,83.22 56.91,83.22 57.28,83.6 59.84,83.6 60,83.43 60,81.94 60.21,81.73 60.81,81.73 61.02,81.94 61.02,83.51 61.11,83.6 61.57,83.6 61.66,83.51 61.66,81.17 61.87,80.96 62.46,80.96 62.67,81.17 62.67,83.49 62.78,83.6 63.2,83.6 63.31,83.49 63.31,79.67 63.52,79.46 73.75,79.46 75.42,77.79 78.67,77.79 80.52,75.95 80.74,75.95 81.67,75.02 81.67,74.75 81.88,74.54 82.17,74.54 v1(82.36,74.36)
  BOTTOM w0.102: v1(82.36,74.36) 82.36,74.31 82.82,73.85 82.82,73.25 82.71,72.99 82.71,72.85 82.85,72.5 U2030.D25
M_B_DQSP2: length 57.3
  TOP w0.102: U2017.G3 v2(41.73,73.53)
  IN3 w0.089: v2(41.73,73.53) 41.73,73.82 41.83,73.93 42.14,73.93 43.32,75.1 43.32,75.46 43.71,75.85 43.71,76.23 43.51,76.44 42.86,76.44 42.76,76.54 42.76,76.96 42.87,77.06 48.62,77.06 48.73,76.96 48.73,76.36 48.94,76.15 57.64,76.15 58.39,75.4 66.42,75.4 66.53,75.29 66.53,73.94 66.74,73.73 67.29,73.73 67.5,73.94 67.5,75.31 67.59,75.4 68.05,75.4 68.13,75.31 68.13,73.92 68.33,73.73 68.94,73.73 69.15,73.94 69.15,75.31 69.24,75.4 69.7,75.4 69.78,75.31 69.78,73.92 69.98,73.73 70.59,73.73 70.8,73.94 70.8,75.31 70.89,75.4 71.35,75.4 71.44,75.31 71.44,73.94 71.64,73.73 73.9,73.73 74.25,73.39 76.92,73.39 77.02,73.28 77.02,73.11 76.92,73.01 v1(76.78,73.01)
  BOTTOM w0.102: v1(76.78,73.01) 76.87,73.01 77.03,72.85 77.03,72.5 77.46,72.07 78.33,72.07 78.61,71.79 78.61,71.41 79.01,71.01 79.58,71.01 79.9,70.69 80.23,70.69 U2030.F29
M_B_DQSP3: length 57.3
  TOP w0.102: v2(45.27,72) 45.46,72 45.63,71.83 45.63,71.03 U2017.B7
  IN3 w0.089: v2(45.27,72) 45.49,71.78 45.49,71.4 45.7,71.19 52.59,71.19 52.7,71.08 52.7,70.24 52.91,70.03 53.66,70.03 53.85,70.22 53.85,71.54 53.96,71.65 54.39,71.65 54.49,71.54 54.49,70.22 54.7,70.01 55.28,70.01 55.48,70.22 55.48,71.54 55.59,71.65 56.02,71.65 56.13,71.54 56.13,70.22 56.33,70.01 57.07,70.01 57.28,70.22 57.28,71.54 57.39,71.65 57.82,71.65 57.92,71.54 57.92,70.22 58.13,70.01 58.71,70.01 58.91,70.22 58.91,71.54 59.02,71.65 59.44,71.65 59.55,71.54 59.55,70.22 59.76,70.01 68,70.01 68.1,69.9 68.1,68.22 68.31,68.01 68.89,68.01 69.1,68.22 69.1,69.9 69.2,70.01 69.63,70.01 69.73,69.9 69.73,68.22 69.94,68.01 70.65,68.01 71.69,66.98 75.44,66.98 75.6,67.14 77.25,67.14 77.47,67.36 77.47,67.51 v1(77.66,67.69)
  BOTTOM w0.102: U2030.K31 79.7,67.42 79.87,67.49 79.94,67.57 79.94,67.64 79.71,67.88 79.52,67.88 79.14,67.51 78.89,67.51 78.67,67.3 77.51,67.3 77.4,67.4 77.4,67.59 77.51,67.69 v1(77.66,67.69)
M_B_DQSP4: length 57.1
  TOP w0.102: v2(46.04,49.01) 46.04,48.08 45.64,47.68 45.64,47.44 U2014.B7
  IN3 w0.089: v2(46.04,49.01) 46.22,49.19 46.22,49.38 46.43,49.59 47.08,49.59 47.98,50.49 49.55,50.49 51.11,48.93 66.58,48.93 66.73,48.78 67.63,48.78 67.78,48.93 68.81,48.93 69.02,48.72 69.02,48.27 68.57,47.82 68.57,45.43 68.67,45.32 69.03,45.32 69.13,45.43 69.13,47.36 69.37,47.59 69.83,47.59 70.02,47.4 70.02,45.41 70.11,45.32 70.47,45.32 70.56,45.41 70.56,47.38 70.76,47.59 71.67,47.59 71.88,47.38 71.88,46.99 71.45,46.55 71.45,45.41 71.53,45.32 71.89,45.32 71.98,45.41 71.98,46.21 72.19,46.42 72.67,46.42 72.87,46.22 72.87,45.41 72.96,45.32 73.31,45.32 73.4,45.41 73.4,46.21 73.61,46.42 74.1,46.42 74.29,46.22 74.29,45.41 74.38,45.32 74.77,45.32 74.88,45.43 74.88,46.2 75.07,46.39 76.74,46.39 76.95,46.18 76.95,45.57 v2(76.95,45.56)
  BOTTOM w0.089: U2030.AR29 79.89,46.29 79.69,46.19 79.47,46.19 79.35,46.32 78.84,46.32 78.8,46.36
  BOTTOM w0.102: 78.8,46.36 78.74,46.41 77.45,46.41 76.95,45.91 v2(76.95,45.56)
M_B_DQSP5: length 56.9
  TOP w0.102: U2014.G3 41.68,49.98 41.68,49.2 v2(41.45,48.97)
  IN3 w0.089: v2(41.45,48.97) 41.62,48.97 41.74,48.84 41.74,48.11 42.75,47.1 42.75,45.19 43.64,44.29 49.74,44.29 50.62,43.42 63.11,43.42 64.76,41.77 64.76,40.26 65.39,39.64 72.83,39.64 72.96,39.51 72.96,39.23 72.84,39.1 71.24,39.1 71,38.87 71,38.19 71.24,37.96 73.04,37.96 73.86,38.78 73.86,40.22 74.06,40.42 74.36,40.42 74.7,40.08 75.03,40.08 75.37,40.42 75.86,40.42 76.02,40.26 76.02,40.08 75.95,40.02 75.63,40.02 75.56,39.95 v2(75.56,39.67)
  BOTTOM w0.102: v2(75.56,39.67) 75.79,39.9 75.79,40.07 76.02,40.3 77.16,40.3 78.98,42.11 79.27,42.11 80.01,42.85 U2030.AW30
M_B_DQSP6: length 61.2
  TOP w0.102: U2013.G3 41.67,39.3 41.67,39.31 41.68,39.32 v2(41.68,39.36)
  IN3 w0.089: v2(63.13,37.71) 63,37.71 62.88,37.83 62.88,38.24 62.59,38.52 50.51,38.52 48.38,40.65 44.52,40.65 44.44,40.73 42.91,40.73 42.68,40.5 42.68,39.79 41.9,39.01 41.76,39.01 41.68,39.09 v2(41.68,39.36)
  BOTTOM w0.102: U2030.BC25 83.01,40.35 82.83,40.17 82.83,39.68 80.36,37.21 77.07,37.21 76.44,37.03 76.19,36.99 73.36,36.99 70.15,40.2 70.15,41.16 70.03,41.29 67.37,41.29 67.08,41.58 67.08,42.05 67.32,42.29 69.84,42.29 69.96,42.42 69.96,42.75 69.81,42.9 66.6,42.9 66.36,42.66 66.36,41.65 65.99,41.29 65.06,41.29 64.78,41.01 64.78,38.45 64.54,38.21 63.02,38.21 62.92,38.11 62.92,37.92 v2(63.13,37.71)
M_B_DQSP7: length 56.9
  TOP w0.102: U2013.B7 v2(45.73,35.35)
  IN3 w0.089: v2(45.73,35.35) 45.99,35.35 46.11,35.23 46.11,34.66 46.5,34.27 46.8,34.27 47.35,34.83 47.5,34.83 47.81,34.52 47.81,34.37 46.56,33.12 46.56,32.82 46.95,32.43 47.27,32.43 48.01,33.18 48.16,33.18 48.54,32.79 48.54,32.64 47.75,31.86 47.75,31.56 48.18,31.13 48.79,31.13 48.92,31.26 56.53,31.26 56.95,31.68 68.01,31.68 68.42,31.26 68.81,31.26 71.15,33.6 74.43,33.6 76.5,35.67 84.77,35.67 86.04,36.95 86.04,37.8 86.18,37.94 86.53,37.94 86.66,37.81 v2(86.66,37.7)
  BOTTOM w0.102: U2030.BC22 86.01,41.11 86.01,38.2 86.22,37.98 86.37,37.98 v2(86.66,37.7)
M_B_ODT0: length 148.4
  TOP w0.102: v2(38.67,89.52) R2321.2
  TOP w0.165: v2(38.56,73.53) 38.56,73.56 U2017.K3 ; v2(38.55,85.7) 38.55,85.68 U2018.K3 ; v2(39.33,49.93) U2014.K3 ; U2013.K3 v2(38.52,38.54)
  IN2 w0.089: v2(38.52,38.54) 38.34,38.54 37.88,39 37.88,43.9 38.67,44.69 38.67,46.09 37.91,46.85 37.91,48.37 38.03,48.5 39.05,48.5 39.69,49.14 39.69,49.82 39.58,49.93 v2(39.33,49.93) 38.54,50.71 38.54,51.93 39.56,52.95 39.56,60.69 39.43,60.82 38.54,60.82 38.42,60.95 38.42,61.2 38.54,61.33 39.43,61.33 39.56,61.45 39.56,61.71 39.43,61.84 37.53,61.84 37.4,61.96 37.4,67.55 38.42,68.57 38.42,72 38.8,72.38 38.8,73.29 v2(38.56,73.53) 38.56,73.76 37.78,74.53 37.78,76.57 37.91,76.69 38.8,76.69 38.92,76.82 38.92,77.08 38.8,77.2 38.42,77.2 38.27,77.35 38.27,78.83 38.67,79.23 38.67,85.58 v2(38.55,85.7)
  IN3 w0.089: v2(38.55,85.7) 38.55,89.4 v2(38.67,89.52)
  IN3 w0.133: v2(66.61,54.72) 66.1,55.23 65.34,55.23 64.97,55.61 57.34,55.61 57.29,55.56 52.74,55.56 52.71,55.52 51.2,55.52 50.99,55.74 41.17,55.74 40.07,55.29 38.97,54.18 38.97,52.9 37.91,51.85 37.91,50.91 37.27,50.28 37.27,48.63 37.95,47.95 37.95,46.42 38.16,46.21 38.16,44.82 37.61,44.27 37.61,43.82 37.73,43.7 37.73,39.33 v2(38.52,38.54)
  BOTTOM w0.102: 77.7,50.15 78.8,50.15 79.16,50.51 U2030.AL31
  BOTTOM w0.165: v2(66.61,54.72) 66.61,54.47 66.23,54.09 64.95,54.09 64.82,53.96 64.82,53.41 64.65,53.25 62.97,53.25 62.8,53.08 62.8,52.75 62.97,52.59 64.65,52.59 64.82,52.42 64.82,52.09 64.65,51.93 62.97,51.93 62.8,51.76 62.8,51.43 62.97,51.27 64.65,51.27 64.82,51.1 64.82,50.77 64.65,50.61 62.97,50.61 62.8,50.44 62.8,50.11 62.97,49.95 64.65,49.95 64.82,49.78 64.82,49.39 64.95,49.26 66.73,49.26 66.89,49.1 66.89,48.77 67.06,48.6 67.39,48.6 67.55,48.77 67.55,49.1 67.72,49.26 68.05,49.26 68.22,49.1 68.22,48.79 68.38,48.63 68.71,48.63 68.88,48.79 68.88,49.1 69.04,49.26 69.43,49.26 69.6,49.1 69.6,48.79 69.76,48.63 70.09,48.63 70.26,48.79 70.26,49.1 70.43,49.26 70.76,49.26 70.92,49.1 70.92,48.79 71.09,48.63 71.42,48.63 71.58,48.79 71.58,49.1 71.75,49.26 72.08,49.26 72.24,49.1 72.24,48.79 72.41,48.63 72.74,48.63 72.9,48.79 72.9,49.1 73.07,49.26 73.4,49.26 73.56,49.1 73.56,48.79 73.73,48.63 74.06,48.63 74.22,48.79 74.22,49.1 74.39,49.26 75.12,49.26 76.01,50.15 77.7,50.15
M_B_PARITY: length 142.5
  TOP w0.102: R6593.1 30.32,89.24 30.41,89.14 31.05,89.14 32.57,87.62 32.57,86.86 v2(33.3,86.13)
  TOP w0.165: v2(32.68,49.77) 33.23,50.33 U2014.T3 ; v2(32.65,73.24) 33.44,73.24 U2017.T3 ; v2(32.8,38.85) 32.93,38.95 U2013.T3 ; v2(33.3,86.13) U2018.T3
  IN1 w0.089: v2(33.3,86.13) 33.08,85.92 33.08,82.28 32.45,81.65 32.45,80.38 32.83,80 32.83,77.58 32.45,77.2 32.45,74.71 33.08,74.08 33.08,73.68 v2(32.65,73.24) 32.45,73.04 32.45,66.41 34.99,63.87 34.99,56.12 34.86,55.99 33.21,55.99 33.08,55.87 33.08,55.61 33.21,55.49 34.35,55.49 34.48,55.36 34.48,55.1 34.35,54.98 33.21,54.98 33.08,54.85 33.08,50.18 v2(32.68,49.77) 32.57,49.77 32.32,49.52 32.32,46.85 33.08,46.09 33.08,43.55 33.97,42.66 33.97,41.39 33.21,40.63 33.21,38.21 33.08,38.09 32.83,38.09 32.7,38.21 32.7,38.75 v2(32.8,38.85)
  IN3 w0.133: v2(77.26,54.72) 77.7,55.15 77.7,55.63 77.38,55.95 76.21,55.95 75.97,56.2 75.97,57 75.27,57.71 75.27,57.93 73.58,59.62 71.05,59.62 70.12,60.55 67.63,61.04 59.5,61.04 58.89,61.66 57.07,62.41 50.44,62.41 49.38,61.36 41.27,61.36 34.35,58.49 31.17,55.31 31.17,54.61 30.85,54.29 30.85,53.53 30.5,53.18 29.71,51.26 29.71,48.56 30.05,48.21 30.05,44.38 31.25,43.18 31.25,42.66 33.23,40.68 33.23,39.28 v2(32.8,38.85)
  BOTTOM w0.102: U2030.AG31 79.54,53.58 79.06,53.58 78.57,54.07
  BOTTOM w0.165: v2(77.26,54.72) 77.71,54.27 78.37,54.27 78.57,54.07
M_B_RAS#: length 151.4
  TOP w0.102: R2337.2 v2(31.3,83.43)
  TOP w0.165: v2(36.89,35.36) 37.72,35.36 U2013.L8 ; U2014.L8 37.73,46.72 v2(36.92,46.72) ; U2018.L8 38.13,81.35 37.74,81.73 37.74,82.21 37.09,82.86 v2(37.09,83.24) ; U2017.L8 37.73,70.32 v2(36.92,70.32)
  IN2 w0.089: v2(36.89,35.36) 36.89,34.87 36.98,34.78 37.31,34.78 37.4,34.87 37.4,35.86 37.4,35.87 37.4,44.44 37.27,44.56 36.51,44.56 36.38,44.69 36.38,46.19 v2(36.92,46.72) 37.4,47.2 37.4,48.78 37.23,48.95 37.23,49.22 37.43,49.42 37.95,49.42 38.16,49.63 38.16,50.03 38.03,50.16 38.03,52.31 39.05,53.33 39.05,58.15 38.92,58.28 38.16,58.28 38.03,58.41 38.03,58.66 38.16,58.79 38.92,58.79 39.05,58.91 39.05,59.17 38.92,59.3 37.02,59.3 36.89,59.42 36.89,68.06 36.38,68.57 36.38,69.79 v2(36.92,70.32) 37.13,70.32 37.42,70.62 37.42,71.72 37.53,71.83 37.53,73.18 37.78,73.43 37.78,73.77 37.28,74.27 37.28,76.96 37.52,77.2 37.52,81.27 36.79,82 36.79,82.94 v2(37.09,83.24)
  IN3 w0.089: v2(37.09,83.24) 36.62,82.76 35.34,82.76 34.95,83.15 34.26,83.15 34.03,82.92 31.81,82.92 v2(31.3,83.43)
  IN3 w0.133: v2(77.99,52.05) 77.99,52.18 78.37,52.56 80.2,52.56 80.33,52.69 80.33,54.09 80.14,54.28 74.95,54.28 72.63,56.6 69.21,56.6 68.49,57.32 67.6,57.32 67.15,57.76 66.39,57.76 65.29,58.87 58.6,58.87 57.77,59.7 51.15,59.7 50.14,58.69 40.51,58.69 36.83,57.16 35.99,56.32 35.99,55.59 32.34,51.95 31.88,50.83 31.88,49.46 32.22,49.11 32.22,45.28 33.42,44.08 33.42,43.56 35.51,41.47 35.51,40.91 36,40.42 36,38.34 36.4,37.94 36.4,36.64 35.72,35.96 35.72,35.17 35.99,34.91 36.45,34.91 v2(36.89,35.36)
  BOTTOM w0.089: v2(77.99,52.05) 77.99,52.03 78.36,51.65 78.76,51.65 78.81,51.71 79.34,51.71 79.64,52.01 U2030.AJ30
M_B_RST#: length 154.9
  TOP w0.102: U2013.P1 34.38,41.9 v2(30.8,41.9) ; U2017.P1 35.07,76.19 33.08,76.19 32.65,75.75 v2(29.45,75.75) ; v1(30.41,54.98) 32.32,54.98 33.88,53.42 34.24,53.42 U2014.P1 ; v2(34.54,88) 34.71,88 35.73,86.98 U2018.P1 ; v1(78.27,63.41) 77.15,64.53 74.21,64.53 66.14,72.6 52.79,72.6 52.39,73.01 51.08,73.01 47.53,69.46 47.53,65.02 45.35,62.83 v2(30.03,62.83)
  IN1 w0.089: v2(30.03,62.83) 29.27,62.07 29.27,58.02 31.02,56.27 31.02,51.4 30.58,50.96 30.58,43.88 30.8,43.67 v2(30.8,41.9) 30.29,41.9 29.91,42.28 29.91,52.56 30.41,53.07 v1(30.41,54.98) 28.51,56.88 28.51,70.73 29.45,71.66 v2(29.45,75.75) 30.8,77.1 30.8,81.39 31.81,82.41 31.81,86.73 32.95,87.87 34.41,87.87 v2(34.54,88)
  BOTTOM w0.102: v1(78.27,63.41) 79.26,63.41 79.61,63.06 U2030.T31
M_B_WE#: length 147.9
  TOP w0.102: v2(37.15,89.52) R2320.2
  TOP w0.165: v2(37.93,72.88) 37.73,73.09 37.73,74.33 U2017.L2 ; U2014.L2 37.73,50.73 v2(37.73,49.9) ; v2(37.93,37.58) 37.74,37.81 37.74,39.37 U2013.L2 ; U2018.L2 v2(37.73,85.71)
  IN1 w0.089: v2(37.93,37.58) 37.93,37.46 37.84,37.37 37.62,37.37 37.53,37.46 37.53,40.12 38.03,40.63 38.03,43.93 38.16,44.06 38.16,46.09 37.56,46.69 37.56,47.83 37.02,48.37 37.02,49.14 37.73,49.84 v2(37.73,49.9) 37.86,49.77 38.42,49.77 38.67,50.02 38.67,51.93 39.43,52.69 39.43,63.4 39.34,63.49 38.16,63.49 38.03,63.61 38.03,63.87 38.16,63.99 39.3,63.99 39.43,64.12 39.43,64.38 39.3,64.5 38.16,64.5 38.03,64.63 38.03,67.59 38.54,68.1 38.54,69.58 37.56,70.57 37.56,71.71 37.4,71.87 37.4,72.58 37.71,72.88 v2(37.93,72.88) 38.16,73.11 38.16,78.09 37.65,78.6 37.65,81.65 37.39,81.91 37.01,81.91 36.89,82.03 36.89,82.41 37.73,83.24 v2(37.73,85.71)
  IN3 w0.089: v2(37.15,89.52) 37.15,86.29 v2(37.73,85.71)
  IN3 w0.133: v2(37.93,37.58) 37.93,37.78 37.01,38.71 37.01,42.8 36.5,43.31 36.5,43.91 35.76,44.65 35.76,46.66 34.81,47.61 34.81,49.49 35.66,50.35 35.66,50.71 35.54,50.82 35.1,50.82 34.98,50.94 34.98,51.11 35.1,51.22 35.54,51.22 35.66,51.34 35.66,51.51 35.54,51.62 35.1,51.62 34.99,51.74 34.99,51.91 35.1,52.02 35.54,52.02 35.66,52.14 35.66,52.7 36.25,53.29 36.42,53.29 36.62,53.1 36.78,53.1 36.9,53.21 36.9,53.38 36.7,53.58 36.7,53.74 36.82,53.86 36.98,53.86 37.18,53.66 37.35,53.66 37.46,53.78 37.46,53.95 37.27,54.14 37.27,54.31 38.19,55.24 38.49,55.24 39.46,56.21 40.95,56.82 50.84,56.82 51.34,57.32 54.98,57.32 55.15,57.49 57.42,57.49 58.21,56.7 65.42,56.7 65.79,56.32 66.55,56.32 67,55.87 67.88,55.87 68.61,55.15 71.05,55.15 71.35,54.85 71.51,54.85 71.81,55.15 71.98,55.15 72.1,55.03 72.1,54.87 71.8,54.57 71.8,54.4 71.91,54.28 72.08,54.28 72.4,54.61 72.57,54.61 72.69,54.49 72.69,54.33 72.36,54 72.36,53.84 72.57,53.63 72.57,53.45 72.47,53.35 72.47,52.67 72.63,52.52 72.83,52.52 73.08,52.77 73.26,52.77 73.52,52.52 73.7,52.52 73.82,52.64 73.82,52.95 73.92,53.04 74.13,53.04 74.24,52.94 74.24,51.32 74.39,51.17 74.57,51.17 74.69,51.29 74.69,52.49 74.8,52.61 74.97,52.61 75.09,52.49 75.09,51.29 75.2,51.17 75.37,51.17 75.49,51.29 75.49,52.13 75.6,52.25 75.77,52.25 75.89,52.13 75.89,51.29 76,51.17 76.22,51.17 76.34,51.29 76.34,51.55 76.47,51.68 76.6,51.68 76.77,51.51 76.77,51.28 76.88,51.17 77.27,51.17 77.43,51.01 v2(77.43,50.78)
  BOTTOM w0.102: U2030.AK30 79.64,51.01 79.34,51.31 79.05,51.31 78.93,51.19 77.84,51.19 77.7,51.05
  BOTTOM w0.165: 77.7,51.05 v2(77.43,50.78)
MAA0_0: length 24.5
  TOP w0.102: 122.52,104.96 120.43,104.96 v2(120.02,105.37)
  TOP w0.127: 122.52,104.96 123.2,104.96 123.76,105.52 128.71,105.52 132.72,109.53 v2(136.59,109.53) 139.83,109.53 v2(140.78,108.58)
  BOTTOM w0.102: U2029.G25 119.6,105.79 v2(120.02,105.37)
  BOTTOM w0.127: VRAM2001.H4 141.18,108.18 v2(140.78,108.58)
MAA0_1: length 26.2
  TOP w0.102: 119.7,105.8 v2(119.31,105.42)
  TOP w0.127: v2(141.58,109.38) 140.41,110.55 v2(139.76,110.55) 132.13,110.55 128.56,106.97 123.46,106.97 122.29,105.8 121.09,105.8 120.99,105.9 119.8,105.9 119.7,105.8
  BOTTOM w0.102: U2029.H25 118.81,105.92 v2(119.31,105.42)
  BOTTOM w0.127: VRAM2001.H5 v2(141.58,109.38)
MAA0_2: length 25.3
  TOP w0.102: 120.71,106.92 v2(120.25,106.46)
  TOP w0.127: 120.71,106.92 122.16,106.92 123.55,108.32 v2(127.57,108.32) 128.28,108.32 131.53,111.56 139.43,111.56 140.16,112.29 v2(140.16,112.45)
  BOTTOM w0.102: v2(120.25,106.46) 120.4,106.61 U2029.E27
  BOTTOM w0.127: VRAM2001.H11 140.79,113.39 140.25,113.39 139.97,113.11 139.97,112.64 v2(140.16,112.45)
MAA0_3: length 24.1
  TOP w0.102: 122.22,106.37 121.88,106.03 121.42,106.03 v2(120.99,106.46)
  TOP w0.127: 122.22,106.37 123.2,107.35 128.22,107.35 131.92,111.05 139.64,111.05 v2(141.01,112.42)
  BOTTOM w0.102: v2(120.99,106.46) 121.2,106.67 U2029.D27
  BOTTOM w0.127: v2(141.01,112.42) 141.01,112.43 141.19,112.61 141.19,112.98 VRAM2001.H10
MAA0_4: length 22.3
  TOP w0.102: 121.96,108 121.26,108 v2(120.86,107.61)
  TOP w0.127: v2(139.14,114.18) 138.04,113.09 131.89,113.09 128.92,110.12 125.49,110.12 124.67,109.31 123.54,109.31 122.23,108 121.96,108
  BOTTOM w0.102: v2(120.86,107.61) 121.2,107.94 U2029.D29
  BOTTOM w0.127: v2(139.14,114.18) 139.18,114.18 VRAM2001.K11
MAA0_5: length 24.5
  TOP w0.102: 120.36,107.15 119.62,106.41 v2(119.31,106.41)
  TOP w0.127: 120.36,107.15 121.88,107.15 123.66,108.93 124.8,108.93 125.63,109.76 126.93,109.76 127.48,109.22 128.68,109.22 131.53,112.07 139.09,112.07 v2(139.47,112.45)
  BOTTOM w0.102: U2029.H27 118.8,106.92 v2(119.31,106.41)
  BOTTOM w0.127: VRAM2001.K10 139.58,112.56 v2(139.47,112.45)
MAA0_6: length 24.4
  TOP w0.102: 123.28,103.67 123.06,103.88 119.63,103.88 v2(119.31,104.2)
  TOP w0.127: v2(139.16,107.78) 139.16,107.72 138.25,106.82 133.07,106.82 132.44,106.18 132.44,105.49 v2(130.62,103.67) 123.28,103.67
  BOTTOM w0.102: U2029.H23 118.8,104.71 v2(119.31,104.2)
  BOTTOM w0.127: v2(139.16,107.78) 139.21,107.83 139.21,108.34 139.58,108.71 VRAM2001.K5
MAA0_7: length 22.8
  TOP w0.102: 123.38,104.69 122.11,104.69 122.03,104.76 121.18,104.76 v2(120.72,104.3)
  TOP w0.127: 123.38,104.69 123.51,104.56 128.33,104.56 132.82,109.05 v2(139.13,109.05) 139.51,109.05 v2(139.98,108.58)
  BOTTOM w0.102: U2029.E23 120.4,104.62 v2(120.72,104.3)
  BOTTOM w0.127: v2(139.98,108.58) 139.58,108.18 VRAM2001.K4
MAA0_8: length 22.8
  TOP w0.102: 121.45,105.47 v2(121.35,105.37)
  TOP w0.127: v2(140.78,109.38) 140.12,110.04 132.57,110.04 128.41,105.88 123.25,105.88 122.85,105.47 121.45,105.47
  BOTTOM w0.102: v2(121.35,105.37) 121.2,105.51 U2029.D25
  BOTTOM w0.127: v2(140.78,109.38) 140.38,108.98 VRAM2001.J5
MAA1_0: length 29.2
  TOP w0.102: v2(120.76,99.89) 120.76,99.68 121,99.44 122.32,99.44 123.96,97.8 124.47,97.8 125.21,97.06 125.21,96.33 126.02,95.52 129.53,95.52
  TOP w0.127: v2(141.58,90.99) 139.98,89.39 138.02,89.39 137.66,89.75 136.6,89.75 136.08,90.27 136.08,90.92 135.32,91.68 134.81,91.68 134.35,92.14 132.73,92.14 131.9,92.97 131.9,94.97 131.35,95.52 129.53,95.52
  BOTTOM w0.102: v2(120.76,99.89) 120.4,100.24 U2029.E15
  BOTTOM w0.127: VRAM2002.K4 v2(141.58,90.99)
MAA1_1: length 30.5
  TOP w0.102: 128.99,95.24 125.84,95.24 124.95,96.13 124.95,96.96 124.37,97.55 123.89,97.55 122.19,99.24 120.8,99.24 120.34,99.71 120.34,100.02 120.11,100.24 119.55,100.24 v2(119.24,99.93)
  TOP w0.127: v2(141.26,89.95) 140.36,89.04 137.87,89.04 137.52,89.39 136.45,89.39 136.08,89.76 134.98,89.76 133.94,90.81 133.94,91.38 133.58,91.73 132.43,91.73 131.54,92.62 131.54,94.31 130.84,95.01 v2(130.24,95.01) 129.22,95.01 128.99,95.24
  BOTTOM w0.102: v2(119.24,99.93) 118.8,100.37 U2029.H15
  BOTTOM w0.127: VRAM2002.K5 141.26,90.51 v2(141.26,89.95)
MAA1_2: length 29.2
  TOP w0.102: v2(120.13,98.79) 120.55,98.38 121.13,98.38 121.34,98.17 122.15,98.17 125.72,94.6 128.26,94.6
  TOP w0.127: 128.26,94.6 128.86,94 v2(129.35,94) 130.64,94 130.83,93.81 130.83,92.32 132.27,90.88 132.27,90.03 132.78,89.52 134.22,89.52 134.69,89.05 135.78,89.05 136.15,88.68 137.22,88.68 137.58,88.33 139.75,88.33 v2(140.82,87.26)
  BOTTOM w0.102: U2029.G13 v2(120.13,98.79)
  BOTTOM w0.127: v2(140.82,87.26) 140.82,86.15 141.17,85.79 VRAM2002.K11
MAA1_3: length 28.4
  TOP w0.102: v2(120.93,98.78) 121.01,98.78 121.42,98.37 122.63,98.37 123.66,97.34 124.17,97.34 124.7,96.81 124.7,95.97 125.77,94.91 128.56,94.91
  TOP w0.127: 128.56,94.91 128.96,94.5 130.71,94.5 131.19,94.03 131.19,92.47 132.28,91.38 133.18,91.38 133.54,91.02 133.54,90.7 134.83,89.41 135.93,89.41 136.3,89.04 137.37,89.04 137.73,88.68 140.18,88.68 141.29,87.57 141.29,87.39 v2(141.45,87.23)
  BOTTOM w0.102: U2029.D13 121.2,99.06 v2(120.93,98.78)
  BOTTOM w0.127: VRAM2002.K10 141.18,86.95 v2(141.45,87.23)
MAA1_4: length 28.4
  TOP w0.102: 124.52,94.78 122.35,96.95 120.68,96.95 120.47,97.15 v2(119.19,97.15)
  TOP w0.127: 124.52,94.78 124.52,94.3 127.32,91.5 129.71,91.5 130.87,90.34 130.87,89.49 132.49,87.87 133.12,87.87 133.67,87.32 133.67,87.18 134.16,86.68 135.62,86.68 136.08,86.22 136.08,85.51 136.76,84.82 138.59,84.82 v2(139.17,85.4)
  BOTTOM w0.102: U2029.H11 118.8,97.54 v2(119.19,97.15)
  BOTTOM w0.127: VRAM2002.H11 139.19,85.4 v2(139.17,85.4)
MAA1_5: length 28.2
  TOP w0.102: v2(119.21,98.74) 119.61,98.74 120.23,98.12 120.99,98.12 121.21,97.91 121.21,97.61 121.46,97.36 122.63,97.36 125.66,94.32 127.94,94.32
  TOP w0.127: v2(139.91,87.05) 138.99,87.97 137.37,87.97 137.09,88.25 136.08,88.25 135.7,88.63 134.55,88.63 134.23,88.95 132.84,88.95 131.91,89.88 131.91,90.74 130.47,92.17 130.47,93.22 130.21,93.49 128.78,93.49 127.94,94.32
  BOTTOM w0.102: v2(119.21,98.74) 118.8,99.15 U2029.H13
  BOTTOM w0.127: v2(139.91,87.05) 139.58,86.72 VRAM2002.H10
MAA1_6: length 28.6
  TOP w0.102: v2(119.28,100.87) 119.71,100.45 120.19,100.45 120.3,100.34 122.24,100.34 124.24,98.33 124.73,98.33 126.06,97
  TOP w0.127: 126.06,97 129.51,97 129.58,97.06 v2(133.67,97.06) 134.14,97.06 134.26,96.94 134.26,96.52 134.17,96.43 133.54,96.43 133.45,96.34 133.45,95.97 134.49,94.93 136.64,94.93 136.89,94.68 136.89,94.05 137.48,93.46 137.48,92.37 138.4,91.44 138.73,91.44 v2(139.18,90.99)
  BOTTOM w0.102: v2(119.28,100.87) 118.8,101.35 U2029.H17
  BOTTOM w0.127: VRAM2002.H5 v2(139.18,90.99)
MAA1_7: length 28.7
  TOP w0.102: 125.9,97.94 124.27,99.58 123.43,99.58 122.47,100.54 120.39,100.54 120.07,100.85 v2(119.96,100.85)
  TOP w0.127: v2(139.98,90.99) 140.27,91.28 140.27,91.78 139.97,92.09 138.26,92.09 137.94,92.41 137.94,94.57 137.11,95.39 134.91,95.39 134.74,95.55 134.74,97.45 134.62,97.57 129.63,97.57 129.26,97.94 125.9,97.94
  BOTTOM w0.102: U2029.G17 119.96,101.16 v2(119.96,100.85)
  BOTTOM w0.127: VRAM2002.H4 v2(139.98,90.99)
MAA1_8: length 26.8
  TOP w0.102: v2(121.39,99.85) 122.32,99.85 124.12,98.06 124.62,98.06 126.12,96.56
  TOP w0.127: v2(139.98,90.19) 139.54,89.75 138.9,89.75 138.62,90.03 138.62,90.66 138.45,90.83 137.84,90.83 136.61,92.06 135.08,92.06 134.68,92.46 134.68,92.82 134.94,93.08 134.94,93.86 133.03,95.77 132.86,95.77 132.54,95.45 132.36,95.45 132.18,95.63 132.18,95.81 132.5,96.13 132.5,96.3 132.24,96.56 v2(130.87,96.56) 126.12,96.56
  BOTTOM w0.102: U2029.D15 121.2,100.04 v2(121.39,99.85)
  BOTTOM w0.127: VRAM2002.J5 v2(139.98,90.19)
MAIND: length 217.6
  TOP w0.102: v2(26.99,37.83) 27.49,37.32 27.49,33.77 27.3,33.58 PQ9014.2 ; v2(25.59,88) 25.97,88.38 25.97,93.59 26.96,94.57 51.27,94.57 51.46,94.39 52.98,94.39 55.19,92.18 63.19,92.18 66.61,88.76 v1(68.79,88.76)
  IN2 w0.089: v1(68.79,88.76) 70.67,88.76 72.58,86.85 79.2,86.85 82.27,83.78 82.27,82.12 85.15,79.24 85.4,79.24 88.07,76.57 88.07,76.05 88.45,75.67 88.53,75.67 89.81,74.39 95.71,74.39 97.22,72.88 105.6,72.88 106,72.48 109.56,72.48 109.82,72.22 v2(113.8,72.22)
  IN3 w0.089: v2(113.8,72.22) 114.01,72.01 114.01,70.76 115.01,69.76 115.01,69.39 117.23,67.17 117.44,67.17 118.11,66.5 118.11,65.77 116.76,64.41 116.76,59.94 115.11,58.29 114.85,57.66 114.85,54.65 116.31,53.19 116.31,51.53 118.68,49.16 118.68,44.37 121.09,41.96 121.09,40.75 v2(123.76,38.09) ; v2(26.99,37.83) 25.46,36.31 25.21,36.31 24.83,36.69 24.83,37.07 24.95,37.2 24.95,40.5 24.06,41.39 24.06,41.9 23.03,42.93 23.03,44.27 25.02,46.26 25.02,54.93 24.76,55.18 24.76,57.44 27.01,59.68 27.01,80.1 25.97,81.14 25.97,87.62 v2(25.59,88)
  BOTTOM w0.102: PQ9056.2 PQ9015.3 68.51,88.48 v1(68.79,88.76) 68.95,88.76 69.2,88.51 69.91,88.51 70.17,88.77 PC104.1 70.17,89.39 69.66,89.9 PR9289.2 ; v2(123.76,38.09) 124.18,37.67 PQ2000.4
MAINON: length 396.6
  TOP w0.102: PR121.2 48.58,18.66 48.7,18.78 51.7,18.78 52.61,19.7 52.61,22.44 v2(53.27,23.1) v2(53.27,24.12) ; v2(143.57,16.7) 143.57,17.55 146.43,20.41 146.43,22.99 145.84,23.59 v2(145.84,24.01) 145.84,24.33 143.21,26.96 v2(143.21,27.26) 143.21,27.78 142.24,28.75 PR92.2 ; R462.1 164.02,16.75 v2(164.27,16.5) 164.33,16.56 U13.30 ; v2(192.21,22.83) 192.77,23.39 PR6417.1
  TOP w0.203: PR89.1 v2(27.82,29.32)
  IN1 w0.089: v2(143.57,16.7) 143.78,16.49 148.7,16.49 149.86,15.33 163.11,15.33 v2(164.27,16.5) ; v2(48.93,95.95) 47.45,94.47 45.59,94.47 41.32,90.2 31.42,90.2 28.64,87.42 28.64,84.31 28.64,79.46 26.44,77.26 26.44,47.7 24.83,46.09 v2(24.83,45.25) ; v2(69.88,124.37) 69.88,124.32 69.87,124.31 69.87,122.5 68.01,120.64 67.5,120.64 64.58,117.72 61.94,117.72 v2(61.76,117.54)
  IN2 w0.089: v2(24.83,45.25) 25.03,45.25 26.54,43.74 26.54,41.61 28.03,40.12 28.03,29.53 v2(27.82,29.32) 27.82,29.23 31.61,25.45 38.83,25.45 39.74,24.54 41.76,24.54 42.42,25.2 46.49,25.2 46.68,25.01 52.39,25.01 v2(53.27,24.12) 53.27,24.03 55.5,21.8 68.03,21.8 68.53,21.3 80.12,21.3 82.05,23.23 85.47,23.23 85.61,23.37 90.89,23.37 91.99,22.27 92.34,22.27 92.55,22.06 94.88,22.06 95.28,22.46 96.34,22.46 98.38,24.5 110.28,24.5 110.87,25.09 116,25.09 116.59,24.5 120.68,24.5 121.39,25.21 130.94,25.21 131.42,24.73 145.11,24.73 v2(145.84,24.01) 147.75,22.09 154.72,22.09 155.36,22.72 161.51,22.72 162.13,23.35 167.54,23.35 167.88,23 170.84,23 171.64,23.8 171.93,23.8 172.76,22.97 175.83,22.97 176.56,23.7 189.27,23.7 190.14,22.83 v2(192.21,22.83) ; v2(61.76,117.54) 61.96,117.54 62.93,116.57 62.93,111.49 65.21,109.21 65.21,106.51 68.59,103.13 68.59,99.35 71.66,96.28 71.66,94.63 v2(75.12,91.17)
  IN3 w0.089: v2(48.93,95.95) 50.43,95.95 50.91,96.42 52.58,96.42 53.79,95.21 58.46,95.21 60.18,96.93 63.03,96.93 66.21,93.76 66.65,93.76 68.78,91.62 74.67,91.62 v2(75.12,91.17)
  BOTTOM w0.102: v2(75.12,91.17) 74.99,91.3 PR9287.1 74.32,89.92 PQ8.2 ; PR259.1 148.46,29.01 147.76,28.31 144.97,28.31 143.92,27.26 v2(143.21,27.26)
  BOTTOM w0.203: v2(69.88,124.37) PR125.2
MAINON_ON_G: length 123.2
  TOP w0.102: v2(123.76,38.72) 123.83,38.65 PQ10.2
  IN2 w0.089: v2(103.14,82.96) 102.56,82.96 101.63,82.03 98.62,82.03 97.52,80.93 96.6,80.93 95.88,80.22 93.44,80.22 91.76,81.9 87.67,81.9 80.69,88.88 80.69,91.92 80.42,92.19 78.93,92.19 v2(77.91,91.17)
  IN3 w0.089: v2(103.14,82.96) 103.4,82.96 106.32,80.04 106.32,78.44 107.72,77.04 108.96,75.8 108.96,74.55 109.46,74.06 110.72,74.06 111.81,72.96 112.76,72.96 113.1,72.62 114.65,72.62 117.48,69.79 117.48,68.51 118.3,67.69 118.3,65.47 119.81,63.96 119.81,53.84 118.87,52.9 118.87,44.45 121.28,42.04 121.28,41.2 v2(123.76,38.72)
  BOTTOM w0.102: PQ35.2 62.61,91.49 62.16,91.05 62.16,87.62 61.18,86.63 PQ9013.2 62.14,85.08 65.09,85.08 66.04,86.03 PQ9015.2 66.51,84.92 67.63,83.81 69.28,83.81 70.87,85.4 PQ9057.2 70.87,86.67 71.18,86.98 PR9288.1 PR9284.2 72,90.23 72.62,89.61 PQ8.3 75.12,89.27 75.18,89.21 PQ7.2 76.46,89.21 77.28,90.03 77.28,90.54 v2(77.91,91.17)
MBCLK: length 86.7
  TOP w0.102: v2(103.17,22.51) 103.19,22.51 103.57,22.89 110.21,22.89 113.32,26 115.54,26 116.45,26.91 131.89,26.91 132.31,26.48 135.14,26.48 136.82,28.16 137.45,28.16 137.82,27.8 v2(138.24,27.8) ; v2(174.94,27.65) 174.94,28.43 174.42,28.96 U13.110 174.42,30.54 174.05,30.91 174.05,31.36 174.22,31.52 R805.1
  IN2 w0.089: v2(138.24,27.8) 138.64,27.4 139.4,27.4 140.73,28.73 143.45,28.73 144.41,27.77 155.53,27.77 156.6,26.7 165.13,26.7 165.94,27.51 167.26,27.51 168.44,26.32 169.25,26.32 169.58,26.65 173.99,26.65 174.94,27.6 v2(174.94,27.65)
  BOTTOM w0.102: v2(138.24,27.8) 139.14,28.7 139.14,30.32 138.22,31.24 PR255.2
MBDATA: length 85.6
  TOP w0.102: v2(138.87,27.8) 138.44,27.37 137.93,27.37 137.36,27.93 136.92,27.93 135.24,26.25 132.16,26.25 131.74,26.68 116.55,26.68 115.63,25.77 113.47,25.77 110.36,22.66 106.39,22.66 v2(106.18,22.45) ; v2(174.32,27.56) 174.32,28.74 174.02,29.03 U13.111 174.02,30.6 173.82,30.8 173.82,31.84 173.7,31.96 173.04,31.96 172.86,32.14 R811.1
  IN2 w0.089: v2(138.87,27.8) 138.87,28.31 139.04,28.47 139.25,28.47 139.38,28.34 139.38,28.09 139.51,27.96 139.69,27.96 140.65,28.92 143.53,28.92 144.49,27.96 155.61,27.96 156.68,26.89 165.02,26.89 165.82,27.7 167.34,27.7 168.52,26.51 169.17,26.51 169.5,26.84 173.6,26.84 v2(174.32,27.56)
  BOTTOM w0.102: PR253.2 138.27,31.95 138.49,31.74 138.49,31.31 139.37,30.43 139.37,28.3 v2(138.87,27.8)
MDI0+: length 22.1
  TOP w0.102: v2(30.08,100.64) 30.08,103.15 30.44,103.5 31.57,103.5 31.9,103.17 31.9,102.84 32,102.74 32.54,102.74 32.64,102.84 32.64,103.43 32.97,103.76 33.83,103.76 34.16,103.43 34.16,102.84 34.26,102.74 34.8,102.74 34.9,102.84 34.9,103.43 35.23,103.76 38,103.76 39.42,105.18 39.42,105.81 40.53,106.92 41.85,106.92 41.97,106.8 U1.1
  BOTTOM w0.102: v2(30.08,100.64) 30.08,101.92 29.9,102.1 U21.9
MDI0+_1: length 34.6
  IN2 w0.089: v2(29.96,109.72) 30.23,109.45 30.23,109.33 29.89,108.99 23.84,108.99 23.13,108.29 23.01,108.29 22.46,108.84 22.03,108.84 21.43,108.23 21.43,107.8 21.98,107.26 21.98,107.13 21.59,106.74 21.46,106.74 20.92,107.29 20.49,107.29 19.88,106.69 19.88,106.26 20.43,105.71 20.43,105.58 20.04,105.2 19.92,105.2 19.31,105.81 18.88,105.81 18.27,105.21 18.27,104.78 18.89,104.16 18.89,104.04 18.5,103.65 18.37,103.65 17.83,104.2 17.39,104.2 16.79,103.6 16.79,103.17 17.34,102.62 17.34,102.49 16.95,102.11 16.83,102.11 16.22,102.72 15.79,102.72 15.18,102.12 15.18,101.69 15.79,101.07 15.79,100.95 14.92,100.07 13.52,100.07 13.22,99.77 CN3.1
  BOTTOM w0.102: v2(29.96,109.72) 30.2,109.96 30.2,110.66 29.9,110.96 U21.16
MDI0-: length 22.1
  TOP w0.102: v2(30.72,100.64) 30.86,100.78 30.86,100.96 30.75,101.08 30.6,101.08 30.48,101.21 30.48,102.98 30.6,103.11 31.41,103.11 31.51,103.01 31.51,102.68 31.84,102.35 32.7,102.35 33.03,102.68 33.03,103.26 33.13,103.36 33.67,103.36 33.77,103.26 33.77,102.68 34.1,102.35 34.96,102.35 35.29,102.68 35.29,103.26 35.39,103.36 38.16,103.36 39.81,105.02 39.81,105.65 40.69,106.53 41.68,106.53 41.81,106.4 U1.2
  BOTTOM w0.102: U21.8 30.9,102.07 30.8,101.97 30.6,101.97 30.48,101.84 30.48,100.88 v2(30.72,100.64)
MDI0-_1: length 34.6
  IN2 w0.089: v2(30.6,109.72) 30.6,109.18 30.04,108.62 23.99,108.62 23.29,107.92 22.86,107.92 22.31,108.47 22.18,108.47 21.8,108.08 21.8,107.96 22.34,107.41 22.34,106.98 21.74,106.37 21.31,106.37 20.76,106.92 20.64,106.92 20.25,106.54 20.25,106.41 20.8,105.86 20.8,105.43 20.2,104.83 19.77,104.83 19.15,105.44 19.03,105.44 18.64,105.05 18.64,104.93 19.25,104.32 19.25,103.89 18.65,103.28 18.22,103.28 17.67,103.83 17.55,103.83 17.16,103.45 17.16,103.32 17.71,102.77 17.71,102.34 17.11,101.74 16.68,101.74 16.06,102.35 15.94,102.35 15.55,101.96 15.55,101.84 16.16,101.23 16.16,100.8 15.07,99.71 13.68,99.71 13.45,99.48 CN3.2
  BOTTOM w0.102: v2(30.6,109.72) 30.6,110.66 30.9,110.96 U21.17
MDI1+: length 21.6
  TOP w0.102: v2(27.08,100.39) 27.08,100.97 27.45,101.34 28.17,101.34 29.32,100.19 31.89,100.19 32.98,101.28 35.65,101.28 37.17,102.8 38.39,102.8 40.6,105.02 40.98,105.02 41.56,105.59 41.91,105.59 41.92,105.6 U1.4
  BOTTOM w0.102: v2(27.08,100.39) 27.08,101.81 26.9,101.99 U21.12
MDI1+_1: length 34.6
  TOP w0.102: CN3.3 13.7,97.73 14.54,96.89 15.11,96.89 15.31,97.09 15.31,99.56 16.9,101.15 16.9,101.29 15.66,102.54 15.66,103.06 16.21,103.61 16.74,103.61 17.34,103.01 17.49,103.01 17.91,103.43 17.91,103.57 17.63,103.85 17.63,104.37 18.16,104.9 18.73,104.9 19.62,104.02 19.77,104.02 20.14,104.39 20.14,104.54 19.39,105.29 19.39,105.8 19.98,106.39 20.45,106.39 21.22,105.62 21.36,105.62 21.74,105.99 21.74,106.14 21.03,106.85 21.03,107.32 21.64,107.92 22.11,107.92 22.82,107.21 22.96,107.21 24.85,109.1 26.94,109.1 27.1,109.27 27.1,109.59 v2(26.98,109.71)
  BOTTOM w0.102: U21.13 26.9,110.96 27.12,110.74 27.12,109.88 26.98,109.74 v2(26.98,109.71)
MDI1-: length 21.6
  TOP w0.102: v2(27.72,100.39) 27.48,100.63 27.48,100.81 27.62,100.95 28,100.95 29.16,99.8 32.05,99.8 33.15,100.89 35.81,100.89 37.34,102.41 38.56,102.41 40.77,104.62 41.15,104.62 41.72,105.2 U1.5
  BOTTOM w0.102: v2(27.72,100.39) 27.88,100.55 27.88,100.75 27.75,100.87 27.6,100.87 27.48,101 27.48,101.74 27.6,101.87 27.77,101.87 27.9,101.99 U21.11
MDI1-_1: length 34.6
  TOP w0.102: CN3.6 v2(14.91,96.13) 15.71,96.93 15.71,99.4 17.29,100.99 17.29,101.46 16.05,102.7 16.05,102.89 16.37,103.22 16.58,103.22 17.18,102.61 17.65,102.61 18.3,103.27 18.3,103.74 18.03,104.01 18.03,104.21 18.33,104.51 18.57,104.51 19.46,103.62 19.93,103.62 20.54,104.23 20.54,104.7 19.78,105.46 19.78,105.64 20.14,106 20.29,106 21.06,105.22 21.53,105.22 22.14,105.83 22.14,106.3 21.43,107.01 21.43,107.15 21.8,107.53 21.95,107.53 22.66,106.82 23.13,106.82 25.02,108.71 27.1,108.71 27.49,109.1 27.49,109.59 v2(27.61,109.71)
  BOTTOM w0.102: U21.14 27.9,110.96 27.51,110.58 27.51,109.84 27.61,109.74 v2(27.61,109.71)
MDI2+: length 22.1
  TOP w0.102: U1.6 42.01,104.8 42,104.79 41.7,104.79 40.17,103.26 40.17,102.07 40.07,101.97 38.77,101.97 38.44,101.64 38.44,101.03 38.77,100.7 40.32,100.7 40.46,100.56 40.46,98.73 40.3,98.57 39.96,98.57 39.81,98.71 39.81,99.72 39.46,100.07 38.63,100.07 38.28,99.72 38.28,98.7 38.13,98.55 37.65,98.55 37.53,98.68 37.53,99.16 37.17,99.51 36.6,99.51 36.5,99.62 36.5,100.05 v2(36.74,100.29)
  BOTTOM w0.102: U21.2 36.9,102.1 36.76,101.97 36.63,101.97 36.5,101.84 36.5,100.96 36.64,100.82 36.84,100.82 36.97,100.7 36.97,100.52 v2(36.74,100.29)
MDI2+_1: length 34.6
  IN1 w0.089: CN3.4 13.45,96.2 13.7,95.95 14.4,95.95 15.19,96.73 15.19,99.07 24.99,108.88 33.93,108.88 35.28,110.22 36.3,110.22 36.64,109.88 v2(36.64,109.36)
  BOTTOM w0.102: U21.23 36.9,110.96 36.57,110.64 36.57,109.42 v2(36.64,109.36)
MDI2-: length 22.1
  TOP w0.102: v2(36.1,100.29) 36.1,99.45 36.44,99.12 37.01,99.12 37.13,98.99 37.13,98.51 37.49,98.16 38.29,98.16 38.67,98.54 38.67,99.55 38.8,99.68 39.29,99.68 39.42,99.55 39.42,98.55 39.8,98.17 40.46,98.17 40.85,98.56 40.85,100.72 40.48,101.09 38.94,101.09 38.84,101.19 38.84,101.47 38.94,101.57 40.23,101.57 40.56,101.91 40.56,103.1 41.86,104.4 U1.7
  BOTTOM w0.102: v2(36.1,100.29) 36.1,101.87 35.9,102.07 U21.3
MDI2-_1: length 34.6
  IN1 w0.089: CN3.5 13.44,95.69 13.55,95.58 14.55,95.58 15.56,96.58 15.56,98.92 25.14,108.51 34.09,108.51 35.43,109.85 36.14,109.85 36.27,109.73 36.27,109.63 v2(36,109.36)
  BOTTOM w0.102: v2(36,109.36) 36,109.38 36.18,109.56 36.18,110.68 35.9,110.96 U21.22
MDI3+: length 22.1
  TOP w0.102: U1.9 43.25,103.29 43.25,102.38 42.44,101.57 42.44,100.58 41.91,100.05 41.91,97.84 41.72,97.65 41.07,97.65 40.74,97.32 40.74,96.86 40.64,96.76 40.11,96.76 40,96.86 40,97.32 39.67,97.65 36.51,97.65 36.32,97.84 36.32,98.47 35.37,99.43 35.37,99.81 34.81,100.37 33.64,100.37 33.26,99.98 33.26,99.65 v2(33.13,99.53)
  BOTTOM w0.102: v2(33.13,99.53) 33.21,99.6 33.21,101.68 32.9,101.99 U21.6
MDI3+_1: length 34.6
  IN3 w0.089: CN3.7 13.79,93.65 15.58,95.44 15.58,100.37 18.75,103.53 18.75,103.66 18.5,103.9 18.5,104.43 19.17,105.1 19.7,105.1 19.94,104.85 20.07,104.85 20.45,105.24 20.45,105.36 20.32,105.5 20.32,106.02 20.99,106.69 21.52,106.69 21.62,106.58 21.8,106.58 24.42,109.21 32.73,109.21 32.96,109.44 v2(32.96,110)
  BOTTOM w0.102: U21.19 32.9,111.09 33.15,110.84 33.15,110.19 v2(32.96,110)
MDI3-: length 22.1
  TOP w0.102: U1.10 43.64,102.21 42.84,101.41 42.84,100.42 42.3,99.88 42.3,97.68 41.88,97.26 41.24,97.26 41.13,97.15 41.13,96.7 40.8,96.37 39.94,96.37 39.61,96.7 39.61,97.15 39.51,97.26 36.35,97.26 35.93,97.68 35.93,98.31 34.97,99.26 34.97,99.64 34.65,99.97 33.8,99.97 33.65,99.82 33.65,99.65 v2(33.77,99.53)
  BOTTOM w0.102: U21.5 33.9,101.97 33.6,101.68 33.6,99.7 v2(33.77,99.53)
MDI3-_1: length 34.6
  IN3 w0.089: v2(33.6,110) 33.44,109.85 33.44,109.24 32.93,108.72 24.62,108.72 22,106.1 21.42,106.1 21.32,106.21 21.19,106.21 20.81,105.82 20.81,105.7 20.94,105.56 20.94,105.04 20.27,104.37 19.74,104.37 19.5,104.61 19.37,104.61 18.98,104.23 18.98,104.1 19.23,103.86 19.23,103.33 16.06,100.17 16.06,95.24 CN3.8
  BOTTOM w0.102: v2(33.6,110) 33.54,110.06 33.54,110.76 33.9,111.12 U21.20
ME_WR#: length 1.5
  TOP w0.102: TP9084.1 174.48,30.93 174.82,30.59 U13.109
MEM_CALRA: length 1.6
  TOP w0.102: R2662.2 118.63,99.83 v2(118.58,99.88)
  BOTTOM w0.102: v2(118.58,99.88) 118.54,99.88 U2029.K15
MF_A0: length 3.6
  BOTTOM w0.102: VRAM2001.J1 140.39,105.77 v2(140.39,103.11) 140.39,102.61 140.44,102.56 R2663.2
MF_A1: length 3.7
  BOTTOM w0.102: R2671.2 v2(140.57,96.51) 140.57,94.77 140.38,94.58 VRAM2002.J1
MIC2-VREFO: length 12.4
  IN3 w0.381: v2(208.85,26.53) 208.6,26.78 208.6,29.45 209.28,30.14 209.28,32.07 v2(208.85,32.5)
  BOTTOM w0.203: 207.68,27.55 207.3,27.55 207.01,27.26 U30.29 ; R257.1 R260.1 209.01,32.65 v2(208.85,32.5)
  BOTTOM w0.254: v2(208.85,26.53) 208.7,26.53 207.68,27.55
