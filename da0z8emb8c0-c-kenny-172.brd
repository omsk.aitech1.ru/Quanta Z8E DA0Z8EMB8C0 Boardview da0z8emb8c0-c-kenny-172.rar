# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN3 (solid shape): 100.96,97.46 100.96,96.76 101.96,95.75 102.67,95.75 103.82,94.6 103.82,93.94 103.76,93.85 103.65,93.87 99.64,97.88 99.61,97.99 99.71,98.05 100.36,98.05
GND on IN3 (solid shape): 108.26,120.19 108.39,120.19 108.48,120.13 108.46,120.02 108.4,119.96 106.51,119.96 106.27,120.2 106.25,120.31 106.34,120.37 106.81,120.37 107.05,120.61 107.84,120.61
GND on IN3 (solid shape): 133.93,22.18 133.98,22.15 133.97,22.09 131.96,20.08 124.2,20.08 124,20.28 123.23,20.28 123.14,20.34 123.16,20.45 123.54,20.84 128.34,20.84 128.95,20.23 131.95,20.23 133.9,22.18
GND on IN3 (solid shape): 40.78,57.43 40.83,57.39 40.8,57.34 38.44,56.36 38.26,56.18 38.26,55.79 38.24,55.77 37.97,55.77 37.93,55.73 37.82,55.7 37.76,55.8 37.76,56.12 37.87,56.23 40.76,57.43
GND on IN3 (solid shape): 74.78,91.3 74.78,91.27 74.77,91.22 74.76,91.17 74.77,91.11 74.78,91.05 74.77,90.96 74.69,90.92 71.36,90.92 70.97,91.3 70.95,91.42 71.04,91.48 74.61,91.48
GND on IN3 (solid shape): 40.74,65.53 40.87,65.49 40.86,65.36 40.53,65.04 40.53,64.97 39.69,64.12 34.49,61.97 34.36,62.02 34.41,62.15 40.68,65.5
GND on IN3 (solid shape): 136.44,85.55 136.43,85.48 136.42,85.43 136.44,85.34 136.47,85.26 136.47,85.16 136.38,85.11 132.24,85.11 131.65,85.69 131.63,85.8 131.72,85.86 136.12,85.86
GND on IN3 (solid shape): 137.81,107.51 137.85,107.53 137.88,107.51 138.38,107.02 139.04,107.02 139.57,106.49 142.38,106.49 143.29,105.58 143.31,105.52 143.26,105.49 143.12,105.49 142.69,105.93 139.87,105.93 138.98,106.83 138.3,106.83 137.78,107.34 137.75,107.42 137.79,107.5
GND on IN3 (solid shape): 157.15,21.93 157.23,21.88 157.23,21.78 157.2,21.69 157.19,21.6 157.19,21.56 157.21,21.48 155.78,20.05 155.58,20.05 155.49,20.12 155.51,20.23 156.65,21.37 156.65,21.73 156.85,21.93
GND on IN3 (solid shape): 54.55,51.84 54.83,51.84 54.92,51.77 54.9,51.66 54.85,51.61 54.85,51.28 54.85,51.28 53.21,51.28 53.2,51.28 53.2,51.61 53.15,51.66 53.13,51.77 53.22,51.84 53.4,51.84 53.6,52.04 53.81,51.84 54.13,51.84 54.34,52.04
GND on IN3 (solid shape): 66.6,48.46 67.76,48.46 67.92,48.61 68.68,48.61 68.7,48.59 68.7,48.41 68.24,47.95 68.24,47.69 68.18,47.6 68.07,47.62 67.95,47.74 65.63,47.74 65.59,47.77 65.59,48.32 65.48,48.43 65.45,48.54 65.55,48.61 66.45,48.61
GND on IN3 (solid shape): 107.68,89.93 108.18,89.93 108.27,89.88 108.27,89.78 108.25,89.71 108.24,89.62 108.26,89.51 108.31,89.4 108.31,89.3 108.22,89.24 107.32,89.24 104.94,91.63 104.94,91.99 105.62,91.99
GND on IN3 (solid shape): 47.66,34.46 47.66,34.43 46.48,33.25 46.37,33.23 46.31,33.32 46.31,33.94 46,34.25 45.99,34.29 46,34.32 46.03,34.36 46.1,34.41 46.19,34.38 46.44,34.13 46.86,34.13 47.41,34.68 47.44,34.68
GND on IN3 (solid shape): 92.43,117.83 92.49,117.92 92.6,117.9 93.54,116.96 93.56,116.85 93.47,116.79 89.97,116.79 89.62,117.14 89.62,117.26 89.72,117.34 89.79,117.44 90.43,117.44 90.55,117.31 92.07,117.31 92.43,117.67
GND on IN3 (solid shape): 98.62,104.48 98.73,104.5 98.79,104.41 98.79,103.04 100.57,101.26 100.57,100.26 100.68,100.15 100.7,100.04 100.61,99.97 100.26,99.97 99.41,100.82 99.41,101.46 98.14,102.73 98.14,103.92 98.18,103.98 98.2,104.05 98.2,104.06
GND on IN3 (solid shape): 97.41,114.75 97.48,114.84 97.59,114.82 98.53,113.88 98.53,112.61 98.47,112.52 98.36,112.54 98.1,112.8 98.1,112.81 98,112.99 97.83,113.08 97.81,113.09 97.41,113.49
GND on IN3 (solid shape): 136.07,99.26 136.14,99.35 136.25,99.33 136.39,99.19 136.39,93.86 136.2,93.67 136.16,93.7 136.06,93.75 135.95,93.76 135.91,93.76 135.84,93.75 135.38,94.21 135.41,94.25 135.45,94.32 135.48,94.4 135.49,94.42 135.55,94.49 135.55,94.5 135.7,94.65 135.72,94.65 136.07,95
GND on IN3 (solid shape): 50.65,62.24 50.74,62.18 50.72,62.07 49.32,60.67 48.75,60.67 48.67,60.71 48.66,60.8 48.67,60.86 48.68,60.92 48.67,60.99 48.65,61.05 48.67,61.14 48.75,61.19 49.45,61.19 50.51,62.24
GND on IN3 (solid shape): 97.47,112.31 97.52,112.4 97.61,112.41 97.69,112.39 97.99,112.08 97.99,110.3 98.19,110.1 98.19,104.88 97.79,104.48 97.73,104.46 97.64,104.47 97.6,104.56 97.6,106.26 98.08,106.75 98.08,109.17 97.6,109.66 97.6,111.69 97.47,111.82
GND on IN3 (solid shape): 42.27,71.77 42.38,71.79 42.44,71.69 42.44,71.43 42.88,70.99 42.88,70.05 42.82,69.96 42.71,69.98 42.63,70.06 42.31,70.06 42.27,70.1 42.27,71.33 42.08,71.53 42.05,71.64 42.15,71.7 42.2,71.7
GND on IN3 (solid shape): 101.06,30.67 101.12,30.74 101.21,30.75 101.28,30.72 101.32,30.68 100.12,29.47 100.12,27.96 94.66,22.51 94.55,22.49 94.49,22.58 94.49,22.59 94.47,22.7 94.42,22.8 94.39,22.83 99.62,28.07 99.62,28.44 99.78,28.59 99.78,29.38
GND on IN3 (solid shape): 40.3,47.99 40.36,47.99 40.44,47.96 40.47,47.89 40.47,47.17 40.66,46.98 40.99,46.98 41.15,46.83 41.15,46.62 40.6,46.07 40.51,46.04 40.44,46.09 40.35,46.21 40.22,46.27 40.21,46.27 40.16,46.32 40.21,46.37 40.21,47.91 40.17,47.95 40.23,48.01
GND on IN3 (solid shape): 54.99,58.47 55.07,58.43 55.08,58.33 55.07,58.28 55.06,58.22 55.07,58.17 55.08,58.13 55.06,58.04 54.98,57.99 54.78,57.99 54.73,57.94 51.41,57.94 51.32,58 51.34,58.11 51.67,58.44 54.49,58.44 54.51,58.47
GND on IN3 (solid shape): 64.57,66.78 64.57,66.56 64.74,66.39 65.04,66.39 65.22,66.56 65.22,66.78 65.22,66.79 67.44,66.79 67.45,66.78 67.45,66.69 67.62,66.51 67.92,66.51 68.1,66.69 68.1,66.78 68.1,66.79 70.14,66.79 70.48,66.45 70.5,66.34 70.41,66.28 63.83,66.28 63.74,66.34 63.76,66.45 64.09,66.79 64.56,66.79
GND on IN3 (solid shape): 66.55,88.24 66.55,87.66 66.74,87.47 67.01,87.47 67.09,87.55 67.2,87.57 67.26,87.48 67.26,86.91 67.38,86.79 67.4,86.68 67.31,86.62 67.1,86.62 63.43,90.28 62.25,90.28 62.15,90.35 62.17,90.46 62.51,90.8 63.99,90.8
GND on IN3 (solid shape): 131.34,37.54 131.36,37.43 131.27,37.37 130.68,37.37 129.56,36.25 129.35,36.25 129.35,36.33 129.38,36.34 129.55,36.49 129.61,36.71 129.61,36.79 129.58,36.87 129.59,36.97 129.67,37.01 129.83,37.01 130.69,37.87 131.01,37.87
GND on IN3 (solid shape): 42.35,77.15 42.41,77.16 42.44,77.12 42.44,76.4 42.72,76.12 43.37,76.12 43.39,76.1 43.39,75.99 43,75.59 43,75.24 42.92,75.16 42.88,75.21 42.87,75.22 42.74,75.41 42.53,75.48 42.47,75.48 42.41,75.46 42.32,75.48 42.27,75.56 42.27,77.07
GND on IN3 (solid shape): 95.77,42.65 95.81,42.73 95.9,42.75 95.96,42.73 96.01,42.73 96.05,42.73 96.12,42.75 96.25,42.61 96.25,41.61 96.77,41.09 96.77,38.81 96.31,38.35 96.24,38.36 96.2,38.37 96.14,38.36 96.08,38.34 95.99,38.36 95.95,38.44 95.95,38.85 96.21,39.12 96.21,40.99 95.77,41.43
GND on IN3 (solid shape): 117.21,76.16 117.21,74.22 117.14,74.13 117.03,74.15 115.14,76.04 115.12,76.15 115.21,76.22 115.44,76.33 115.54,76.57 115.54,76.62 115.52,76.69 115.61,76.78 115.61,77.21 115.63,77.24 116.12,77.24
GND on IN3 (solid shape): 138.44,115.26 141.15,115.26 141.23,115.22 141.25,115.12 141.23,115.07 141.23,115.01 141.23,114.95 141.25,114.89 141.23,114.8 141.15,114.75 140.16,114.75 139.83,115.08 138.32,115.08 137.84,115.55 135.47,115.55 135.41,115.6 135.39,115.72 135.49,115.78 137.92,115.78
GND on IN3 (solid shape): 90.25,52.84 90.31,52.94 90.42,52.91 90.82,52.52 90.82,50.56 90.09,49.83 90.09,49.35 90.03,49.26 89.92,49.27 89.83,49.32 89.72,49.34 89.67,49.33 89.62,49.32 89.53,49.34 89.49,49.42 89.49,49.71 90.25,50.47
GND on IN3 (solid shape): 112.84,65.95 112.84,62.52 112.97,62.38 112.97,61.99 112.62,61.64 112.53,61.64 112.46,61.67 112.43,61.73 112.36,61.92 112.2,62.04 112.14,62.12 112.16,62.21 112.69,62.73 112.69,65.95 111.62,67.02 111.11,67.02 111.07,67.06 111.05,67.12 111.1,67.15 111.63,67.15
GND on IN3 (solid shape): 99.34,31.46 99.4,31.55 99.5,31.55 99.58,31.51 99.67,31.5 99.71,31.5 99.76,31.51 99.85,31.5 99.89,31.42 99.89,31.15 98.59,29.85 98.59,29.13 98.39,28.93 98.33,28.96 98.3,28.97 98.23,29.05 98.26,29.14 98.33,29.21 98.33,30.32 99.34,31.34
GND on IN3 (solid shape): 50.75,52.72 50.75,52.05 50.96,51.84 51.26,51.84 51.47,52.04 51.67,51.84 51.74,51.84 51.83,51.79 51.84,51.7 51.82,51.63 51.81,51.57 51.82,51.49 51.85,51.42 51.84,51.32 51.75,51.28 51.19,51.28 50.65,51.82 50.65,52.47 50.53,52.58 50.51,52.69 50.61,52.76 50.71,52.76
GND on IN3 (solid shape): 63.1,40.65 63.1,40.55 63.06,40.47 62.97,40.45 62.91,40.47 62.85,40.47 62.8,40.47 62.75,40.46 62.72,40.45 62.34,40.84 57.58,40.84 57.41,40.66 56.74,40.66 56.65,40.71 56.65,40.8 56.67,40.88 56.68,40.95 56.67,41.03 56.65,41.1 56.66,41.2 56.74,41.24 62.51,41.24
GND on IN3 (solid shape): 176.94,27.55 177.04,27.52 177.6,26.97 178.86,26.97 179.07,27.17 184.7,27.17 184.78,27.12 184.79,27.02 184.76,26.94 184.74,26.86 184.76,26.74 184.82,26.64 184.83,26.54 184.74,26.48 183.34,26.48 183.05,26.77 177.47,26.77 176.85,27.39 176.87,27.47
GND on IN3 (solid shape): 144.43,116.7 144.42,116.63 144.41,116.59 144.43,116.48 144.48,116.38 144.49,116.28 144.4,116.22 144.1,116.22 143.54,116.78 143.03,116.78 142.94,116.83 142.94,116.93 142.96,117 142.97,117.09 142.96,117.18 142.92,117.27 142.92,117.38 143,117.43 143.71,117.43
GND on IN3 (solid shape): 71.07,88.36 71.17,88.3 71.15,88.19 70.92,87.97 70.92,83.88 70.9,83.85 70.64,83.85 70.62,83.87 70.62,86.31 70.32,86.6 69.63,86.6 69.33,86.31 69.33,84.33 69.32,84.31 69.05,84.31 68.94,84.42 68.94,86.33 68.72,86.55 68.7,86.66 68.79,86.72 69.74,86.72 69.93,86.91 69.93,87.11 69.99,87.2 70.1,87.18 70.18,87.1 70.45,87.1 70.64,87.29 70.64,88.35 70.66,88.36
GND on IN3 (solid shape): 105.85,98.14 105.85,98.08 105.81,98 105.72,97.98 105.66,98 105.6,98.01 105.46,97.98 105.35,97.9 104.95,98.3 103.33,98.3 103.29,98.34 103.26,98.43 103.32,98.5 103.44,98.62 103.49,98.79 103.48,98.87 103.45,98.95 103.46,99.05 103.54,99.1 104.89,99.1
GND on IN3 (solid shape): 41.33,110.48 41.39,110.39 41.39,107.86 41.72,107.53 41.72,107.17 41.01,106.46 41.01,105.96 40.96,105.88 40.87,105.86 40.81,105.88 40.75,105.88 40.67,105.87 40.6,105.85 40.5,105.85 40.45,105.94 40.45,107.12 41.16,107.83 41.16,110.17 41.09,110.24 41.07,110.33 41.12,110.4 41.17,110.43 41.22,110.46
GND on IN3 (solid shape): 50.58,41.24 51.93,41.24 52.01,41.2 52.02,41.1 52,41.03 51.99,40.95 52,40.88 52.02,40.8 52.02,40.71 51.93,40.66 50.59,40.66 49.03,42.22 45.71,42.22 45.63,42.26 45.61,42.35 45.63,42.41 45.63,42.47 45.63,42.53 45.61,42.59 45.63,42.68 45.71,42.73 49.09,42.73
GND on IN3 (solid shape): 59.99,77.2 59.99,76.75 59.81,76.58 59.81,76.09 60,75.9 60.02,75.79 59.93,75.72 58.53,75.72 57.76,76.49 57.75,76.54 57.8,76.58 57.88,76.65 57.99,76.68 58.05,76.58 58.05,76.36 58.24,76.17 58.51,76.17 58.67,76.33 58.73,76.34 58.76,76.3 58.76,76.23 58.95,76.04 59.22,76.04 59.41,76.23 59.41,77.19 59.43,77.21 59.97,77.21
GND on IN3 (solid shape): 63.29,109.31 65.96,109.31 66.05,109.26 66.04,109.15 65.99,109.05 65.97,108.93 65.97,108.87 65.99,108.81 65.98,108.72 65.89,108.68 63.68,108.68 61.79,110.57 59.61,110.57 59.43,110.38 58.83,110.38 58.71,110.5 58.72,110.53 58.73,110.58 58.74,110.63 58.72,110.73 58.67,110.83 58.67,110.94 58.76,110.99 61.62,110.99
GND on IN3 (solid shape): 110.34,29.74 110.4,29.71 110.51,29.65 110.63,29.63 110.67,29.63 110.74,29.64 111.31,29.07 111.31,25.15 113.21,23.25 122.26,23.25 122.26,23.2 122.29,23.09 122.35,22.99 122.37,22.88 122.28,22.82 119.91,22.82 119.35,22.26 113.59,22.26 110.88,24.97 110.88,28.73 110.13,29.48 110.1,29.58 110.17,29.65 110.22,29.68 110.27,29.71
GND on IN3 (solid shape): 54.09,46.59 54.26,46.42 54.9,46.42 54.97,46.48 55.08,46.5 55.14,46.42 55.17,46.29 55.25,46.19 55.28,46.08 55.18,46.01 53.36,46.01 53.28,46.09 53.32,46.13 53.33,46.13 53.48,46.26 53.53,46.45 53.52,46.52 53.5,46.58 53.51,46.68 53.6,46.72 54.09,46.72
GND on IN3 (solid shape): 112.6,79.88 112.6,75.97 113.52,75.06 113.5,74.96 113.45,74.91 112.77,75.58 112.77,75.58 111.95,76.4 111.95,79 111.57,79.38 111.54,79.47 111.59,79.55 111.64,79.58 111.69,79.61 111.76,79.64 111.83,79.61 111.94,79.54 112.08,79.51 112.33,79.62 112.43,79.87 112.42,79.95 112.48,80.01
GND on IN3 (solid shape): 134,21.23 134.11,21.25 134.17,21.16 134.25,20.96 134.41,20.83 134.47,20.75 134.44,20.66 132.86,19.08 121.42,19.08 121.34,19.12 121.33,19.21 121.34,19.27 121.35,19.34 121.34,19.4 121.33,19.46 121.34,19.55 121.42,19.59 123.75,19.59 123.9,19.44 132.22,19.44
GND on IN3 (solid shape): 157.95,21.53 158.04,21.5 158.09,21.45 159.75,21.45 159.78,21.4 159.81,21.36 159.83,21.26 159.73,21.2 158.98,21.2 157.12,19.34 155.38,19.34 154.03,18 153.23,18 153.13,18.06 153.16,18.17 153.68,18.69 154.44,18.69 155.5,19.75 155.9,19.75 157.42,21.26 157.5,21.25 157.54,21.25 157.74,21.31 157.87,21.47
GND on IN3 (solid shape): 50.79,54.63 52.97,54.63 53.05,54.6 53.07,54.51 53.07,54.47 53.08,54.41 53.09,54.35 53.08,54.26 53,54.21 48.53,54.21 48.32,54.42 46.65,54.42 46.44,54.21 45.06,54.21 44.97,54.26 44.97,54.35 44.99,54.42 45,54.49 44.98,54.6 44.94,54.69 44.93,54.79 45.02,54.85 50.57,54.85
GND on IN3 (solid shape): 103.04,97.38 103.77,97.38 103.87,97.33 103.97,97.32 104.08,97.33 104.18,97.38 104.53,97.38 104.63,97.33 104.74,97.32 104.87,97.34 104.98,97.42 105.02,97.43 105.06,97.42 105.37,97.1 105.37,94.96 105.31,94.86 105.2,94.89 103.17,96.92 102.46,96.92 102.13,97.25 102.13,97.94 101.82,98.25 101.8,98.36 101.89,98.42 102,98.42
GND on IN3 (solid shape): 50.85,46.72 52.07,46.72 52.15,46.68 52.16,46.59 52.15,46.52 52.14,46.46 52.15,46.4 52.17,46.34 52.15,46.24 52.07,46.2 51.68,46.2 51.49,46.01 50.98,46.01 49.57,47.43 49.1,47.43 49.01,47.47 49,47.57 49.03,47.64 49.03,47.71 49.01,47.83 48.96,47.93 48.94,48.04 49.04,48.1 49.47,48.1
GND on IN3 (solid shape): 66.29,33.75 66.4,33.75 66.49,33.69 66.47,33.58 66.4,33.51 66.4,32.42 66.4,32.41 66.28,32.41 66.25,32.44 66.25,32.81 66.06,33 65.76,33 65.55,32.79 65.55,32.43 65.52,32.4 56.6,32.4 56.57,32.47 56.56,32.5 56.56,32.6 56.65,32.65 63.57,32.65 63.82,32.91 64.06,32.68 64.33,32.68 64.5,32.85 64.5,33.06 64.57,33.15 64.68,33.13 64.82,32.99 65.42,32.99 65.63,33.2 65.63,34.06 65.67,34.1 65.94,34.1
GND on IN3 (solid shape): 49.1,68.17 49.37,68.17 49.45,68.24 49.56,68.27 49.62,68.17 49.62,68.08 49.61,68.06 49.35,68.06 49.16,67.87 49.16,67.65 49.13,67.6 49.08,67.62 49.07,67.62 48.36,67.62 48.27,67.67 48.27,67.76 48.29,67.84 48.3,67.91 48.26,68.07 48.15,68.2 48.11,68.27 48.17,68.38 48.39,68.17 48.66,68.17 48.88,68.39
GND on IN3 (solid shape): 132.97,106.39 133.11,106.39 133.19,106.35 133.2,106.26 133.19,106.2 133.18,106.14 133.22,105.99 133.31,105.86 133.35,105.75 133.25,105.68 132.84,105.68 129.1,109.42 128.76,109.42 128.67,109.46 128.66,109.56 128.68,109.61 128.68,109.67 128.67,109.75 128.65,109.82 128.66,109.91 128.74,109.96 129.41,109.96
GND on IN3 (solid shape): 180.53,24.71 180.64,24.69 181.23,24.1 184.28,24.1 184.79,23.59 185.14,23.59 185.5,23.23 185.5,23.2 185.49,23.15 185.48,23.1 185.49,23.04 185.5,22.98 185.49,22.89 185.41,22.85 184.16,22.85 183.02,23.99 179.93,23.99 179.84,24.05 179.86,24.16 179.98,24.29 180.01,24.28 180.06,24.27 180.11,24.27 180.36,24.37 180.47,24.62
GND on IN3 (solid shape): 101.44,65.88 101.44,49.12 101.77,48.79 101.77,47.42 102.53,46.66 102.53,45.74 102.48,45.65 102.39,45.65 102.32,45.67 102.24,45.68 102.19,45.68 102.14,45.66 102.05,45.68 102.01,45.76 102.01,46.61 101.53,47.1 101.53,48.69 101.17,49.04 101.17,65.61 100.49,66.3 98.52,66.3 98.43,66.34 98.42,66.43 98.43,66.48 98.44,66.53 98.43,66.59 98.42,66.64 98.43,66.74 98.51,66.78 100.54,66.78
GND on IN3 (solid shape): 105.44,119.19 106.27,119.19 106.29,119.21 106.72,119.21 106.81,119.17 106.82,119.08 106.8,118.98 104.19,118.98 104.08,118.94 104,118.85 103.98,118.82 103.94,118.82 103.9,118.83 103.85,118.83 103.8,118.83 103.75,118.82 103.71,118.82 103.69,118.85 103.61,118.94 103.5,118.98 103.45,118.98 103.35,119.04 103.38,119.15 103.72,119.49 105.14,119.49
GND on IN3 (solid shape): 49.48,80.49 49.53,80.5 49.57,80.46 49.57,80.41 49.76,80.22 51.1,80.22 51.17,80.16 51.97,80.16 52.06,80.11 52.06,80.02 52.04,79.94 52.03,79.86 52.04,79.8 52.05,79.74 52.04,79.65 51.95,79.61 51.14,79.61 50.94,79.82 49.39,79.82 49.31,79.86 49.29,79.95 49.31,80.01 49.31,80.07 49.3,80.16 49.27,80.25 49.27,80.3 49.31,80.33
GND on IN3 (solid shape): 85.43,68.62 85.5,68.52 85.5,67.04 85.62,66.91 85.62,66.81 85.59,66.77 85.54,66.78 85.44,66.83 85.33,66.85 85.26,66.84 85.19,66.81 85.09,66.82 85.04,66.91 85.04,67.68 84.66,68.06 84.66,68.5 84.73,68.59 84.84,68.57 84.94,68.5 85.07,68.47 85.21,68.5 85.32,68.59
GND on IN3 (solid shape): 92.6,22.88 92.68,22.83 92.69,22.73 92.67,22.66 92.66,22.59 92.67,22.52 92.69,22.45 92.68,22.35 92.6,22.31 91.98,22.31 91.18,21.5 83.98,21.5 81.55,19.06 58.1,19.06 58.01,19.12 58.02,19.22 58.06,19.31 58.08,19.42 58.07,19.48 58.06,19.54 58.07,19.63 58.15,19.67 59.06,19.67 59.49,19.24 81.47,19.24 84.08,21.84 90.87,21.84 91.9,22.88
GND on IN3 (solid shape): 139.74,105.61 140.53,105.61 140.62,105.56 140.62,105.46 140.59,105.38 140.58,105.29 140.6,105.16 140.67,105.05 140.68,104.94 140.59,104.88 139.32,104.88 138.5,105.7 138.48,105.79 138.53,105.86 138.68,105.99 138.74,106.18 138.72,106.27 138.69,106.36 138.69,106.46 138.78,106.51 138.84,106.51
GND on IN3 (solid shape): 57.72,31.53 57.82,31.47 57.8,31.36 57.46,31.02 57.46,30.9 57.38,30.9 57.37,30.92 57.24,31.03 57.08,31.06 56.83,30.96 56.73,30.71 56.73,30.65 56.75,30.59 56.74,30.49 56.65,30.45 56.23,30.45 55.69,30.99 55.15,30.99 54.94,30.79 54.74,30.99 54.37,30.99 54.15,30.78 54,30.94 53.97,31.05 54.07,31.11 56.59,31.11 57.01,31.53
GND on IN3 (solid shape): 104.5,36.13 104.57,36.11 104.61,36.08 104.66,36.06 104.71,35.98 104.69,35.89 104.58,35.79 104.58,33.83 104.54,33.74 104.45,33.73 104.4,33.74 104.36,33.74 104.27,33.73 104.2,33.7 104.1,33.7 104.05,33.79 104.05,34.13 103.97,34.2 103.97,35.92 104.02,36 104.11,36.02 104.15,36.01 104.2,36 104.33,36.03 104.44,36.1
GND on IN3 (solid shape): 125.22,100.27 125.24,100.17 124.74,99.67 124.74,99.21 124.7,99.13 124.6,99.11 124.55,99.13 124.49,99.13 124.23,99.03 124.13,98.78 124.19,98.59 124.33,98.46 124.39,98.38 124.36,98.29 124.36,95.8 125.66,94.5 125.66,94.48 125.63,94.43 125.58,94.44 123.66,96.35 123.66,99.3 124.01,99.65 124.5,99.65 125.17,100.32
GND on IN3 (solid shape): 29.76,94.18 29.82,94.27 29.93,94.25 30.22,93.95 37.18,93.95 37.46,94.23 43.29,94.23 43.39,94.17 43.36,94.06 42.1,92.8 32.45,92.8 30.35,90.7 29.97,90.7 29.97,91 29.64,91.33 28.99,91.33 28.99,91.53 29.05,91.62 29.16,91.61 29.27,91.55 29.4,91.53 29.69,91.65 29.81,91.93 29.79,92.04 29.76,92.13
GND on IN3 (solid shape): 115.13,40.04 115.24,40.06 115.3,39.97 115.3,39.95 115.31,39.88 115.34,39.8 115.34,38.87 116.03,38.18 116.03,36.33 115.98,36.25 115.89,36.24 115.83,36.25 115.77,36.26 115.6,36.21 115.48,36.07 115.31,36.07 113.86,37.53 113.83,37.61 113.89,37.69 114.02,37.81 114.07,37.98 114.07,38.02 114.05,38.09 114.6,38.64 114.6,39.52
GND on IN3 (solid shape): 188.13,16.83 188.21,16.78 188.22,16.69 188.2,16.63 188.2,16.57 188.3,16.34 188.53,16.24 188.67,16.27 188.78,16.36 188.86,16.39 188.94,16.35 188.98,16.31 189.01,16.19 188.92,16.13 176.5,16.13 176.45,16.18 176.43,16.29 176.52,16.35 186.94,16.35 187.42,16.83
GND on IN3 (solid shape): 62.54,38.11 62.49,38.06 62.47,38.06 62.23,37.95 62.13,37.71 62.14,37.63 62.16,37.56 62.16,37.47 62.07,37.42 61.48,37.42 61.39,37.46 61.38,37.56 61.4,37.62 61.4,37.68 61.3,37.93 61.05,38.04 61,38.03 60.95,38.02 60.92,38.01 60.85,38.08 50.34,38.08 50.32,38.11 50.31,38.16 50.35,38.19 62.46,38.19
GND on IN3 (solid shape): 94.95,25.84 95.05,25.86 95.12,25.8 95.19,25.68 95.3,25.59 95.36,25.52 95.33,25.43 93.99,24.08 89.35,24.08 88.58,23.32 83.9,23.32 81.46,20.88 70.56,20.88 69.97,21.47 50.25,21.47 48.29,19.51 44.65,19.51 42.13,16.99 42.13,16.39 39.92,14.18 38.52,14.18 38.4,14.05 38.35,14.05 38.26,14.1 38.25,14.19 38.27,14.25 38.28,14.31 38.29,14.36 39.85,14.36 41.94,16.45 41.94,17.15 43.21,18.42 43.21,21.05 43.9,21.73 70.15,21.73 70.82,21.06 81.39,21.06 83.82,23.49 88.5,23.49 89.28,24.27 93.39,24.27
GND on IN3 (solid shape): 105.41,79.6 105.41,78.33 105.35,78.23 105.23,78.25 104.49,79 104.47,79.1 104.54,79.17 104.74,79.29 104.81,79.51 104.71,79.77 104.46,79.87 104.24,79.79 104.11,79.6 104.04,79.52 103.94,79.55 103.08,80.41 103.08,80.91 104.09,80.91
GND on IN3 (solid shape): 186.52,26.66 188.85,26.66 189.38,26.13 193.41,26.13 193.99,26.7 194.02,26.69 194.07,26.68 194.12,26.68 194.18,26.69 194.24,26.7 194.33,26.69 194.37,26.61 194.37,22.11 194.31,22.02 194.2,22.04 193.3,22.94 193.3,24.16 193.15,24.31 193.15,25.19 192.39,25.95 189.31,25.95 188.78,26.48 185.46,26.48 185.37,26.54 185.38,26.64 185.44,26.74 185.46,26.86 185.45,26.94 185.42,27.02 185.42,27.12 185.51,27.17 186,27.17
GND on IN3 (solid shape): 18.58,17.18 23.54,17.18 23.7,17.35 24.87,17.35 25.46,16.75 25.58,16.68 25.72,16.65 26,16.65 26.15,16.5 26.18,16.41 26.12,16.33 25.97,16.2 25.92,16.01 26.02,15.76 26.27,15.66 26.28,15.66 26.33,15.63 26.32,15.58 26.3,15.54 26.28,15.51 25.97,15.51 24.4,17.07 17.34,17.07 14.57,19.85 14.54,19.96 14.64,20.03 15.74,20.03
GND on IN3 (solid shape): 100.39,34.13 100.43,34.21 100.53,34.22 100.55,34.21 100.62,34.14 100.59,34.05 100.57,34.02 100.57,30.87 99.28,29.59 99.28,28.8 99.13,28.65 99.13,28.27 94.23,23.37 91.7,23.37 90.66,22.34 83.87,22.34 81.27,19.74 72.91,19.74 72.81,19.79 72.83,19.9 72.89,20.01 72.91,20.13 72.91,20.19 72.89,20.25 72.91,20.34 72.99,20.39 81.67,20.39 84.1,22.82 88.79,22.82 89.56,23.59 94.19,23.59 98.94,28.33 98.94,28.77 99.09,28.92 99.09,29.65 100.39,30.95
GND on IN3 (solid shape): 139.43,107.52 139.47,107.51 139.83,107.14 142.67,107.14 143.37,106.44 144.35,106.44 144.48,106.56 145.39,106.56 145.46,106.64 145.53,106.62 145.58,106.62 145.76,106.67 145.89,106.81 145.98,106.86 146.07,106.81 146.17,106.69 146.3,106.63 146.38,106.56 146.35,106.46 145.75,105.86 143.46,105.86 142.51,106.81 139.7,106.81 139.24,107.27 139.21,107.37 139.28,107.44 139.34,107.47 139.4,107.51
GND on IN3 (solid shape): 91.17,28.28 91.26,28.31 91.33,28.25 91.46,28.11 91.63,28.05 91.72,27.98 91.7,27.88 90.4,26.57 87.01,26.57 86.08,25.64 82.93,25.64 81.28,23.99 73.29,23.99 72.61,24.66 68.02,24.66 65.14,27.55 65.11,27.64 65.18,27.72 65.25,27.75 65.31,27.8 65.38,27.82 65.45,27.8 65.5,27.76 65.55,27.73 65.55,27.64 68.2,24.99 74.92,24.99 75.36,24.56 81.39,24.56 82.79,25.97 85.94,25.97 86.88,26.9 89.88,26.9 91.14,28.16 91.14,28.25
GND on IN3 (solid shape): 102.48,45.04 102.53,44.96 102.53,43.99 101.52,42.97 101.52,42.63 101.2,42.31 101.2,41.07 100.68,40.54 100.68,39.94 101.15,39.47 101.15,37.19 101.11,37.1 101.01,37.09 100.93,37.12 100.85,37.13 100.69,37.1 100.56,37.01 100.45,36.99 100.39,37.08 100.39,40.54 101,41.15 101,42.42 101.3,42.72 101.3,43.76 102.01,44.47 102.01,44.94 102.05,45.02 102.14,45.03 102.19,45.02 102.24,45.02 102.32,45.03 102.39,45.05
GND on IN3 (solid shape): 128.92,22.21 129,22.17 129.01,22.08 129,22.02 128.99,21.96 129.35,21.6 129.7,21.96 129.7,22.02 129.68,22.08 129.7,22.17 129.78,22.21 132.79,22.21 132.88,22.15 132.86,22.04 132.3,21.47 123.49,21.47 123.4,21.54 123.42,21.65 123.98,22.21
GND on IN3 (solid shape): 189.27,24.25 189.36,24.19 189.35,24.09 189.31,23.99 189.29,23.89 189.31,23.78 189.36,23.67 189.37,23.57 189.28,23.51 189.12,23.51 188.64,23.03 188.64,22.68 187.79,21.83 187.7,21.8 187.63,21.86 187.49,22 187.3,22.06 187.17,22.03 187.06,21.96 186.99,21.93 186.92,21.96 186.88,21.99 186.88,22.06 186.94,22.06 189.12,24.25
GND on IN3 (solid shape): 67.39,33.75 67.39,33.62 67.59,33.42 67.86,33.42 67.94,33.49 68.05,33.52 68.11,33.42 68.11,33.4 68.4,33.12 68.81,33.12 68.85,33.09 68.84,33.03 68.82,33.01 68.82,32.91 68.76,32.91 68.75,32.92 68.67,32.95 68.59,32.96 68.36,32.86 68.26,32.63 68.26,32.58 68.27,32.53 68.26,32.44 68.18,32.4 67.25,32.4 67.21,32.44 67.21,33.49 67.12,33.58 67.1,33.69 67.2,33.75 67.39,33.75
GND on IN3 (solid shape): 99.22,49.31 99.28,49.22 99.28,49.15 100.36,48.07 100.36,46.55 100.8,46.1 100.8,45.41 100.76,45.33 100.66,45.32 100.59,45.34 100.51,45.35 100.43,45.38 100.41,45.47 100.41,45.51 100.31,45.74 100.08,45.84 100.04,45.84 99.97,45.82 99.46,46.34 99.46,48.27 98.63,49.11 98.63,49.24 98.69,49.24 98.7,49.23 98.78,49.2 98.87,49.19 99,49.21 99.11,49.29
GND on IN3 (solid shape): 106.73,45.27 106.77,45.19 106.77,45.09 106.43,44.75 106.43,42.68 106.16,42.41 106.16,36.32 105.26,35.41 105.26,32.14 105.2,32.08 105.2,30.74 103.31,28.86 103.31,27.07 99.23,22.98 99.23,22.84 99.18,22.75 99.07,22.76 99.03,22.78 98.99,22.8 98.92,22.87 98.95,22.97 103.14,27.15 103.14,28.93 105.02,30.81 105.02,32.13 105.08,32.2 105.08,35.58 105.62,36.12 105.62,40.53 105.96,40.87 105.96,43.19 106.2,43.44 106.2,45.19 106.25,45.27 106.35,45.28 106.42,45.26 106.49,45.25 106.56,45.26 106.63,45.28
GND on IN3 (solid shape): 108.58,51.95 108.64,52.05 108.75,52.03 108.86,51.96 108.98,51.94 109.05,51.95 109.12,51.97 109.22,51.97 109.26,51.88 109.26,51.64 109.03,51.41 109.03,49.7 107.87,48.53 107.87,44.78 107.36,44.28 107.36,42.24 107.1,41.99 107.1,35.86 106.19,34.95 106.19,33.69 106.15,33.61 106.07,33.59 106.03,33.59 105.96,33.58 105.9,33.56 105.8,33.57 105.75,33.65 105.75,35.2 106.66,36.11 106.66,42.21 106.93,42.47 106.93,44.54 107.27,44.88 107.27,48.55 108.58,49.86
GND on IN3 (solid shape): 137.33,104.03 137.35,103.92 137.25,103.85 135.18,103.85 134.84,104.19 134.84,104.48 134.9,104.57 135,104.57 135.1,104.52 135.21,104.5 135.57,104.85 135.21,105.21 135.06,105.17 134.93,105.07 134.84,105.1 134.84,105.2 134.64,105.4 134.62,105.51 134.71,105.57 135.78,105.57
GND on IN3 (solid shape): 122.94,95.9 123,95.99 123.11,95.97 124.98,94.1 124.98,93.36 125.06,93.28 125.08,93.17 124.99,93.11 124.69,93.11 124.35,93.44 124.33,93.53 124.38,93.61 124.53,93.74 124.59,93.93 124.49,94.18 124.23,94.29 124.04,94.23 123.91,94.08 123.84,94.02 123.75,94.05 122.94,94.86
GND on IN3 (solid shape): 11.7,14.51 13.84,14.51 13.92,14.47 13.93,14.37 13.91,14.31 13.9,14.24 14.01,13.99 14.26,13.88 14.49,13.96 14.61,14.17 14.68,14.25 14.78,14.23 15.79,13.22 15.82,13.1 15.72,13.04 15.07,13.04 14.56,13.55 11.64,13.55 11,14.19 9.19,14.19 9.1,14.25 9.12,14.36 9.28,14.51 10.65,14.51 11.17,15.04
GND on IN3 (solid shape): 103.03,45.36 103.08,45.45 103.19,45.44 103.28,45.39 103.39,45.38 103.46,45.38 103.53,45.41 103.63,45.4 103.67,45.31 103.67,44.94 103.34,44.61 103.34,43.79 102.66,43.1 102.66,42.59 102.05,41.99 102.05,40.84 101.83,40.62 101.83,36.16 102.02,35.96 102.02,34.99 101.98,34.91 101.88,34.9 101.8,34.93 101.73,34.94 101.68,34.93 101.63,34.92 101.54,34.94 101.5,35.02 101.5,35.74 101.65,35.89 101.65,39.67 101.17,40.15 101.17,40.34 101.7,40.86 101.7,42.11 102.01,42.42 102.01,42.77 103.03,43.78
GND on IN3 (solid shape): 101.24,101.41 101.31,101.51 101.42,101.49 101.92,100.99 102.07,100.93 102.22,101 102.31,101.08 102.42,101.1 102.6,101.03 102.68,100.85 102.65,100.74 102.58,100.65 102.5,100.5 102.56,100.34 102.87,100.04 102.85,100 102.82,99.92 102.8,99.83 102.81,99.77 102.82,99.72 102.81,99.62 102.73,99.58 102.2,99.58 101.24,100.54
GND on IN3 (solid shape): 120.1,116.88 120.2,116.9 120.27,116.82 120.39,116.6 120.63,116.52 120.81,116.57 120.94,116.71 121.11,116.71 121.31,116.51 121.43,116.51 121.52,116.45 121.5,116.34 120.93,115.77 120.09,115.77 119.96,115.91 119.77,115.96 119.75,115.96 119.67,116 119.64,116.08 119.65,116.14 119.63,116.24 119.59,116.33 119.59,116.39 119.63,116.41 119.64,116.41
GND on IN3 (solid shape): 110.07,91.94 110.07,91.71 110.83,90.95 110.84,90.86 110.81,90.78 110.74,90.74 108.01,90.74 107.9,90.85 107.88,90.96 107.98,91.03 109.6,91.03 109.72,90.93 109.87,90.9 110.23,91.25 109.87,91.61 109.72,91.58 109.6,91.48 107.78,91.48 107.3,91.96 107.27,92.07 107.37,92.14 109.88,92.14
GND on IN3 (solid shape): 169.71,25.32 172.78,25.32 174,24.11 177.04,24.11 177.64,23.51 179.2,23.51 179.24,23.46 179.24,23.2 179.17,23.16 179.11,23.1 179.04,23.07 178.96,23.1 178.84,23.19 178.69,23.23 178.48,23.16 178.35,22.99 178.28,22.92 178.18,22.95 177.96,23.18 174.18,23.18 172.21,25.15 167.83,25.15 167.61,25.37 167.57,25.37 167.57,25.44 167.59,25.46 167.68,25.58 167.72,25.74 167.69,25.88 167.6,26 167.58,26.11 167.67,26.17 168.86,26.17
GND on IN3 (solid shape): 64.91,34.71 64.91,34.58 65.09,34.41 65.39,34.41 65.56,34.58 65.56,34.71 65.57,34.71 66.82,34.71 66.91,34.66 66.91,34.56 66.87,34.47 66.86,34.38 66.87,34.29 66.91,34.2 66.91,34.1 66.82,34.05 66.41,34.05 66.06,34.4 65.55,34.4 65.34,34.18 65.34,34.13 65.28,34.13 65.27,34.14 65.19,34.17 65.11,34.17 65.06,34.17 65.01,34.16 64.92,34.18 64.88,34.26 64.88,34.34 64.69,34.54 64.41,34.54 64.18,34.31 63.97,34.51 63.7,34.51 63.61,34.42 63.5,34.4 63.43,34.49 63.43,34.63 63.52,34.71 64.91,34.71
GND on IN3 (solid shape): 178.13,28.65 178.16,28.55 178.1,28.48 177.94,28.35 177.89,28.15 177.91,28.02 177.99,27.91 178.01,27.84 177.99,27.77 177.91,27.65 177.89,27.52 177.89,27.46 177.91,27.4 177.9,27.3 177.81,27.26 177.72,27.26 176.78,28.2 176.19,28.2 176.1,28.26 176.12,28.37 176.18,28.48 176.21,28.6 176.2,28.66 176.19,28.72 176.2,28.81 176.28,28.86 177.92,28.86
GND on IN3 (solid shape): 128.65,112.64 129.65,112.64 132.03,110.27 137.14,110.27 139.12,108.29 139.14,108.19 139.07,108.12 138.96,108.07 138.87,107.99 138.79,107.95 138.71,107.99 138.59,108.1 138.42,108.14 138.36,108.13 138.3,108.12 138.21,108.13 138.17,108.21 138.17,108.77 137,109.94 131.89,109.94 129.52,112.31 127.91,112.31 127.83,112.36 127.82,112.45 127.84,112.52 127.85,112.59 127.82,112.74 127.73,112.86 127.7,112.97 127.79,113.04 128.25,113.04
GND on IN3 (solid shape): 112.2,70.96 112.2,70 113.16,69.04 113.16,68.63 113.29,68.5 113.32,68.4 113.25,68.33 113.07,68.23 112.96,68.05 112.88,67.98 112.79,68.01 112.73,68.07 112.73,68.86 111.92,69.68 111.46,69.68 111.42,69.72 111.39,69.81 111.45,69.89 111.61,70.02 111.67,70.22 111.64,70.35 111.57,70.46 111.54,70.53 111.57,70.6 111.64,70.72 111.67,70.85 111.66,70.91 111.65,70.97 111.66,71.06 111.75,71.11 112.05,71.11
GND on IN3 (solid shape): 43.39,84.06 43.48,84.09 43.56,84.03 43.63,83.93 43.73,83.86 43.73,83.3 43.95,83.09 43.74,82.87 43.74,82.63 43.72,82.62 43.53,82.62 43.34,82.43 43.34,82.16 43.41,82.09 43.43,81.98 43.34,81.92 43.02,81.92 42.84,81.74 42.84,81.45 42.8,81.41 42.35,81.41 42.16,81.22 42.09,81.13 41.98,81.15 41.94,81.19 41.9,81.22 41.85,81.31 41.9,81.39 42.03,81.53 42.08,81.71 42.08,81.77 42.06,81.82 42.08,81.92 42.16,81.96 42.3,81.96 43.29,82.95 43.29,83.96
GND on IN3 (solid shape): 45.89,113.59 45.89,112.83 46.52,112.19 46.52,111.43 43.83,108.74 43.72,108.71 43.66,108.81 43.66,110.76 42.77,111.65 42.77,112.74 42.62,112.89 42.63,112.91 42.64,112.96 42.65,113.01 42.54,113.26 42.29,113.37 42.2,113.36 42.12,113.33 42.02,113.33 41.97,113.42 41.97,113.59 42.08,113.7 42.17,113.73 42.24,113.68 42.38,113.53 42.57,113.47 42.81,113.57 42.95,113.87 43.02,113.89 45.59,113.89
GND on IN3 (solid shape): 65.74,96.03 67.05,96.03 68.23,94.85 68.25,94.74 68.15,94.68 68.13,94.68 67.85,94.56 67.73,94.27 67.81,94.03 68.01,93.88 68.08,93.83 68.07,93.74 68.05,93.68 68.04,93.61 67.97,93.53 67.86,93.56 66.94,94.47 66.5,94.47 63.33,97.65 61.81,97.65 61.73,97.69 61.71,97.78 61.73,97.84 61.73,97.9 61.73,97.97 61.71,98.03 61.72,98.12 61.81,98.16 63.6,98.16
GND on IN3 (solid shape): 74.64,39.93 75.09,39.93 75.43,40.28 75.79,40.28 75.82,40.25 75.83,40.19 75.79,40.16 75.57,40.16 75.41,40.01 75.41,39.99 75.26,39.86 75.2,39.67 75.21,39.6 75.23,39.54 75.22,39.45 75.13,39.4 74.8,39.4 74.52,39.11 74.52,38.6 74.49,38.58 74.44,38.57 74.41,38.62 74.41,39.34 74.56,39.47 74.62,39.66 74.51,39.91 74.26,40.02 74.2,40.01 74.14,40 74.05,40.01 74.01,40.09 74.01,40.16 74.13,40.28 74.3,40.28
GND on IN3 (solid shape): 78.12,67.91 78.39,67.91 78.47,67.99 78.58,68.01 78.64,67.92 78.64,67.25 78.62,67.23 77.83,67.23 77.64,67.04 77.64,66.77 77.71,66.7 77.73,66.59 77.63,66.53 77.58,66.53 77.5,66.57 77.48,66.66 77.49,66.69 77.49,66.73 77.47,66.85 77.41,66.95 77.38,67.03 77.41,67.09 77.62,67.3 77.62,67.31 77.63,67.35 77.89,67.46 77.99,67.69 77.95,67.84 77.86,67.96 77.82,68.03 77.85,68.11 77.89,68.15
GND on IN3 (solid shape): 90.41,79.73 90.46,79.82 90.55,79.83 90.63,79.8 90.71,79.79 90.74,79.79 90.79,79.74 90.7,79.66 90.7,78.05 91.13,77.62 91.13,76 91.07,75.9 90.96,75.92 90.86,75.99 90.74,76.01 90.53,75.94 90.42,75.75 90.37,75.68 90.29,75.67 90.26,75.68 90.2,75.71 90.18,75.78 90.18,75.81 90.08,76.04 89.85,76.14 89.78,76.13 89.71,76.11 89.61,76.12 89.57,76.2 89.57,77.09 90.41,77.94
GND on IN3 (solid shape): 114.34,67.38 114.44,67.35 114.83,66.96 114.83,62.56 114.95,62.44 114.95,61.32 114.51,60.26 113.51,59.27 113.04,58.12 113.04,51.65 113.13,51.56 113.13,49.42 114.79,47.77 114.79,47.68 114.72,47.59 114.61,47.61 112.76,49.46 112.76,51.27 110.3,53.73 110.3,56.93 110.36,57.03 110.47,57 110.59,56.92 110.73,56.89 110.97,56.98 111.08,57.21 111.09,57.25 111.51,57.25 112.72,58.47 112.72,59.09 113.87,60.24 113.87,60.85 114.39,61.37 114.39,62.97 114.26,63.11 114.26,66.54 113.94,66.86 113.91,66.96 113.98,67.03 114.16,67.13 114.27,67.31
GND on IN3 (solid shape): 124.24,113.04 124.34,112.98 124.31,112.86 124.22,112.74 124.19,112.6 124.2,112.52 124.22,112.45 124.21,112.36 124.13,112.31 122.79,112.31 122.45,112.64 121.28,112.64 121.18,112.69 121.07,112.71 120.82,112.61 120.71,112.36 120.74,112.23 120.8,112.12 120.81,112.06 120.77,112.03 120.66,112.03 120.66,112.08 120.62,112.18 120.56,112.28 120.53,112.35 120.56,112.42 120.64,112.54 120.66,112.67 120.66,112.72 120.65,112.79 120.9,113.04
GND on IN3 (solid shape): 41,43.7 41.1,43.68 42.05,42.73 44.85,42.73 44.93,42.68 44.94,42.59 44.93,42.53 44.92,42.47 44.92,42.43 44.9,42.35 44.82,42.32 41.17,42.32 40.68,41.83 40.59,41.8 40.52,41.87 40.39,42.05 40.18,42.11 40.09,42.1 40.01,42.07 39.91,42.07 39.86,42.16 39.86,42.43 40.32,42.89 40.32,43.21 40.36,43.3 40.46,43.31 40.51,43.29 40.57,43.29 40.82,43.38 40.93,43.61
GND on IN3 (solid shape): 76.94,51.49 76.97,51.53 77.03,51.52 77.09,51.46 77.59,51.46 77.61,51.44 77.61,51.34 77.83,51.13 78.13,51.13 78.38,51.37 78.53,51.22 78.56,51.15 78.52,51.07 78.41,50.94 78.37,50.78 78.37,50.71 78.13,50.46 78.13,50.09 78.23,49.98 78.26,49.9 78.22,49.83 78.17,49.79 78.1,49.76 78.03,49.79 78,49.82 77.95,49.85 77.95,49.89 77.55,50.29 77.53,50.38 77.58,50.46 77.73,50.59 77.79,50.78 77.74,50.97 77.59,51.1 77.58,51.11 77.34,51.34 76.95,51.34 76.94,51.35
GND on IN3 (solid shape): 108.54,83.73 108.54,82.18 109.8,80.93 109.8,79.52 110.79,78.52 110.79,75.92 111.04,75.67 111.06,75.56 110.97,75.5 110.88,75.5 110.62,75.77 110.62,77.56 109.01,79.17 108.89,79.24 108.76,79.27 108.51,79.17 108.4,78.91 108.43,78.78 108.51,78.66 109.9,77.27 109.9,75.86 109.84,75.77 109.73,75.79 109.64,75.88 109.64,76.56 108.18,78.02 108.18,80.1 107.13,81.14 107.11,81.25 107.2,81.32 107.57,81.32 107.85,81.6 107.85,83.33 105.91,85.27 103.68,85.27 103.51,85.1 103.45,85.14 103.42,85.15 103.36,85.23 103.38,85.32 103.51,85.44 106.83,85.44
GND on IN3 (solid shape): 58.87,96.61 58.96,96.55 58.94,96.44 58.24,95.74 57.55,95.74 57.46,95.79 57.46,95.89 57.49,95.97 57.5,96.06 57.15,96.42 56.79,96.06 56.8,95.97 56.84,95.89 56.83,95.79 56.75,95.74 56.12,95.74 56.04,95.79 56.03,95.89 56.07,95.98 56.08,96.07 56.02,96.27 55.86,96.4 55.8,96.47 55.83,96.56 55.88,96.61
GND on IN3 (solid shape): 53.16,75.27 53.24,75.22 53.25,75.12 53.22,75.04 53.21,74.96 53.31,74.71 53.57,74.6 53.7,74.63 53.81,74.7 53.88,74.73 53.95,74.7 54.01,74.64 54.28,74.64 54.47,74.83 54.47,75.24 54.49,75.27 54.75,75.27 54.84,75.22 54.85,75.13 54.83,75.07 54.83,75.01 54.83,74.92 54.86,74.85 54.87,74.84 54.87,74.77 54.81,74.77 54.64,74.6 54.64,74.47 54.63,74.47 52.95,74.47 52.75,74.67 52.69,74.67 52.6,74.72 52.59,74.81 52.62,74.89 52.63,74.96 52.62,75.04 52.59,75.12 52.59,75.22 52.68,75.27
GND on IN3 (solid shape): 27.2,95.75 27.26,95.66 27.26,90.92 27.22,90.88 27.22,80.34 27.16,80.25 27.05,80.27 26.12,81.2 26.12,87.68 25.92,87.87 25.93,87.9 25.94,87.95 25.95,88 25.59,88.35 25.23,88 25.26,87.85 25.35,87.73 25.38,87.64 25.32,87.56 25.29,87.55 25.26,87.53 25.15,87.52 25.1,87.61 25.1,88.32 25.86,89.08 25.86,94.79 26.73,95.66 26.76,95.66 26.81,95.65 26.86,95.64 26.99,95.67 27.1,95.73
GND on IN3 (solid shape): 24.68,48.6 24.68,46.4 24.59,46.31 24.53,46.37 24.55,46.43 24.55,46.47 24.52,46.6 24.45,46.72 24.42,46.79 24.45,46.86 24.52,46.97 24.55,47.1 24.44,47.35 24.19,47.46 24.15,47.46 24.11,47.45 24.08,47.46 24.06,47.48 24.04,47.53 24.01,47.56 23.96,47.64 23.94,47.74 23.96,47.83 24.01,47.91 24.04,47.95 24.06,47.99 24.08,48.02 24.11,48.03 24.15,48.02 24.19,48.02 24.44,48.12 24.55,48.37 24.54,48.45 24.52,48.52 24.51,48.56 24.54,48.59 24.56,48.61 24.59,48.64
GND on IN3 (solid shape): 51.89,77.21 51.97,77.17 51.98,77.08 51.97,77.02 51.96,76.96 52.07,76.71 52.32,76.6 52.49,76.65 52.61,76.76 52.7,76.81 52.78,76.76 52.91,76.65 53.08,76.6 53.33,76.71 53.43,76.96 53.43,77.02 53.41,77.08 53.43,77.17 53.51,77.21 53.98,77.21 54,77.2 54,76.77 54.12,76.65 54.14,76.54 54.04,76.47 51.32,76.47 51.23,76.54 51.25,76.65 51.37,76.77 51.37,77.2 51.39,77.21
GND on IN3 (solid shape): 76.21,41.57 76.3,41.51 76.28,41.4 76.21,41.29 76.19,41.16 76.28,40.92 76.51,40.8 76.59,40.74 76.57,40.63 76.5,40.56 76.5,40.3 76.67,40.12 77.15,40.12 77.19,40.08 77.19,39.4 77.19,39.4 76.62,39.4 76.54,39.45 76.53,39.54 76.55,39.6 76.55,39.67 76.49,39.86 76.34,39.99 76.34,40.4 75.99,40.75 75.24,40.75 74.89,40.4 74.84,40.4 74.55,40.69 74.52,40.77 74.56,40.84 74.65,40.93 74.7,41.03 74.77,41.1 74.87,41.08 74.9,41.04 75.2,41.04 75.38,41.21 75.38,41.57 75.38,41.57
GND on IN3 (solid shape): 66.9,86.15 68.45,86.15 68.47,86.13 68.47,84.32 68.41,84.23 68.3,84.25 63.89,88.66 60.6,88.66 60.12,89.14 59.38,89.14 58.9,88.66 57.52,88.66 57.43,88.7 57.42,88.79 57.44,88.85 57.44,88.91 57.08,89.27 56.73,88.91 56.73,88.85 56.75,88.79 56.74,88.7 56.65,88.66 56.2,88.66 56.12,88.7 56.11,88.8 56.13,88.86 56.13,88.93 56.06,89.14 55.88,89.27 55.81,89.35 55.83,89.44 56.2,89.81 63.24,89.81
GND on IN3 (solid shape): 89.57,75.42 89.61,75.5 89.71,75.51 89.75,75.49 89.79,75.48 89.86,75.44 89.88,75.37 89.88,75.35 89.98,75.12 90.21,75.02 90.42,75.09 90.53,75.28 90.58,75.35 90.66,75.36 90.7,75.35 90.74,75.35 90.86,75.37 90.96,75.43 91.07,75.45 91.13,75.36 91.13,72.98 88.57,70.42 88.47,70.39 88.4,70.46 88.28,70.64 88.08,70.7 88.03,70.7 87.97,70.68 87.88,70.7 87.84,70.78 87.84,71.81 89.57,73.53
GND on IN3 (solid shape): 136.55,117.05 136.64,116.99 136.63,116.88 136.55,116.76 136.53,116.63 136.88,116.28 137.24,116.63 137.22,116.76 137.14,116.88 137.12,116.99 137.22,117.05 137.54,117.05 137.95,116.63 137.95,116.38 138.67,115.67 138.68,115.61 138.63,115.58 138.57,115.58 138.05,116.1 135.41,116.1 135.36,116.15 135.33,116.24 135.38,116.31 135.53,116.44 135.59,116.63 135.56,116.76 135.49,116.88 135.47,116.99 135.56,117.05
GND on IN3 (solid shape): 39.05,46.3 39.1,46.39 39.19,46.4 39.26,46.38 39.31,46.33 39.25,46.27 39.25,44.09 39.71,43.63 39.71,43.14 39.25,42.68 39.25,38.78 39.3,38.73 39.3,38.65 39.26,38.56 39.16,38.55 39.11,38.56 39.05,38.57 39.01,38.57 38.98,38.56 38.9,38.57 38.86,38.63 38.79,38.76 38.68,38.86 38.63,38.95 38.69,39.04 38.83,39.17 38.89,39.36 38.84,39.54 38.7,39.67 38.65,39.76 38.7,39.84 38.83,39.97 38.88,40.15 38.83,40.34 38.69,40.47 38.69,42.72 39.09,43.11 39.09,44.85 39.05,44.89
GND on IN3 (solid shape): 112.61,83.35 112.64,83.27 112.58,83.19 112.44,83.06 112.38,82.87 112.49,82.62 112.74,82.51 112.79,82.52 112.84,82.53 112.87,82.54 112.98,82.42 112.98,81.89 112.94,81.8 112.85,81.79 112.79,81.8 112.73,81.81 112.37,81.45 112.73,81.1 112.79,81.1 112.85,81.12 112.94,81.11 112.98,81.02 112.98,80.43 112.92,80.34 112.81,80.36 111.33,81.83 111.33,83.11 110.92,83.52 110.9,83.63 110.99,83.7 112.27,83.7
GND on IN3 (solid shape): 128.98,92.9 129.07,92.87 129.27,92.67 129.27,90.75 129.99,90.03 129.99,88.21 131.85,86.36 131.87,86.25 131.77,86.18 131.65,86.18 128.62,89.21 128.62,89.81 128.68,89.9 128.79,89.89 128.89,89.82 129.02,89.8 129.37,90.16 129.02,90.51 128.89,90.49 128.79,90.43 128.68,90.41 128.62,90.5 128.62,92.13 128.11,92.64 128.11,92.9 128.2,92.9 128.21,92.86 128.33,92.65 128.56,92.57 128.78,92.64 128.9,92.83
GND on IN3 (solid shape): 95.98,109.53 96.04,109.44 96.04,109.05 96.14,108.95 96.08,108.89 96.02,108.9 95.99,108.9 95.73,108.8 95.63,108.55 95.66,108.41 95.73,108.3 95.76,108.22 95.74,108.15 95.67,108.04 95.64,107.91 95.75,107.66 96,107.55 96.1,107.57 96.2,107.61 96.3,107.62 96.35,107.53 96.35,107.27 96.04,106.95 96.04,101.22 95.97,101.13 95.86,101.15 95.64,101.37 95.64,107.09 95.41,107.32 95.41,109.38 95.46,109.47 95.55,109.48 95.61,109.46 95.67,109.46 95.78,109.48 95.87,109.53
GND on IN3 (solid shape): 45.31,72.61 45.4,72.55 45.51,72.43 45.66,72.38 45.68,72.37 45.77,72.28 45.78,72.23 45.73,72.19 45.71,72.19 45.63,72.17 45.56,72.21 45.43,72.31 45.27,72.35 45.02,72.25 44.92,72 45.01,71.75 45.32,71.61 45.35,71.54 45.35,71.34 45.57,71.11 45.59,71 45.5,70.94 45.03,70.94 45.02,70.96 45.02,71.44 44.72,71.74 44.5,71.74 44.12,72.12 44.12,72.24 44.18,72.34 44.29,72.32 44.36,72.25 44.87,72.25 45,72.38 45.02,72.39 45.14,72.45 45.22,72.55
GND on IN3 (solid shape): 160.73,20.84 160.76,20.73 160.67,20.66 160.53,20.63 160.42,20.55 160.35,20.52 160.26,20.56 160.14,20.63 160.01,20.66 159.76,20.56 159.65,20.31 159.66,20.26 158.46,19.06 158.46,18.17 157.94,17.65 154.37,17.65 154.27,17.71 154.3,17.83 155.51,19.04 157.25,19.04 158.56,20.35 158.66,20.37 158.73,20.3 158.86,20.11 159.08,20.03 159.33,20.14 159.43,20.39 159.33,20.64 159.08,20.75 159.06,20.75 159.01,20.8 159.1,20.89 160.68,20.89
GND on IN3 (solid shape): outline of 102 points within 131.69,107.12 134.75,109.27
GND on IN3 (solid shape): 47.31,106.21 47.4,106.24 47.48,106.17 47.54,106.06 47.63,105.98 47.67,105.92 47.65,105.84 47.6,105.74 47.58,105.62 47.67,105.4 47.88,105.27 47.96,105.2 47.93,105.1 47.89,105.06 46.59,105.06 43.49,101.95 42.31,101.95 42.3,101.98 42.17,102.14 41.97,102.2 41.81,102.16 41.68,102.05 41.62,102.01 41.54,102.02 41.51,102.04 41.48,102.06 41.43,102.13 41.45,102.22 42.33,103.1 42.33,103.12 42.39,103.21 42.5,103.2 42.6,103.15 42.71,103.13 42.9,103.19 43.03,103.34 44.13,103.34 45.64,104.85 45.95,104.85
GND on IN3 (solid shape): 40.51,39.18 40.59,39.14 40.65,39.08 40.73,39.03 40.78,38.95 40.74,38.86 40.61,38.73 40.57,38.55 40.65,38.33 40.84,38.21 40.91,38.14 40.89,38.04 40.89,37.84 40.17,37.13 40.17,36.56 40.16,36.53 40.12,36.51 39.94,36.46 39.82,36.33 39.73,36.28 39.64,36.33 39.53,36.44 39.39,36.5 39.31,36.57 39.33,36.68 39.5,36.85 39.5,36.9 39.74,37.14 39.74,37.65 39.91,37.81 39.91,38.9 39.95,38.98 40.04,39 40.09,38.99 40.14,38.98 40.3,39.02 40.43,39.14
GND on IN3 (solid shape): 76.07,72.24 76.4,72.24 76.41,72.23 76.41,72.15 76.58,71.98 76.64,71.98 76.64,71.9 76.63,71.89 76.57,71.79 76.54,71.67 76.54,71.65 76.5,71.61 76.5,71.3 76.59,71.21 76.61,71.1 76.51,71.04 74.79,71.04 74.61,71.21 74.59,71.3 74.64,71.37 74.77,71.49 74.81,71.66 74.81,71.71 74.8,71.76 74.81,71.85 74.89,71.89 75.1,72.1 75.3,71.89 75.39,71.89 75.39,71.83 75.39,71.82 75.36,71.74 75.35,71.66 75.68,71.33 76.01,71.66 75.97,71.83 75.85,71.95 75.61,72.19 75.42,72.19 75.42,72.19 75.42,72.45 75.25,72.62 74.95,72.62 74.77,72.45 74.77,72.19 74.77,72.19 74.61,72.19 74.12,72.67 74.1,72.78 74.2,72.85 75.46,72.85
GND on IN3 (solid shape): outline of 110 points within 91.59,25.39 97.32,30.48
GND on IN3 (solid shape): outline of 102 points within 46.87,45.47 74.96,50.88
GND on IN3 (solid shape): 201.01,18.01 201.01,17.14 200.98,17.12 200.95,17.1 200.87,17.09 200.81,17.13 200.66,17.25 200.48,17.3 200.32,17.27 200.19,17.18 200.12,17.15 200.04,17.19 199.91,17.29 199.74,17.32 199.63,17.31 199.52,17.26 199.44,17.25 199.38,17.29 199.25,17.42 199.08,17.46 198.72,17.11 199.08,16.75 199.16,16.76 199.24,16.79 199.31,16.79 199.37,16.74 199.39,16.7 199.41,16.67 199.42,16.57 199.33,16.51 198.72,16.51 198.18,17.05 198.18,17.79 197.95,18.02 197.93,18.13 198.02,18.2 200.82,18.2
GND on IN3 (solid shape): 130.33,113.33 130.33,112.88 132.29,110.91 137.41,110.91 138.69,109.63 140.35,109.63 140.43,109.59 140.44,109.5 140.43,109.44 140.42,109.38 140.47,109.2 140.61,109.07 140.66,108.98 140.61,108.89 140.53,108.83 140.47,108.75 140.38,108.7 140.29,108.75 140.16,108.89 139.98,108.94 139.73,108.83 139.62,108.58 139.71,108.35 139.93,108.23 139.97,108.18 139.93,108.13 139.87,108.11 139.82,108.09 139.79,108.07 137.27,110.58 132.16,110.58 129.78,112.96 128.78,112.96 128.38,113.36 127.36,113.36 127.27,113.43 127.3,113.54 127.39,113.66 127.42,113.81 127.42,113.84 127.45,113.92 127.52,113.96 129.7,113.96
GND on IN3 (solid shape): 87.96,89.7 93.49,89.7 94.45,88.74 94.45,83.28 95.6,82.13 95.62,82.02 95.53,81.96 95.52,81.96 95.29,81.88 95.17,81.68 95.1,81.6 94.99,81.62 94.93,81.69 94.66,81.69 94.62,81.73 94.62,82.17 94.25,82.54 94.25,87.38 93.66,87.97 93.63,88.08 93.71,88.14 93.93,88.26 94.02,88.5 93.91,88.75 93.66,88.85 93.43,88.77 93.31,88.55 93.24,88.47 93.14,88.49 92.11,89.52 87.87,89.52 85.69,91.7 84.08,91.7 83.98,91.77 84,91.88 84.07,91.99 84.1,92.12 84.09,92.18 84.08,92.24 84.09,92.34 84.17,92.38 85.29,92.38
GND on IN3 (solid shape): 174.42,30.27 179.89,30.27 180.47,29.68 183.52,29.68 183.89,30.06 185.67,30.06 187.27,28.46 192.42,28.46 192.98,29.02 193.08,29.05 193.15,28.99 193.19,28.9 193.25,28.83 193.29,28.76 193.25,28.68 193.16,28.55 193.13,28.39 193.14,28.3 193.16,28.22 193.15,28.13 193.07,28.08 192.39,28.08 192.19,28.28 187.19,28.28 186.02,29.45 182.99,29.45 182.46,28.92 182.38,28.92 182.34,28.94 182.34,28.99 182.37,29.08 182.38,29.17 182.03,29.53 181.67,29.17 181.68,29.11 181.69,29.05 181.68,28.96 181.6,28.92 179.6,28.92 178.43,30.09 174.35,30.09 173.73,30.71 173.23,30.71 173.15,30.75 173.13,30.84 173.14,30.89 173.15,30.94 173.14,31.02 173.11,31.1 173.11,31.2 173.19,31.25 173.44,31.25
GND on IN3 (solid shape): 127.27,100.07 127.34,100.04 127.39,100 127.44,99.96 127.44,99.74 127.86,99.32 127.89,99.23 127.83,99.15 127.77,99.13 127.72,99.09 127.64,99.07 127.57,99.11 127.45,99.22 127.28,99.26 127.03,99.15 126.93,98.9 126.93,98.86 126.94,98.79 126.35,98.19 125.8,98.19 125.75,98.22 125.77,98.28 125.77,98.28 125.77,98.42 125.88,98.53 125.95,98.52 125.99,98.51 126.24,99.12 125.64,98.87 125.64,98.83 125.65,98.76 125.57,98.68 125.46,98.66 125.4,98.75 125.4,98.98 125.9,99.48 126.35,99.48 126.82,99.94 126.89,99.93 126.93,99.92 127.07,99.95 127.19,100.04
GND on IN3 (solid shape): 22.47,27.22 22.54,27.04 22.52,26.93 22.46,26.85 22.39,26.69 22.46,26.54 22.52,26.46 22.54,26.35 22.55,26.23 22.58,26.18 22.77,25.99 22.79,25.88 22.7,25.82 21.27,25.82 21.25,25.82 21.2,25.85 21.23,25.91 21.41,26.06 21.47,26.29 21.36,26.58 21.07,26.69 20.99,26.69 20.92,26.67 20.82,26.68 20.78,26.78 20.79,26.82 20.79,26.86 20.79,26.9 20.78,26.94 20.8,27.02 20.88,27.06 21.7,27.06 21.71,27.05 21.9,26.99 22.05,27.12 22.14,27.24 22.29,27.29
GND on IN3 (solid shape): 42.36,85.14 42.45,85.08 42.43,84.97 41.97,84.51 41.97,84.11 41.84,83.98 41.81,83.99 41.76,84 41.71,84.01 41.46,83.9 41.36,83.65 41.37,83.56 41.41,83.47 41.4,83.42 41.36,83.4 41.3,83.4 41.29,83.43 41.16,83.59 40.96,83.65 40.7,83.55 40.6,83.3 40.6,83.29 40.54,83.19 40.43,83.21 39.97,83.67 39.97,84.97 40.04,85.06 40.15,85.04 40.41,84.78 40.59,84.78 40.72,84.63 40.91,84.58 41.09,84.62 41.22,84.76 41.31,84.81 41.4,84.76 41.53,84.62 41.71,84.58 41.97,84.68 42.07,84.93 42.07,84.98 42.06,85.03 42.05,85.06 42.13,85.14
GND on IN3 (solid shape): 79.47,41.67 79.47,41.23 79.65,41.06 79.95,41.06 80.03,41.14 80.13,41.16 80.2,41.07 80.26,40.89 80.41,40.76 80.41,40.69 80.72,40.38 81.14,40.38 81.14,39.96 81.15,39.95 81.13,39.88 80.8,39.88 80.73,39.82 80.62,39.8 80.56,39.89 80.56,39.91 80.36,40.11 80.09,40.11 79.91,39.94 79.91,39.89 79.85,39.8 79.74,39.82 79.68,39.88 79.62,39.88 79.54,39.92 79.52,40.01 79.54,40.07 79.54,40.12 79.5,40.27 79.41,40.4 79.37,40.48 79.41,40.56 79.51,40.68 79.55,40.84 79.2,41.2 78.84,40.84 78.84,40.79 78.85,40.74 78.86,40.71 78.72,40.58 78.15,40.58 77.97,40.39 77.97,39.37 77.93,39.33 77.84,39.33 77.84,39.33 77.84,40.77 78.17,41.11 78.17,41.41 78.08,41.5 78.06,41.61 78.16,41.67 79.47,41.67
GND on IN3 (solid shape): 85.65,62.35 85.74,62.3 85.86,62.19 86.02,62.14 86.1,62.15 86.18,62.19 86.28,62.19 86.33,62.1 86.33,61.8 86.27,61.7 86.16,61.73 86.05,61.81 85.91,61.84 85.58,61.5 85.91,61.17 86.05,61.2 86.16,61.28 86.27,61.31 86.33,61.21 86.33,60.27 86.81,59.8 86.81,59.26 87.2,58.87 88.16,58.87 88.37,58.67 88.37,57.74 88.31,57.69 88.31,50.19 88.27,50.11 88.18,50.09 88.13,50.11 88.07,50.11 88.02,50.11 87.97,50.09 87.88,50.11 87.84,50.19 87.84,50.68 87.88,50.73 87.88,57.91 87.36,58.44 87.02,58.44 86.38,59.08 86.38,59.09 85,60.47 85,62.11 85.09,62.2 85.12,62.18 85.2,62.15 85.28,62.14 85.44,62.18 85.56,62.3
GND on IN3 (solid shape): 42.63,16.25 42.67,16.33 42.77,16.34 42.83,16.32 42.9,16.25 42.88,16.15 40.2,13.47 39.24,13.47 38.04,12.26 36.33,12.26 36.23,12.32 36.25,12.43 36.33,12.55 36.36,12.69 36.32,12.85 36.2,12.98 36.16,13.07 36.2,13.15 36.25,13.19 36.32,13.22 36.39,13.19 36.5,13.12 36.64,13.09 36.99,13.45 36.64,13.8 36.48,13.77 36.36,13.67 36.32,13.65 36.28,13.67 36.26,13.7 36.23,13.77 36.26,13.84 36.33,13.95 36.36,14.08 36.34,14.19 36.3,14.29 36.29,14.39 36.38,14.44 36.42,14.44 37.31,13.56 38.6,13.56 38.73,13.68 40.13,13.68 42.63,16.18
GND on IN3 (solid shape): 198.47,23.63 198.52,23.72 198.63,23.71 198.68,23.68 198.75,23.66 199.16,23.26 199.16,21.07 200.35,19.89 202.63,19.89 203.47,19.05 203.5,18.95 203.42,18.88 203.21,18.75 203.13,18.53 203.15,18.43 203.19,18.34 203.19,18.29 203.14,18.27 203.04,18.27 202.63,18.68 198.95,18.68 198.86,18.73 198.86,18.83 198.89,18.91 198.9,18.99 198.83,19.2 198.66,19.33 198.6,19.39 198.61,19.48 198.65,19.57 198.67,19.67 198.56,19.92 198.31,20.03 198.29,20.03 198.2,20.09 198.22,20.2 198.26,20.24 198.29,20.28 198.31,20.33 198.33,20.36 198.37,20.36 198.4,20.36 198.44,20.36 198.69,20.46 198.79,20.71 198.71,20.94 198.51,21.06 198.47,21.07
GND on IN3 (solid shape): 62.52,40.25 62.51,40.22 62.5,40.17 62.49,40.12 62.6,39.87 62.85,39.76 62.91,39.77 62.97,39.78 63.06,39.77 63.1,39.69 63.1,38.79 63.84,38.06 64.11,38.06 64.2,38 64.19,37.9 64.14,37.79 64.12,37.68 64.12,37.63 64.13,37.58 64.14,37.55 64.01,37.42 63.54,37.42 63.46,37.47 63.45,37.56 63.47,37.63 63.48,37.71 63.38,37.96 63.05,38.09 63.02,38.17 63.02,38.3 62.65,38.66 62.22,38.66 62.13,38.73 62.15,38.83 62.22,38.95 62.24,39.08 62.14,39.33 61.89,39.43 61.84,39.43 61.79,39.42 61.76,39.41 61.52,39.65 61.63,39.76 61.64,39.77 61.85,39.89 61.94,40.12 61.91,40.25 61.83,40.37 61.81,40.48 61.9,40.54 62.22,40.54
