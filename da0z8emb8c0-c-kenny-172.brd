# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Nets (continued)
32K_X2: C2568.1 R2408.2 U2030.AY4 Y2003.2
48M_X1: C2575.2 R2404.2 U2030.BB3 Y2002.1
48M_X2: C2576.2 R2404.1 U2030.BA5 Y2002.3
80PORT_CLK: CN17.3 U13.31
80PORT_DAT: CN17.4 U13.83
3622AC_PVCC: PC6002.2 PR6002.1 PU6000.34
3622AM_PVCC_GPU: PC9002.2 PR9002.1 PU9000.34
3662AC_BOOT1: PR6033.1 PU6000.38
3662AC_BOOT2: PR6043.1 PU6000.2
3662AC_CPU_HG1: PQ6001.1 PR6031.2
3662AC_CPU_HG2: PQ6002.1 PR6042.2
3662AC_CPU_LG1: PQ6001.8 PU6000.35
3662AC_CPU_LG2: PQ6002.8 PU6000.39
3662AC_CPU_LX1: PC6009.1 PL6001.1 PQ6001.5 PQ6001.6 PQ6001.7 PR6067.1 PR6068.1 PU6000.36
3662AC_CPU_LX2: PC6013.1 PL6002.1 PQ6002.5 PQ6002.6 PQ6002.7 PR6070.1 PR6071.1 PU6000.40
3662AC_CPUISEN1N: PC6011.1 PR6038.1 PR6040.2 PR6050.2 PR6069.2
3662AC_CPUISEN1P: PR6036.2 PR6068.2
3662AC_CPUISEN2N: PC6014.1 PR6035.2 PR6046.1 PR6047.1 PR6072.2
3662AC_CPUISEN2P: PR6045.2 PR6071.2
3662AC_EN: PC6000.1 PR6028.2 PU6000.29
3662AC_HG1: PR6031.1 PU6000.37
3662AC_HG2: PR6042.1 PU6000.1
3662AC_IMON_CPU: PC6017.1 PR6054.2 PU6000.14
3662AC_IMON_NB: PC6020.1 PR6066.2 PU6000.16
3662AC_ISEN1N_CPU: PC6012.2 PR6040.1 PR6047.2 PU6000.10
3662AC_ISEN1P_CPU: PC6011.2 PR6035.1 PR6036.1 PR6038.2 PU6000.9
3662AC_ISEN2P_CPU: PC6014.2 PR6045.1 PR6046.2 PR6050.1 PU6000.7
3662AC_ISENP_NB: PC6005.1 PR6015.2 PR6023.1 PU6000.25
3662AC_NB_HG1: PQ6003.4 PR6008.2
3662AC_NB_LG1: PQ6000.4 PU6000.33
3662AC_NB_LX1: PC6004.1 PL6000.1 PQ6000.5 PQ6003.1 PQ6003.2 PQ6003.3(S3) PR6073.1 PR6074.1 PU6000.32
3662AC_PGOOD: PR6049.1 PU6000.3
3662AC_PWROK: PR6037.1 PU6000.18
3662AC_RGND: PC6018.2 PR6032.2 PR6061.2 PR6064.1 PU6000.4
3662AC_SVC: PR6039.1 PU6000.19
3662AC_SVD: PR6041.1 PU6000.20
3662AC_SVT: PR6044.1 PU6000.21
3662AC_TSEN: PR6022.2 PR6025.2 PU6000.12
3662AC_TSEN_NB: PR6013.2 PR6018.2 PU6000.23
3662AC_VCC: PC6001.2 PR6001.2 PU6000.17
3662AC_VDDIO: PC6010.1 PR6034.2 PU6000.22
3662AC_VRHOT: PR6051.1 PU6000.11
3662ACCOMP_CPU: PC6015.1 PR6052.1 PU6000.5
3662ACCOMP_NB: PC6007.1 PR6026.1 PU6000.27
3662ACFB_CPU: PC6015.2 PC6016.2 PR6052.2 PR6053.2 PU6000.6
3662ACFB_NB: PC6007.2 PC6008.2 PR6026.2 PR6027.2 PU6000.26
3662ACNBISENN: PC6005.2 PC6006.1 PR6023.2 PR6075.2 PU6000.24
3662ACNBISENP: PR6015.1 PR6074.2
3662ACSET1: PR6005.2 PR6010.2 PU6000.13
3662AM_BOOT1_GPU: PR9031.1 PU9000.38
3662AM_BOOT2_GPU: PR9040.1 PU9000.2
3662AM_BOOT_VDDCI: PR9010.1 PU9000.30
3662AM_COMP_GPU: PC9016.1 PR9049.1 PU9000.5
3662AM_COMP_VDDCI: PC9007.1 PR9026.1 PU9000.27
3662AM_EN_GPU: PC9009.1 PR9029.2 PR77862.1 PR77865.2 PU9000.29
3662AM_FB_GPU: PC9016.2 PC9017.2 PR9049.2 PR9050.2 PU9000.6
3662AM_FB_VDDCI: PC9007.2 PC9008.2 PR9026.2 PR9027.2 PR9304.1 PU9000.26
3662AM_GPU_ISEN1N: PC9012.1 PR9035.1 PR9037.2 PR9047.2 PR9067.2
3662AM_GPU_ISEN1P: PR9033.2 PR9066.2
3662AM_GPU_ISEN2N: PC9015.2 PR9000.2 PR9044.2 PR9045.1 PR9069.2
3662AM_GPU_ISEN2P: PR9042.1 PR9070.2
3662AM_HG1_GPU: PQ9000.1 PR9030.2
3662AM_HG1_VDDCI: PQ9002.1 PR9006.2
3662AM_HG2_GPU: PQ9001.1 PR9039.2
3662AM_IMON_GPU: PC9018.1 PR9051.2 PU9000.14
3662AM_IMON_VDDCI: PC9020.1 PR9064.2 PU9000.16
3662AM_ISEN1N_GPU: PC9013.2 PR9037.1 PR9045.2 PU9000.10
3662AM_ISEN1P_GPU: PC9012.2 PR9000.1 PR9033.1 PR9035.2 PU9000.9
3662AM_ISEN2P_GPU: PC9015.1 PR9042.2 PR9044.1 PR9047.1 PU9000.7
3662AM_ISENP_VDDCI: PC9005.1 PR9011.2 PR9022.1 PR9100.2 PU9000.25
3662AM_LG1_GPU: PQ9000.8 PU9000.35
3662AM_LG1_VDDCI: PQ9002.8 PU9000.33
3662AM_LG2_GPU: PQ9001.8 PU9000.39
3662AM_LX1_GPU: PC9010.1 PL9001.1 PQ9000.5 PQ9000.6 PQ9000.7 PR9065.1 PR9066.1 PU9000.36
3662AM_LX1_VDDCI: PC9004.1 PL9002.1 PQ9002.9 PR9071.1 PR9072.1 PU9000.32
3662AM_LX2_GPU: PC9014.1 PL9000.1 PQ9001.5 PQ9001.6 PQ9001.7 PR9068.1 PR9070.1 PU9000.40
3662AM_PGOOD_GPU: PR9046.1 PU9000.3
3662AM_PWROK_GPU: PR9034.1 PU9000.18
3662AM_RGND_GPU: PC9019.2 PR9059.2 PR9062.1 PU9000.4
3662AM_SET1_GPU: PR9005.2 PR9016.2 PU9000.13
3662AM_SVC_GPU: PR9036.1 PU9000.19
3662AM_SVD_GPU: PR9038.1 PU9000.20
3662AM_SVT_GPU: PR9041.1 PU9000.21
3662AM_TSEN_GPU: PR9021.2 PR9025.2 PU9000.12
3662AM_TSEN_VDDCI: PR9009.2 PR9019.2 PU9000.23
3662AM_UGATE1_GPU: PR9030.1 PU9000.37
3662AM_UGATE2_GPU: PR9039.1 PU9000.1
3662AM_UGATE_VDDCI: PR9006.1 PU9000.31
3662AM_VCC_GPU: PC9001.2 PR9001.2 PU9000.17
3662AM_VDDCI_ISENN: PC9005.2 PC9006.1 PR9022.2 PR9073.2 PR9102.1
3662AM_VDDCI_ISENP: PR9011.1 PR9072.2
3662AM_VDDIO_GPU: PC9011.1 PR9032.2 PU9000.22
3662AM_VRHOT_GPU: PR9048.1 PU9000.11
3662AM_VSEN_GPU: PR9053.1 PU9000.8(VSEN)
3662NBBOOTNB: PR6014.1 PU6000.30
3662NBUGATENB: PR6008.1 PU6000.31
5213EN_1.8V: PC581.1 PR566.1 PU3004.7
5213EN_VDD08: PC9192.1 PR9105.2 PU9007.7
5213FB_1.8V: PC574.2 PR567.2 PR568.2 PU3004.1
5213FB_1.8V_S: PC574.1 PR568.1 PR569.1
5213FB_VDD08: PC9189.2 PR9106.2 PR9107.1 PU9007.1
5213LX_1.8V: PL551.1 PR551.1 PU3004.6
5213LX_VDD08: PL9006.1 PU9007.6
5213PG_1.8V: PR9290.1 PU3004.2
5213PG_VDD08: PR9104.1 PU9007.2
5447_CC1_CON: C438.2 C2769.2 CN14.A5 D38.2 U2034.12
5447_CC2_CON: C711.2 C2768.2 CN14.B5 D41.2 U2034.14
8801EN: PC9182.1 PR77846.2 PR77858.1 PR77864.2 PU9.2
24780_ACDET: PQ9.3 PR245.2 PR246.2 PU12.6
24780_ACDRV: PR247.2 PU12.4
24780_ACN: PC74.1 PC237.2 PR19.1 PU12.1
24780_ACP: PC76.2 PC237.1 PR18.1 PU12.2
24780_BATDRV: PR99.1 PU12.18
24780_BATSRC: PR108.2 PU12.17
24780_BM#: PR264.1 PU12.16
24780_BST: PR254.1 PU12.25
24780_CMPIN: PR85.1 PU12.13
24780_CMPOUT: PR265.1 PU12.14
24780_CMSRC: PR248.2 PU12.3
24780_DH: PQ26.4 PU12.26
24780_DL: PQ27.4 PU12.23
24780_ILIM: PC96.2 PR97.1 PR98.1 PU12.21
24780_LX: PC243.1 PL11.1 PQ26.1 PQ26.2 PQ26.3(S_3) PQ27.5 PR268.1 PU12.27
24780_PROCHOT: PR252.1 PR9292.2 PU12.10
24780_SRN: PC253.1 PC254.2 PR267.1 PR271.2
24780_SRP: PC248.2 PC253.2 PR261.1 PR270.2
24780_VCC: PC238.1 PR81.1 PU12.28(VCC)
25810_POL#_EC: R264.2 R6514.1 TP9099.1
+601_VCC: C449.1 C450.1 C451.1 C466.1 C476.1 C479.1 R435.2 R451.2 R461.2 R465.2 R470.2 R476.2 R481.2 R488.1 U17.10 U17.20(VCC#2)
+APU_VDD_33: C2531.1 C2532.1 C2533.1 R2391.2 U2030.AL18 U2030.AM17
+APU_VDD_33_S5: C2537.1 C2538.1 C2539.1 R2393.2 U2030.AL17 U2030.AM16
+APU_VDDIO_AZ: C2466.1 C2467.1 R2412.2 U2030.AP12
+AZA_VDD: C624.1 C656.1 C666.1 R364.2 R780.2 U30.1 U30.36
+BAT_RTC: CN2020.1 R2396.1
+ECVSPI: C370.1 C374.2 R324.1 R351.2 R358.2 R6594.1 U33.8(VCC)
+G_SEN_PW: C436.1 C447.1 R431.2 R468.1 R483.1 U16.1(VDD_IO) U16.8 U16.14
+TYPEC_VBUS: C426.2 C462.2 C2788.2 CN14.A4 CN14.A9 CN14.B4 CN14.B9(VBUS_4) R6521.1 U2035.1(OUT)
+USBPWR0: C304.2 C310.2 C593.2 C599.2 CN5.1 R646.1 R649.1 U5.2(VDD) U7.12(VOUT)
+USBPWR1: C604.2 C608.2 C609.2 C612.2 CN7.1 R646.2 R649.2 U11.2(VDD) U28.1(OUT)
+VGA_CORE: C2247.1 C2248.1 C2249.1 C2250.1 C2251.2 C2256.1 C2257.1 C2261.2 C2262.2 C2264.2 C2265.2 C2271.1 C2274.1 C2275.1 C2278.2 C2279.1 PC9027.1 PC9028.1 PC9029.1 PC9037.1 PC9038.1 PC9039.1 PC9040.1 PL9000.2 PL9001.2 PR9052.1 PR9067.1 PR9069.1 PR77860.1 R2717.2 U2029.AA13 U2029.AA15 U2029.AA21 U2029.AA23 U2029.AA29 U2029.AA31 U2029.AC13 U2029.AC15 U2029.AC21 U2029.AC23 U2029.AC29 U2029.AC31 U2029.AE13 U2029.AE15 U2029.AE21 U2029.AE23 U2029.AE29 U2029.AE31 U2029.AG13 U2029.AG15 U2029.AG21 U2029.AG23 U2029.AG29 U2029.AG31 U2029.AJ13 U2029.AJ15 U2029.AJ17 U2029.AJ19 U2029.AJ21 U2029.AJ23 U2029.AJ25 U2029.AJ27 U2029.AJ29 U2029.AJ31 U2029.AL13 U2029.AL15 U2029.AL17 U2029.AL19 U2029.AL21 U2029.AL23 U2029.AL25 U2029.AL27 U2029.AL29 U2029.AL31 U2029.N13 U2029.N15 U2029.N21 U2029.N23 U2029.N29 U2029.N31 U2029.R13 U2029.R15 U2029.R21 U2029.R23 U2029.R29 U2029.R31 U2029.U13 U2029.U15 U2029.U21 U2029.U23 U2029.U29 U2029.U31 U2029.W13 U2029.W15 U2029.W21 U2029.W23 U2029.W29 U2029.W31
+VREF_CA0: C2368.2 C2369.1 C2674.1 CN2019.164 R2270.1 R2276.2 R2389.1 R2682.2
+VREF_CA1: C2469.1 C2470.2 C2689.2 C2690.1 C2693.2 C2694.1 C2707.2 C2708.1 R2389.2 R2684.2 U2013.M1 U2014.M1 U2017.M1 U2018.M1
AC_PRESENT_EC: R77851.1 U13.84 U2030.AT10
ACCEL_INT1: C395.2 D14.1(CATHODE) U2030.AW16
ACCEL_INT2: D15.1(CATHODE) R835.2
ACCEL_INT2_R: D15.2 U16.9
ACCEL_INTA_R: D14.2 U16.11
ACIN: PR74.1 PR75.2 PR80.2 U13.72
ACZ_BCLK_R: R2426.1 U2030.AR2
ACZ_RST#_AUDIO: Q45.1(S) R782.1 R2429.2
ACZ_RST#_R: R2429.1 U2030.AP3
ACZ_SDIN0: R751.2 U2030.AP7
ACZ_SDOUT_AUDIO: R2443.2 U30.5
ACZ_SDOUT_R: R2443.1 U2030.AR3
ACZ_SPKR: D34.2 U2030.AU16
ACZ_SYNC_AUDIO: R2446.2 U30.10
ACZ_SYNC_R: R2446.1 U2030.AR4
ADBIA0: U2029.H21 VRAM2001.J4
ADBIA1: U2029.H19 VRAM2002.J4
ADOGND: C323.1 C327.1 C332.1 C340.1 C343.1 C366.2 C375.1 C616.1 C619.2 C620.2 C623.2 C627.2 C629.1 C635.2 C643.1 CN6.1 CN6.3 CN6.5 CN6.12 R224.2 R249.2 R275.1 R281.2 R289.1 R345.2 R686.1 R691.1 R720.1 R77884.2 U30.25 U30.38
ADP_ID: PJ6.3 PQ9.2 PR69.1 PR71.2
AGPIO3: TP2039.1 U2030.AT15
AGPIO130: TP9100.1 U2030.AV15
AMP_MUTE#: D36.1(CATHODE) U13.108
ANALOGIO: R2653.2 U2029.AY38
APU_ALERT#: R2524.2 U2030.J15
APU_CORETYPE: R2510.2 U2030.AW11
APU_DBRDY: CN2021.14 TP9104.1
APU_DBREQ#: C8164.1 R129.2 R567.2 U2030.AW3
APU_DISP_ON: D2039.2 Q2032.6 R536.2 R2546.2
APU_DISP_ON_R: Q2032.1(S) U2030.F15
APU_DPST_PWM: Q2033.3 R25.1 R2522.2
APU_DPST_PWM_R: Q2033.1(S) U2030.L14
APU_LVDS_BLON: D2038.2 Q2032.3 R20.2 R2547.2
APU_LVDS_BLON_R: Q2032.4 U2030.G15
APU_PROCHOT#: R2496.1 R2508.1 R2523.1 R2525.2
APU_PROCHOT#_R: R2525.1 U2030.L19
APU_PWRGD: C2594.2 R2517.2 R2519.2 R77835.2 U2030.AW2
APU_PWRGD_D: R77835.1 U8022.3
APU_PWRGD_SVID_REG: PR2033.2 PR6037.2 R2503.1 R2517.1
APU_PWROK_BUF: CN2021.10 R569.2 U8022.4(Y2)
APU_RST#: C2593.2 R2538.2 R77871.2 U2030.AW4 U8022.1
APU_RST_L_BUF: CN2021.12 R568.2 U8022.6
APU_SIC: Q2031.4 R2527.2 U2030.H14 U5400.8
APU_SID: Q2031.1(S) R2499.2 U2030.J14 U5400.7
APU_SPI_CLK: C2792.1 R403.1 R2308.2 R2310.1 R2403.1 R2430.1 R6533.1 U2030.BB7
APU_SPI_CLK_R: R6533.2 U2038.6
APU_SPI_CLK_TPM: R403.2 U15.19
APU_SPI_CS0#: R2425.1 R6532.2 R6544.2 U2030.BC9
APU_SPI_CS0#_R: R6532.1 U2038.1
APU_SPI_HOLD#: R6535.1 R6543.1 U2030.BC10 U2038.7
APU_SPI_SI: R448.1 R458.1 R2445.1 R6536.1 R6540.1 U2030.BA9
APU_SPI_SI_R: R6536.2 U2038.2
APU_SPI_SI_TPM: R458.2 U15.24
APU_SPI_SO: R417.1 R6534.1 R6541.1 U2030.BB10
APU_SPI_SO_R: R6534.2 U2038.5
APU_SPI_SO_TPM: R417.2 U15.21
APU_SPI_WP: R6538.1 R6542.1 R6550.2 U2030.BA10
APU_SPI_WP_R: R6538.2 U2038.3
APU_SVC: PC9173.2 PR6039.2 R2505.1 R2512.1 R2515.1
APU_SVD: PC9174.2 PR6041.2 R2502.1 R2513.1 R2516.1
APU_SVT: PC9175.2 PR6044.2 R2511.1 R2514.1
APU_TCK: CN2021.2 R12314.2 U2030.AU1
APU_TDI: C926.1 R626.2 R12315.2 U2030.AU2
APU_TDO: CN2021.8 U2030.AU4
APU_TEST4: TP2051.1 U2030.AP14
APU_TEST5: TP2052.1 U2030.AN14
APU_TEST14: R2551.1 U2030.G18
APU_TEST15: R2543.1 U2030.H19
APU_TEST16: R2544.1 U2030.F18
APU_TEST17: R2545.1 U2030.F19
APU_TEST18: CN2021.20 TP8548.1
APU_TEST19: CN2021.18 TP8547.1
APU_TEST31: R2520.1 R2521.1 U2030.W24
APU_TEST41: TP2053.1 U2030.AR11
APU_TEST470: TP2054.1 U2030.AJ21
APU_TEST471: TP2055.1 U2030.AK21
APU_THERMTRIP#: Q14.1(EMITTER) R2526.2 U2030.AP16
APU_TMS: CN2021.4 R12313.2 U2030.AU3
APU_TRST#: C869.1 R554.2 R12316.1 U2030.AV3
APU_VDDIO_MEM_FB_H: PR9301.2 TP9089.1
APU_VDDP_RUN_FB_H: PR2012.1 TP9091.1 U2030.AN11
APU_VDDP_RUN_FB_L: PR9296.1 TP9092.1 U2030.AM11
AUX_ZVSS: R2673.1 U2029.BA12
BAT-V: PC236.1 PC241.1 PC246.1 PC256.2 PC258.1 PD4.1 PJ11.7 PJ11.8 PR266.2 PR271.1
BATLED0#: CN6.21 U13.29
BATLED1#: CN6.20 U13.25
BI: PJ11.6 PR112.1 R622.2 SW3.1 SW3.2
BIT_CLK_AUDIO: C667.2 C2580.2 R2426.2 U30.6
BL#: Q4.2 Q4.3 R24.1
BL_ON: CN2.26 D1.2 Q3.3 Q4.6 R13.1
BOARD_ID0: R2357.2 R2376.1 U2030.BC18
BOARD_ID1: R2358.1 R2359.2 U2030.BA17
BOARD_ID2: R2360.1 R2361.2 U2030.BC16
BOARD_ID3: R2362.1 R2363.2 U2030.BB19
BOARD_ID4: C541.2 R517.1 R2364.1 R2365.2 U2030.BB16
BOARD_ID5: R2349.1 R2350.2 U2030.AK9
BOARD_ID6: C532.2 R516.1 R2351.1 R2352.2 U2030.AL9
BOARD_ID7: R2354.1 R2355.2 U2030.AL8
BOARD_ID8: R77862.1 R77863.2 U2030.AT12
BOARD_ID9: R77872.1 R77873.2 U2030.BA11
BP_0: R2226.2 TP8002.1 U2029.AA38
BP_1: R2231.2 TP8001.1 U2029.AA37
BRIGHT: R21.2 R25.2 R26.1
BT_EN: CN9.54(W_DISABLE2#) R402.2 R825.1
C1: R817.2 R824.1 U2032.12
C2: R775.1 R785.2 U2032.6
C_IN_CLK: CN4.10 D25.2 R589.1 R2706.1
C_IN_CLK#: CN4.12 D26.2 R589.2 R2705.1
C_IN_CLK#_R: C2742.2 U26.10
C_IN_CLK_R: C2743.2 U26.9
C_TX0_HDMI+: CN4.7 D31.2 R606.1 R2700.1
C_TX0_HDMI+_R: C2737.2 U26.6
C_TX0_HDMI-: CN4.9 D32.2 R606.2 R2699.1
C_TX0_HDMI-_R: C2736.2 U26.7
C_TX1_HDMI+: CN4.4 D29.2 R601.1 R2702.1
C_TX1_HDMI+_R: C2739.2 U26.4
C_TX1_HDMI-: CN4.6 D30.2 R601.2 R2701.1
C_TX1_HDMI-_R: C2738.2 U26.5
C_TX2_HDMI+: CN4.1 D27.2 R595.1 R2704.1
C_TX2_HDMI+_R: C2741.2 U26.1
C_TX2_HDMI-: CN4.3 D28.2 R595.2 R2703.1
C_TX2_HDMI-_R: C2740.2 U26.2
CASA0B: U2029.D23 VRAM2001.L3
CASA1B: U2029.D17 VRAM2002.G3
CKEA0: U2029.G21 VRAM2001.J3
CKEA1: U2029.E19 VRAM2002.J3
CLK_GFX_N_R: R2402.1 U2030.AN4
CLK_GFX_P_R: R2401.1 U2030.AN2
CLK_LPC_DEBUG: C701.1 R706.1 R77883.2
CLK_PCIE_LANN: R2413.2 U1.16
CLK_PCIE_LANN_R: R2413.1 U2030.AM4
CLK_PCIE_LANP: R2433.2 U1.15
CLK_PCIE_LANP_R: R2433.1 U2030.AM2
CLK_PCIE_SSDN: R848.2 R2420.2
CLK_PCIE_SSDN_C: CN18.53 R848.1
CLK_PCIE_SSDN_R: R2420.1 U2030.AL4
CLK_PCIE_SSDP: R847.2 R2419.2
CLK_PCIE_SSDP_C: CN18.55 R847.1
CLK_PCIE_SSDP_R: R2419.1 U2030.AL2
CLK_PCIE_VGA_N: R2402.2 U2029.AU33
CLK_PCIE_VGA_P: R2401.2 U2029.AV33
CLK_PCIE_WLANN: CN9.49 R2418.2
CLK_PCIE_WLANN_R: R2418.1 U2030.AM3
CLK_PCIE_WLANP: CN9.47 R2416.2
CLK_PCIE_WLANP_R: R2416.1 U2030.AM1
CLKA0: R2238.2 U2029.E31 VRAM2001.J12
CLKA0B: R2239.2 U2029.D31 VRAM2001.J11
CLKA1: R2257.2 U2029.D7 VRAM2002.J12
CLKA1B: R2254.2 U2029.D9 VRAM2002.J11
CLR_CMOS: Q2025.2 R2395.1 U13.19
CLR_REQ5#: R2449.1 U2030.AW18
CODEC_VREF: C616.2 U30.28(VREF)
CORE_PWM_PROCHOT#: PR6051.2 PR9292.1 R2508.2
CPU_VDD0_RUN_FB_H: PR6000.1 TP2045.1 U2030.K18
CPU_VDD0_RUN_FB_L: PR6061.1 U2030.J18
CPU_VDDNB_RUN_FB_H: PR6030.1 TP2044.1 U2030.J19
CPU_VDDNB_RUN_FB_L: PR6032.1 TP9093.1
CPU_VDDP_RUN_FB_H: PR9298.2 TP2056.1
CPU_VDDP_RUN_FB_L: PR2015.2 TP2050.1
CSA0B_0: U2029.H31 VRAM2001.G12
CSA1B_0: U2029.E7 VRAM2002.L12
CTL2: R225.1 U7.7
CTL3: R222.1 U7.8
DBGDATA_0: R2615.2 R2638.2 U2029.L40
DBGDATA_1: R2616.2 R2639.2 U2029.L41
DBGDATA_2: R2613.2 R2636.2 U2029.M40
DBGDATA_3: R2614.2 R2637.2 U2029.M41
DBGDATA_4: R2611.2 R2634.2 U2029.N40
DBGDATA_5: R2612.2 R2635.2 U2029.N41
DBGDATA_6: R2609.2 R2632.2 U2029.P40
DBGDATA_7: R2610.2 R2633.2 U2029.P41
DBRDY1: CN2021.15 R575.2
DBRDY2: CN2021.13 R12317.2
DBRDY3: CN2021.11 R560.2
DC-DET: R375.2 R752.1 U30.4
DCIN_EN: R2710.1 U26.8
DDBIA0_0: U2029.J38 VRAM2001.D2
DDBIA0_1: U2029.F40 VRAM2001.D13
DDBIA0_2: U2029.A38 VRAM2001.P13
DDBIA0_3: U2029.B30 VRAM2001.P2
DDBIA1_0: U2029.B25 VRAM2002.D2
DDBIA1_1: U2029.B18 VRAM2002.D13
DDBIA1_2: U2029.A12 VRAM2002.P2
DDBIA1_3: U2029.B5 VRAM2002.P13
DDR4_SUSON_2V5: PR124.2 U13.122
DE1: R465.1 R466.2 U17.9
DE2: R460.2 R461.1 U17.8
DEBUG_CLK: CN9.60 R706.2
DEBUG_IRQ: CN9.62 R712.2
DEVSLP0: Q5403.3 R570.2 U2030.AP9
DEVSLP0_R: HD1.5 R837.2
DEVSLP_HDD_C: Q5403.1(S) R570.1 R573.2 R837.1 R6645.1
DEW1: R481.1 R485.2 U17.16
DEW2: R435.1 R436.2 U17.6
DGPU_DP_HPD: TP9081.1 U2029.AV25
DGPU_HIN_RST#: R8133.1 R8134.1 U8001.2
DGPU_OPP#: R77852.2 U13.71
DGPU_OVT#_EC: R791.1 TP9095.1 U13.20
DGPU_PW_CTRL#: R77832.2 R77833.1 U2030.AW7
DGPU_PWREN: PR9133.2 PR9134.1 PR9136.1 R2431.1 U2030.AT18
DGPU_PWREN_R: PC9094.2 PQ9006.2 PR9134.2 PR77835.1 PR77846.1
DGPU_PWROK: PR9119.1 PR9122.2 R2439.1 R2452.2
DGPUT_CLK: Q2038.1(S) R2630.1 R2644.2 R8128.2
DGPUT_CLK_R: R2644.1 U2029.AW40
DGPUT_DATA: Q2038.4 R2629.1 R2643.2 R8118.2
DGPUT_DATA_R: R2643.1 U2029.AW41
DIECRACKMON: R8485.2 TP8067.1 U2029.B2
DISP_ON: R535.2 R536.1 U23.4
DMIC-DATA34: R338.1 TP36.1
DMIC_CLK: R749.2 U30.3
DMIC_CLK_2: R77874.2 U2030.AT2
DMIC_CLK_2_R: CN1.3 R77874.1
DMIC_CLK_L: C663.2 L11.2 R749.1
DMIC_CLK_L_C: C528.1 CN2.1 L11.1
DMIC_DAT: R745.1 U30.2
DMIC_DAT_2: R77875.2 U2030.AT4
DMIC_DAT_2_R: CN1.2 R77875.1
DMIC_DAT_L: L12.2 R745.2
DMIC_DAT_L_C: C529.1 CN2.2 L12.1
DNBSWON#: R2455.1 U13.123 U2030.AR15
DP_STEREOSYNC: R2549.1 R2550.1 U2030.K15
DQA0_0: U2029.L34 VRAM2001.E2
DQA0_1: U2029.L37 VRAM2001.F4
DQA0_2: U2029.L38 VRAM2001.E4
DQA0_3: U2029.J35 VRAM2001.F2
DQA0_4: U2029.G37 VRAM2001.B2
DQA0_5: U2029.E38 VRAM2001.B4
DQA0_6: U2029.E35 VRAM2001.A4
DQA0_7: U2029.D35 VRAM2001.A2
DQA0_8: U2029.H41 VRAM2001.B13
DQA0_9: U2029.H40 VRAM2001.A13
DQA0_10: U2029.G41 VRAM2001.A11
DQA0_11: U2029.G40 VRAM2001.B11
DQA0_12: U2029.E40 VRAM2001.E13
DQA0_13: U2029.D41 VRAM2001.F13
DQA0_14: U2029.D40 VRAM2001.F11
DQA0_15: U2029.C41 VRAM2001.E11
DQA0_16: U2029.C40 VRAM2001.M11
DQA0_17: U2029.B39 VRAM2001.M13
DQA0_18: U2029.A39 VRAM2001.N13
DQA0_19: U2029.B38 VRAM2001.N11
DQA0_20: U2029.B36 VRAM2001.T13
DQA0_21: U2029.A36 VRAM2001.U13
DQA0_22: U2029.B35 VRAM2001.T11
DQA0_23: U2029.A35 VRAM2001.U11
DQA0_24: U2029.B33 VRAM2001.U4
DQA0_25: U2029.B32 VRAM2001.T4
DQA0_26: U2029.A32 VRAM2001.U2
DQA0_27: U2029.B31 VRAM2001.T2
DQA0_28: U2029.A30 VRAM2001.N4
DQA0_29: U2029.B29 VRAM2001.N2
DQA0_30: U2029.B28 VRAM2001.M2
DQA0_31: U2029.A28 VRAM2001.M4
DQA1_0: U2029.B27 VRAM2002.F4
DQA1_1: U2029.A27 VRAM2002.F2
DQA1_2: U2029.B26 VRAM2002.E2
DQA1_3: U2029.A26 VRAM2002.E4
DQA1_4: U2029.A24 VRAM2002.B2
DQA1_5: U2029.B23 VRAM2002.A2
DQA1_6: U2029.A23 VRAM2002.B4
DQA1_7: U2029.B22 VRAM2002.A4
DQA1_8: U2029.B20 VRAM2002.A11
DQA1_9: U2029.A20 VRAM2002.B11
DQA1_10: U2029.B19 VRAM2002.A13
DQA1_11: U2029.A19 VRAM2002.B13
DQA1_12: U2029.B17 VRAM2002.E11
DQA1_13: U2029.A16 VRAM2002.E13
DQA1_14: U2029.B16 VRAM2002.F13
DQA1_15: U2029.A15 VRAM2002.F11
DQA1_16: U2029.B15 VRAM2002.U4
DQA1_17: U2029.A14 VRAM2002.U2
DQA1_18: U2029.B14 VRAM2002.T2
DQA1_19: U2029.B13 VRAM2002.T4
DQA1_20: U2029.A11 VRAM2002.M4
DQA1_21: U2029.B11 VRAM2002.N4
DQA1_22: U2029.A10 VRAM2002.N2
DQA1_23: U2029.B10 VRAM2002.M2
DQA1_24: U2029.B8 VRAM2002.M11
DQA1_25: U2029.A7 VRAM2002.N11
DQA1_26: U2029.B7 VRAM2002.N13
DQA1_27: U2029.A6 VRAM2002.M13
DQA1_28: U2029.A4 VRAM2002.T11
DQA1_29: U2029.B4 VRAM2002.T13
DQA1_30: U2029.A3 VRAM2002.U13
DQA1_31: U2029.B3 VRAM2002.U11
DRAM_RST_A: R2223.2 VRAM2001.J2 VRAM2002.J2
DRAM_RST_A_R: R2222.2 R2232.2 U2029.L32
EC_FPBACK#: Q3.2 U13.86
EC_ODD_EJ#: CN15.16 R393.1 R463.1
EC_ODD_EJ_R#: C384.1 R393.2 U13.94
EC_PECR_R: TP9083.1 U13.117
EC_PWROK: D2025.1 U13.33
EC_SPI1_CLK: C373.1 R312.1 R319.2
EC_SPI1_CLK_ER: R319.1 U13.105
EC_SPI1_CLK_R: R312.2 U33.6
EC_SPI1_SI: R321.2 R323.1 R698.1
EC_SPI1_SI_ER: R321.1 U13.102
EC_SPI1_SI_R: R323.2 U33.5
EC_SPI1_SO: R320.2 R382.1 R700.1
EC_SPI1_SO_ER: R320.1 U13.103
EC_SPI1_SO_R: R382.2 U33.2
EC_SPI_CS0#: R322.2 R384.2 R6594.2
EC_SPI_CS0#_ER: R322.1 U13.101
EC_SPI_CS0#_R: R384.1 U33.1
EC_SPI_HOLD#: R335.2 TP9102.1
EC_SPI_WP#: R363.1 TP9101.1
EC_SPI_WP#_R: R351.1 R363.2 U33.3
EC_TYPEC_CHG_HI: R6511.1 U13.3
EC_TYPEC_EN: R416.2 U13.80
EC_TYPEC_EN_R: R416.1 R6529.2
ECAGND: C433.2 C434.1 C457.1 L9.1 U13.75
ECROM_PWR: R324.2 R335.1 U33.7
EDCA0_0: U2029.G38 VRAM2001.C2
EDCA0_1: U2029.F41 VRAM2001.C13
EDCA0_2: U2029.B37 VRAM2001.R13
EDCA0_3: U2029.A31 VRAM2001.R2
EDCA1_0: U2029.B24 VRAM2002.C2
EDCA1_1: U2029.A18 VRAM2002.C13
EDCA1_2: U2029.B12 VRAM2002.R2
EDCA1_3: U2029.B6 VRAM2002.R13
EEPROM_SCL: R77831.1 TP2090.1 U2033.18
EEPROM_SDA: TP2091.1 U2033.26
EMMC_CLK: R6579.2 U2031.M6
EMMC_CLK_R: R6579.1 U2030.BD13
EMMC_CMD: R6580.2 U2031.M5
EMMC_CMD_R: R6552.1 R6580.1 R77880.2 U2030.BB14
EMMC_DAT0: R6581.2 U2031.A3
EMMC_DAT0_R: R6553.1 R6581.1 U2030.BB12
EMMC_DAT1: R6582.2 U2031.A4
EMMC_DAT1_R: R6554.1 R6582.1 U2030.BC11
EMMC_DAT2: R6583.2 U2031.A5
EMMC_DAT2_R: R6555.1 R6583.1 U2030.BB15
EMMC_DAT3: R6584.2 U2031.B2
EMMC_DAT3_R: R6556.1 R6584.1 U2030.BC15
EMMC_DAT4: R6585.2 U2031.B3
EMMC_DAT4_R: R6557.1 R6585.1 U2030.BA15
EMMC_DAT5: R6586.2 U2031.B4
EMMC_DAT5_R: R6558.1 R6586.1 U2030.BC13
EMMC_DAT6: R6587.2 U2031.B5
EMMC_DAT6_R: R6587.1 R77883.1 U2030.BB13
EMMC_DAT7: R6588.2 U2031.B6
EMMC_DAT7_R: R6559.1 R6588.1 U2030.BC12
EMMC_RCLK: R6589.2 U2031.H5
EMMC_RCLK_R: R6560.1 R6589.1 U2030.BA12
EMMC_RST_L_R: D2040.2 R2714.2 U2031.K5
EMMC_VDDI_BYP: C146.1 U2031.C2
EN: R446.2 R451.1 U17.7
EQ0: R2708.1 U26.13
EQ1: R476.1 R477.2 U17.17
EQ2: R470.1 R471.2 U17.19
ESPI_0: R6541.2 R6573.1
ESPI_0_R: R6564.1 R6573.2 U13.10
ESPI_1: R6540.2 R6574.1
ESPI_1_R: R6565.1 R6574.2 U13.9
ESPI_2: R6542.2 R6575.1
ESPI_2_R: R6566.1 R6575.2 U13.8
ESPI_3: R6543.2 R6576.1
ESPI_3_R: R6567.1 R6576.2 U13.7
ESPI_ALERT#: Q6565.6 R77859.1
ESPI_ALERT#_Q: Q6565.1(S) R77869.1 R77876.1 U2030.BC6
ESPI_CLK: R419.2 R2403.2 R6577.1
ESPI_CLK_R: R6568.1 R6577.2 U13.13
ESPI_CS#: R6578.1 R77857.1 U2030.BA8
ESPI_CS#_R: R6571.1 R6578.2 U13.6
ESPI_RESET#: D8516.2 R441.1 R77870.1 R77871.1
ESPI_RESET#_Q: Q6565.4 R77868.1 U2030.BB11
FAN1_RPM: FAN1.2 R371.2 U13.47
FAN_PWM: Q16.1(EMITTER) U13.32
FAN_PWM_C: FAN1.3 Q16.3 R370.2
FB_VMEMIO: TP8000.1 U2029.C3
G5335-AGND: PC9077.2 PC9096.2 PR9116.1 PR9117.1 PR9126.2 PU9005.4
G5335-AGND-1: PC2016.2 PC2017.2 PR2006.2 PR2011.2 PR2013.1 PR2015.1 PR9296.2 PU2000.4
G5335-BST: PR9137.2 PU9005.20
G5335-BST-1: PR2003.2 PU2000.20
G5335-EN: PC9096.1 PR9118.2 PR77853.1 PU9005.2
G5335-EN-1: PC2016.1 PR2009.2 PU2000.2
G5335-FB: PC9095.1 PR9125.2 PR9126.1 PU9005.5
G5335-FB-1: PC2014.1 PR2010.2 PR2011.1 PU2000.5
G5335-LX: PC9072.1 PL9005.1 PR9123.1 PU9005.10 PU9005.11 PU9005.16 PU9005.17 PU9005.18 PU9005.25
G5335-LX-1: PC2005.1 PL2000.1 PR2007.1 PU2000.10 PU2000.11 PU2000.16 PU2000.17 PU2000.18 PU2000.25
G5335-PFM: PR9116.2 PR9124.1 PU9005.3
G5335-PFM-1: PR2005.1 PR2006.1 PU2000.3
G5335-PWRGD: PR9119.2 PU9005.1
G5335-PWRGD-1: PR2004.1 PU2000.1
G5335-SS: PC9077.1 PU9005.23
G5335-SS-1: PC2017.1 PU2000.23
G5335-TON: PR9120.1 PU9005.6
G5335-TON-1: PR2001.1 PU2000.6
G5335-VCC: PC9074.1 PR9121.2 PU9005.21(VCC)
G5335-VCC-1: PC2004.1 PR2002.2 PU2000.21(VCC)
G_MBCLK_R: C467.1 R483.2 R484.2 U16.4
G_MBDATA_R: C464.1 R468.2 R475.2 U16.6
G_WAKEB: R2631.1 U2029.AU40
GC6FBEN_Q_EC: TP39.1 U13.2
GENERICA: TP8071.1 U2029.BA38
GFX_TX0N_C: C2653.2 U2030.N3
GFX_TX0P_C: C2652.2 U2030.N1
GFX_TX1N_C: C2651.2 U2030.M4
GFX_TX1P_C: C2650.2 U2030.M2
GFX_TX2N_C: C2649.2 U2030.L4
GFX_TX2P_C: C2648.2 U2030.L2
GFX_TX3N_C: C2647.2 U2030.L3
GFX_TX3P_C: C2646.2 U2030.L1
GPIO_0: R2607.2 R2626.2 U2029.W40
GPIO_1: R2604.2 R2623.2 U2029.AA40
GPIO_2: R2211.2 R2218.2 U2029.AA35
GPIO_8_ROMSO: R2660.2 R2661.2 R2664.1 TP8012.1 U2029.AP25
GPIO_9_ROMSI: R2656.1 R77855.2 R77856.2 TP8008.1 U2029.AM25
GPIO_10_ROMSCK: R2657.1 TP8006.1 U2029.AM27
GPIO_11: R2608.2 R2627.2 U2029.W41
GPIO_12: R2605.2 R2624.2 U2029.Y40
GPIO_13: R2606.2 R2625.2 U2029.Y41
GPIO_15: R77853.2 R77854.2 U2029.AA41
GPIO_20: R2603.2 R2622.2 U2029.AB40
GPIO_21_PCC: TP8527.1 U2029.AB41
GPIO_22_ROMCSB: R2667.2 R2668.2 R2669.1 TP8013.1 U2029.AP27
GPIO_28_FDO: R8042.1 R8047.2 U2029.U38
GPIO_29: R2212.2 R2219.2 U2029.W37
GPIO_30: R8041.1 R8046.2 U2029.W38
GPIO_5441: R6514.2 R6516.2 U2034.23
GPIO_SVC: R2243.1 U2029.AU17
GPIO_SVD: R2242.1 U2029.AV17
GPIO_SVT: R2241.1 U2029.AR17
GPU_CHOKE_THERMAL: R325.1 TP9088.1 U13.126
GPU_CLR_REQ4#: Q2030.3 R2448.1 R6648.1 U2030.AU19
GPU_CLR_REQ6#: R6647.1 U2030.AW19
GPU_EDP_HPD: TP8531.1 U2029.AV21
GPU_GPIO6: D8509.2 R12293.2 R12295.2 R12296.1 U2029.U35
GPU_PCIE_CLKREQ#: Q2030.1 R6648.2 R8527.2 R77861.2 U2029.AV40
GPU_PWM_PROCHOT#: PR9048.2 PR77866.2 R77867.2
H_PROCHOT#: C2596.1 Q20.3 R2496.2
H_THRMDA1: C96270.1 Q6544.2 Q6544.3 U5400.2
H_THRMDC1: C96270.2 Q6544.1(EMITTER) U5400.3
HDMI_ALS_PD: R2711.1 U26.12
HDMI_HPD: R93.2 R98.2 U26.25 VC1.1
HDMI_HPD_C: C183.1 CN4.19 R98.1
HDMI_HPD_PCH: TP8530.1 U2029.AU25
HDMI_HPD_Q: U26.3 U2030.G13
HDMI_SCLK: C239.1 CN4.15 D3.2 R163.2 U26.28
HDMI_SDATA: C249.1 CN4.16 D4.2 R164.2 U26.29
HDT_APU_TDI: CN2021.6 R12315.1
HDT_DBREQ#: CN2021.16 R567.1
HDT_TRST#: CN2021.9 R12316.2
HP-L2: C333.2 R238.2 R248.2 R249.1 U30.32
HP-L3: C327.2 CN6.4 R238.1
HP-R2: C334.2 R224.1 R227.2 R232.2 U30.33
HP-R3: C323.2 CN6.2 R232.1
HP_JD#: CN6.13 R715.2
HSYNC: R2214.2 R2221.2 U2029.W34
HUB_USB3_N: TP9086.1 U2033.15
HUB_USB3_P: TP9085.1 U2033.16
HWPG: D8.2 D9.2 D11.2 D12.2 D8514.2 R336.2 R369.1 U13.21
HWPG_1.5V: PR284.2 PR6416.2 R336.1
HWPG_1.8VS5: D11.1(CATHODE) PR9283.2 PR9290.2
HWPG_VDDPS5: D8514.1(CATHODE) PR2000.2 PR2004.2
HWPG_VDDR: D12.1(CATHODE) PR128.2 PR131.2
ICMNT: C457.2 PC235.2 PR249.2 U13.67
IDCHG_R: C453.2 PC73.2 PR250.2 U13.68
ILIM_HI: R235.2 U7.16
ILIM_LO: R223.2 U7.15
IN_CLK: C2743.1 U2030.F4
IN_CLK#: C2742.1 U2030.F2
IN_D0: C2737.1 U2030.F3
IN_D0#: C2736.1 U2030.E4
IN_D1: C2739.1 U2030.E1
IN_D1#: C2738.1 U2030.C1
IN_D2: C2741.1 U2030.E6
IN_D2#: C2740.1 U2030.D5
INT_AMIC-VREFO: C620.1 R686.2 U30.27
INT_EDP_AUXN: C43.2 U2030.B9
INT_EDP_AUXN_C: C43.1 CN2.22 R18.1
INT_EDP_AUXP: C53.2 U2030.D9
INT_EDP_AUXP_C: C53.1 CN2.23 R22.1
INT_EDP_TXN0: C537.2 U2030.A8
INT_EDP_TXN0_C: C537.1 CN2.19
INT_EDP_TXN1: C535.2 U2030.B8
INT_EDP_TXN1_C: C535.1 CN2.16
INT_EDP_TXN2: C533.2 U2030.C7
INT_EDP_TXN2_C: C533.1 CN2.13
INT_EDP_TXN3: C530.2 U2030.D6
INT_EDP_TXN3_C: C530.1 CN2.10
INT_EDP_TXP0: C538.2 U2030.C8
INT_EDP_TXP0_C: C538.1 CN2.20
INT_EDP_TXP1: C536.2 U2030.D8
INT_EDP_TXP1_C: C536.1 CN2.17
INT_EDP_TXP2: C534.2 U2030.B6
INT_EDP_TXP2_C: C534.1 CN2.14
INT_EDP_TXP3: C531.2 U2030.C6
INT_EDP_TXP3_C: C531.1 CN2.11
INT_HDMI_AUXN: R106.1 U26.32 U2030.F11
INT_HDMI_AUXP: R107.1 U26.31 U2030.G11
INT_HDMICLK+_OUT: R2706.2 U26.19
INT_HDMICLK-_OUT: R2705.2 U26.18
INT_HDMITX0N_OUT: R2699.2 U26.21
INT_HDMITX0P_OUT: R2700.2 U26.22
INT_HDMITX1N_OUT: R2701.2 U26.23
INT_HDMITX1P_OUT: R2702.2 U26.24
INT_HDMITX2N_OUT: R2703.2 U26.26
INT_HDMITX2P_OUT: R2704.2 U26.27
ISOLATEB: R30.2 R31.1 U1.20
JTAG_TCK: TP8075.1 U2029.AE41
JTAG_TDI: TP8073.1 U2029.AD40
JTAG_TDO: TP8074.1 U2029.AF41
JTAG_TESTEN: R2600.1 R2619.1 TP8007.1 U2029.AE40
JTAG_TMS: TP8076.1 U2029.AD41
JTAG_TRSTB: R2599.1 R2618.1 TP8010.1 U2029.AF40
JW5222LX1.5V: PL14.1 PU3003.3
KB_BL_LED: Q44.2 U13.113
KBC_RST#_C: R2421.2 U2030.BD11
KBRST#: Q6565.3 U13.4
KL_NO_EC: PR96.2 PR122.2 U13.70
L_SPK+: R442.1 U30.42
L_SPK+_1: C396.1 CN11.4 R442.2
L_SPK-: R443.1 U30.43
L_SPK-_1: C397.1 CN11.3 R443.2
LAD0: R830.1 R6553.2 R6564.2
LAD0_R: CN9.58 R830.2
LAD0_TP: CN9.64 TP9111.1
LAD1: CN9.66 R6554.2 R6565.2
LAD2: CN9.68 R6555.2 R6566.2
LAD3: CN9.70 R6556.2 R6567.2
LAN_AMBLED#: TP4.1 U1.27
LAN_LED1: TP2.1 U1.26
LAN_LED2: TP3.1 U1.25
LAN_MCTG0: R11.2 U21.24
LAN_MCTG1: R10.2 U21.21
LAN_MCTG2: R8.2 U21.18
LAN_MCTG3: R9.2 U21.15
LAN_XTAL1: C33.2 R16.1 Y1.1
LANPWR#: R5.2 R14.1 U13.16
LCD_BL_PWM: R2230.1 U2029.AC38
LCD_BLEN: R2229.1 U2029.AC37
LCD_VDD: R2601.1 U2029.AC40
LDO_3V3: C2783.2 R6512.2 R6513.2 R6522.2 R6524.2 R6525.2 R6526.2 U2034.20
LFRAME_L: R712.1 R6560.2 R6571.2
LID#: C498.1 D1.1(CATHODE) D21.2 HE1.1 HE2.1 R23.2 R368.2
LID#_C: C381.1 D10.1 R368.1 U13.118
LINE1-L: C333.1 U30.22
LINE1-R: C334.1 U30.21
LINE1-VREFO-L: R248.1 U30.31
LINE1-VREFO-R: R227.1 U30.30
LLB#: TP2038.1 U2030.AN6
LPC_PD_L: R6552.2 R6563.2
LPC_RST#: C2573.1 R2421.1 R6572.2
LPCCLK: R6557.2 R6568.2
LPCCLK_RUN_L: R2451.1 R6558.2 R6569.2
LPCCLK_RUN_L_R: R6569.1 U13.93
M0_5441: R6513.1 U2034.22
M1_5441: R6511.2 R6512.1 U2034.21
M_A_A0: CN2019.144 U2030.AF25
M_A_A1: CN2019.133 U2030.AE23
M_A_A2: CN2019.132 U2030.AD27
M_A_A3: CN2019.131 U2030.AE21
M_A_A4: CN2019.128 U2030.AC24
M_A_A5: CN2019.126 U2030.AC26
M_A_A6: CN2019.127 U2030.AD21
M_A_A7: CN2019.122 U2030.AC27
M_A_A8: CN2019.125 U2030.AD22
M_A_A9: CN2019.121 U2030.AC21
M_A_A10: CN2019.146 U2030.AF22
M_A_A11: CN2019.120 U2030.AA24
M_A_A12: CN2019.119 U2030.AC23
M_A_A13: CN2019.158 U2030.AJ25
M_A_ACT#: CN2019.114 U2030.AA22
M_A_ALERT#: CN2019.116 R2290.2 U2030.AA25
M_A_BG#0: CN2019.115 U2030.AA21
M_A_BG#1: CN2019.113 U2030.AA27
M_A_BS#0: CN2019.150 U2030.AF21
M_A_BS#1: CN2019.145 U2030.AF27
M_A_CAS#: CN2019.156 U2030.AG23
M_A_CKE0: CN2019.109 U2030.Y23
M_A_CKE1: CN2019.110 U2030.Y26
M_A_CLKN0: CN2019.139 U2030.AD24
M_A_CLKN1: CN2019.140 U2030.AE27
M_A_CLKP0: CN2019.137 U2030.AD25
M_A_CLKP1: CN2019.138 U2030.AE26
M_A_CS#0: CN2019.149 U2030.AG21
M_A_CS#1: CN2019.157 U2030.AJ27
M_A_DM0: CN2019.12 U2030.F21
M_A_DM1: CN2019.33 U2030.G27
M_A_DM2: CN2019.54 U2030.N24
M_A_DM3: CN2019.75 U2030.N23
M_A_DM4: CN2019.178 U2030.AL24
M_A_DM5: CN2019.199 U2030.AN27
M_A_DM6: CN2019.220 U2030.AW25
M_A_DM7: CN2019.241 U2030.AT21
M_A_DQ0: CN2019.8 U2030.J21
M_A_DQ1: CN2019.4 U2030.H21
M_A_DQ2: CN2019.17 U2030.F23
M_A_DQ3: CN2019.20 U2030.H23
M_A_DQ4: CN2019.7 U2030.G20
M_A_DQ5: CN2019.3 U2030.F20
M_A_DQ6: CN2019.16 U2030.J22
M_A_DQ7: CN2019.21 U2030.J23
M_A_DQ8: CN2019.28 U2030.G25
M_A_DQ9: CN2019.25 U2030.F26
M_A_DQ10: CN2019.37 U2030.L24
M_A_DQ11: CN2019.41 U2030.L26
M_A_DQ12: CN2019.29 U2030.L23
M_A_DQ13: CN2019.24 U2030.F25
M_A_DQ14: CN2019.38 U2030.K25
M_A_DQ15: CN2019.42 U2030.K27
M_A_DQ16: CN2019.45 U2030.M25
M_A_DQ17: CN2019.49 U2030.M27
M_A_DQ18: CN2019.59 U2030.P27
M_A_DQ19: CN2019.62 U2030.R24
M_A_DQ20: CN2019.50 U2030.L27
M_A_DQ21: CN2019.46 U2030.M24
M_A_DQ22: CN2019.58 U2030.P24
M_A_DQ23: CN2019.63 U2030.P25
M_A_DQ24: CN2019.70 U2030.M22
M_A_DQ25: CN2019.66 U2030.N21
M_A_DQ26: CN2019.80 U2030.T22
M_A_DQ27: CN2019.84 U2030.V21
M_A_DQ28: CN2019.71 U2030.L21
M_A_DQ29: CN2019.67 U2030.M20
M_A_DQ30: CN2019.79 U2030.R23
M_A_DQ31: CN2019.83 U2030.T21
M_A_DQ32: CN2019.169 U2030.AL27
M_A_DQ33: CN2019.174 U2030.AL25
M_A_DQ34: CN2019.186 U2030.AP26
M_A_DQ35: CN2019.187 U2030.AR27
M_A_DQ36: CN2019.170 U2030.AK26
M_A_DQ37: CN2019.173 U2030.AK24
M_A_DQ38: CN2019.182 U2030.AM24
M_A_DQ39: CN2019.183 U2030.AP27
M_A_DQ40: CN2019.191 U2030.AM23
M_A_DQ41: CN2019.195 U2030.AM21
M_A_DQ42: CN2019.204 U2030.AR25
M_A_DQ43: CN2019.203 U2030.AU27
M_A_DQ44: CN2019.190 U2030.AL22
M_A_DQ45: CN2019.194 U2030.AL21
M_A_DQ46: CN2019.208 U2030.AP24
M_A_DQ47: CN2019.207 U2030.AP23
M_A_DQ48: CN2019.215 U2030.AW26
M_A_DQ49: CN2019.212 U2030.AV25
M_A_DQ50: CN2019.225 U2030.AV22
M_A_DQ51: CN2019.229 U2030.AW22
M_A_DQ52: CN2019.216 U2030.AU26
M_A_DQ53: CN2019.211 U2030.AV27
M_A_DQ54: CN2019.224 U2030.AW23
M_A_DQ55: CN2019.228 U2030.AT22
M_A_DQ56: CN2019.236 U2030.AW21
M_A_DQ57: CN2019.237 U2030.AU21
M_A_DQ58: CN2019.246 U2030.AP21
M_A_DQ59: CN2019.250 U2030.AN20
M_A_DQ60: CN2019.232 U2030.AR22
M_A_DQ61: CN2019.233 U2030.AN22
M_A_DQ62: CN2019.245 U2030.AT20
M_A_DQ63: CN2019.249 U2030.AR20
M_A_DQSN0: CN2019.11 U2030.G22
M_A_DQSN1: CN2019.32 U2030.H26
M_A_DQSN2: CN2019.53 U2030.N26
M_A_DQSN3: CN2019.74 U2030.P21
M_A_DQSN4: CN2019.177 U2030.AM27
M_A_DQSN5: CN2019.198 U2030.AN25
M_A_DQSN6: CN2019.219 U2030.AT23
M_A_DQSN7: CN2019.240 U2030.AW20
M_A_DQSP0: CN2019.13 U2030.F22
M_A_DQSP1: CN2019.34 U2030.H27
M_A_DQSP2: CN2019.55 U2030.N27
M_A_DQSP3: CN2019.76 U2030.R21
M_A_DQSP4: CN2019.179 U2030.AM26
M_A_DQSP5: CN2019.200 U2030.AN24
M_A_DQSP6: CN2019.221 U2030.AU23
M_A_DQSP7: CN2019.242 U2030.AV20
M_A_EVENT#: CN2019.134 R2284.1 U2030.AE24
M_A_ODT0: CN2019.155 U2030.AG24
M_A_ODT1: CN2019.161 U2030.AJ22
M_A_PARITY: CN2019.143 R2283.2 U2030.AF24
M_A_RAS#: CN2019.152 U2030.AG26
M_A_RST#: CN2019.108 U2030.Y24
M_A_WE#: CN2019.151 U2030.AG27
M_B1_UZQ0: R2339.2 U2018.E9
M_B1_UZQ1: R2301.2 U2017.E9
M_B1_UZQ2: R2690.2 U2014.E9
M_B1_UZQ3: R2694.2 U2013.E9
M_B1_ZQ0: R2338.1 U2018.F9(ZQ)
M_B1_ZQ1: R2300.1 U2017.F9(ZQ)
M_B1_ZQ2: R2689.1 U2014.F9(ZQ)
M_B1_ZQ3: R2693.1 U2013.F9(ZQ)
M_B_A0: R2313.2 U2013.P3 U2014.P3 U2017.P3 U2018.P3 U2030.AG30
M_B_A1: R2328.2 U2013.P7 U2014.P7 U2017.P7 U2018.P7 U2030.AC32
M_B_A2: R2304.2 U2013.R3 U2014.R3 U2017.R3 U2018.R3 U2030.AC30
M_B_A3: R2342.2 U2013.N7 U2014.N7 U2017.N7 U2018.N7 U2030.AB29
M_B_A4: R2315.2 U2013.N3 U2014.N3 U2017.N3 U2018.N3 U2030.AB31
M_B_A5: R2347.2 U2013.P8 U2014.P8 U2017.P8 U2018.P8 U2030.AA30
M_B_A6: R2314.2 U2013.P2 U2014.P2 U2017.P2 U2018.P2 U2030.AA29
M_B_A7: R2330.2 U2013.R8 U2014.R8 U2017.R8 U2018.R8 U2030.Y30
M_B_A8: R2302.2 U2013.R2 U2014.R2 U2017.R2 U2018.R2 U2030.AA31
M_B_A9: R2329.2 U2013.R7 U2014.R7 U2017.R7 U2018.R7 U2030.W29
M_B_A10: R2317.2 U2013.M3 U2014.M3 U2017.M3 U2018.M3 U2030.AH29
M_B_A11: R2303.2 U2013.T2 U2014.T2 U2017.T2 U2018.T2 U2030.Y32
M_B_A12: R2343.2 U2013.M7 U2014.M7 U2017.M7 U2018.M7 U2030.W31
M_B_A13: R2332.2 U2013.T8 U2014.T8 U2017.T8 U2018.T8 U2030.AL30
M_B_ACT#: R2319.2 U2013.L3 U2014.L3 U2017.L3 U2018.L3 U2030.V30
M_B_ALERT#: R2683.1 U2013.P9 U2014.P9 U2017.P9 U2018.P9 U2030.W30
M_B_BG#0: R2318.2 U2013.M2 U2014.M2 U2017.M2 U2018.M2 U2030.V31
M_B_BG#1: R2344.2 R2346.1 R2687.1 R2691.1 R2695.1 U2030.V29
M_B_BG#1_R0: R2346.2 R2685.1 U2018.M9
M_B_BG#1_R1: R2687.2 R2688.1 U2017.M9
M_B_BG#1_R2: R2691.2 R2692.1 U2014.M9
M_B_BG#1_R3: R2695.2 R2696.1 U2013.M9
M_B_BS#0: R2316.2 U2013.N2 U2014.N2 U2017.N2 U2018.N2 U2030.AH31
M_B_BS#1: R2334.2 U2013.N8 U2014.N8 U2017.N8 U2018.N8 U2030.AG32
M_B_CAS#: R2335.2 U2013.M8 U2014.M8 U2017.M8 U2018.M8 U2030.AK32
M_B_CKE0: R2322.2 U2013.K2 U2014.K2 U2017.K2 U2018.K2 U2030.U29
M_B_CLKN0: R2697.2 U2013.K8 U2014.K8 U2017.K8 U2018.K8 U2030.AD30
M_B_CLKP0: R2698.2 U2013.K7 U2014.K7 U2017.K7 U2018.K7 U2030.AC31
M_B_CS#0: R2336.2 U2013.L7 U2014.L7 U2017.L7 U2018.L7 U2030.AJ31
M_B_DM0: U2018.E7 U2030.C21
M_B_DM1: U2018.E2 U2030.C25
M_B_DM2: U2017.E7 U2030.E32
M_B_DM3: U2017.E2 U2030.K30
M_B_DM4: U2014.E2 U2030.AP30
M_B_DM5: U2014.E7 U2030.AW31
M_B_DM6: U2013.E7 U2030.BB26
M_B_DM7: U2013.E2 U2030.BD22
M_B_DQ0: U2018.H2 U2030.B21
M_B_DQ1: U2018.H3 U2030.D21
M_B_DQ2: U2018.H7 U2030.B23
M_B_DQ3: U2018.J7 U2030.D23
M_B_DQ4: U2018.G2 U2030.A20
M_B_DQ5: U2018.J3 U2030.C20
M_B_DQ6: U2018.F7 U2030.A22
M_B_DQ7: U2018.H8 U2030.C22
M_B_DQ8: U2018.C2 U2030.D24
M_B_DQ9: U2018.D3 U2030.A25
M_B_DQ10: U2018.C8 U2030.D27
M_B_DQ11: U2018.D7 U2030.C27
M_B_DQ12: U2018.A3 U2030.C23
M_B_DQ13: U2018.C3 U2030.B24
M_B_DQ14: U2018.C7 U2030.C26
M_B_DQ15: U2018.B8 U2030.B27
M_B_DQ16: U2017.H3 U2030.C30
M_B_DQ17: U2017.G2 U2030.E29
M_B_DQ18: U2017.H7 U2030.H29
M_B_DQ19: U2017.F7 U2030.H31
M_B_DQ20: U2017.J3 U2030.A28
M_B_DQ21: U2017.H2 U2030.D28
M_B_DQ22: U2017.J7 U2030.F31
M_B_DQ23: U2017.H8 U2030.G30
M_B_DQ24: U2017.C2 U2030.J29
M_B_DQ25: U2017.A3 U2030.J31
M_B_DQ26: U2017.D7 U2030.L29
M_B_DQ27: U2017.C8 U2030.L31
M_B_DQ28: U2017.D3 U2030.H30
M_B_DQ29: U2017.C3 U2030.H32
M_B_DQ30: U2017.B8 U2030.L30
M_B_DQ31: U2017.C7 U2030.L32
M_B_DQ32: U2014.A3 U2030.AP29
M_B_DQ33: U2014.D3 U2030.AP32
M_B_DQ34: U2014.B8 U2030.AT29
M_B_DQ35: U2014.D7 U2030.AU32
M_B_DQ36: U2014.C2 U2030.AN30
M_B_DQ37: U2014.C3 U2030.AP31
M_B_DQ38: U2014.C7 U2030.AR30
M_B_DQ39: U2014.C8 U2030.AT31
M_B_DQ40: U2014.G2 U2030.AU29
M_B_DQ41: U2014.H3 U2030.AV30
M_B_DQ42: U2014.H8 U2030.BB30
M_B_DQ43: U2014.J7 U2030.BA28
M_B_DQ44: U2014.H2 U2030.AU30
M_B_DQ45: U2014.J3 U2030.AU31
M_B_DQ46: U2014.H7 U2030.AY32
M_B_DQ47: U2014.F7 U2030.AY29
M_B_DQ48: U2013.G2 U2030.BA27
M_B_DQ49: U2013.H3 U2030.BC27
M_B_DQ50: U2013.H8 U2030.BA24
M_B_DQ51: U2013.F7 U2030.BC24
M_B_DQ52: U2013.J3 U2030.BD28
M_B_DQ53: U2013.H2 U2030.BB27
M_B_DQ54: U2013.H7 U2030.BB25
M_B_DQ55: U2013.J7 U2030.BD25
M_B_DQ56: U2013.C2 U2030.BC23
M_B_DQ57: U2013.A3 U2030.BB22
M_B_DQ58: U2013.D7 U2030.BC21
M_B_DQ59: U2013.C8 U2030.BD20
M_B_DQ60: U2013.D3 U2030.BB23
M_B_DQ61: U2013.C3 U2030.BA23
M_B_DQ62: U2013.B8 U2030.BB21
M_B_DQ63: U2013.C7 U2030.BA21
M_B_DQSN0: U2018.F3 U2030.B22
M_B_DQSN1: U2018.A7 U2030.B25
M_B_DQSN2: U2017.F3 U2030.F30
M_B_DQSN3: U2017.A7 U2030.K29
M_B_DQSN4: U2014.A7 U2030.AR31
M_B_DQSN5: U2014.F3 U2030.AW29
M_B_DQSN6: U2013.F3 U2030.BA25
M_B_DQSN7: U2013.A7 U2030.BA22
M_B_DQSP0: U2018.G3 U2030.D22
M_B_DQSP1: U2018.B7 U2030.D25
M_B_DQSP2: U2017.G3 U2030.F29
M_B_DQSP3: U2017.B7 U2030.K31
M_B_DQSP4: U2014.B7 U2030.AR29
M_B_DQSP5: U2014.G3 U2030.AW30
M_B_DQSP6: U2013.G3 U2030.BC25
M_B_DQSP7: U2013.B7 U2030.BC22
M_B_ODT0: R2321.2 U2013.K3 U2014.K3 U2017.K3 U2018.K3 U2030.AL31
M_B_PARITY: R6593.1 U2013.T3 U2014.T3 U2017.T3 U2018.T3 U2030.AG31
M_B_RAS#: R2337.2 U2013.L8 U2014.L8 U2017.L8 U2018.L8 U2030.AJ30
M_B_RST#: U2013.P1 U2014.P1 U2017.P1 U2018.P1 U2030.T31
M_B_WE#: R2320.2 U2013.L2 U2014.L2 U2017.L2 U2018.L2 U2030.AK30
MAA0_0: U2029.G25 VRAM2001.H4
MAA0_1: U2029.H25 VRAM2001.H5
MAA0_2: U2029.E27 VRAM2001.H11
MAA0_3: U2029.D27 VRAM2001.H10
MAA0_4: U2029.D29 VRAM2001.K11
MAA0_5: U2029.H27 VRAM2001.K10
MAA0_6: U2029.H23 VRAM2001.K5
MAA0_7: U2029.E23 VRAM2001.K4
MAA0_8: U2029.D25 VRAM2001.J5
MAA1_0: U2029.E15 VRAM2002.K4
MAA1_1: U2029.H15 VRAM2002.K5
MAA1_2: U2029.G13 VRAM2002.K11
MAA1_3: U2029.D13 VRAM2002.K10
MAA1_4: U2029.H11 VRAM2002.H11
MAA1_5: U2029.H13 VRAM2002.H10
MAA1_6: U2029.H17 VRAM2002.H5
MAA1_7: U2029.G17 VRAM2002.H4
MAA1_8: U2029.D15 VRAM2002.J5
MAIND: PC104.1 PQ2000.4 PQ9014.2 PQ9015.3 PQ9056.2 PR9289.2
MAINON: PQ8.2 PR89.1 PR92.2 PR121.2 PR125.2 PR259.1 PR6417.1 PR9287.1 R462.1 U13.30
MAINON_ON_G: PQ7.2 PQ8.3 PQ10.2 PQ35.2 PQ9013.2 PQ9015.2 PQ9057.2 PR9284.2 PR9288.1
MBCLK: PC123.1 PD6.1 PR120.2 PR255.2 R805.1 U13.110
MBDATA: PC122.1 PD5.1 PR119.2 PR253.2 R811.1 U13.111
MDI0+: U1.1 U21.9
MDI0+_1: CN3.1 U21.16
MDI0-: U1.2 U21.8
MDI0-_1: CN3.2 U21.17
MDI1+: U1.4 U21.12(TD4-)
MDI1+_1: CN3.3 U21.13
MDI1-: U1.5 U21.11
MDI1-_1: CN3.6 U21.14
MDI2+: U1.6 U21.2
MDI2+_1: CN3.4 U21.23
MDI2-: U1.7 U21.3
MDI2-_1: CN3.5 U21.22
MDI3+: U1.9 U21.6
MDI3+_1: CN3.7 U21.19
MDI3-: U1.10 U21.5
MDI3-_1: CN3.8 U21.20
ME_WR#: TP9084.1 U13.109
MEM_CALRA: R2662.2 U2029.K15
MF_A0: R2663.2 VRAM2001.J1
MF_A1: R2671.2 VRAM2002.J1
MIC2-VREFO: R257.1 R260.1 U30.29
MINICAR_PME#: CN9.55 Q46.1(S) R833.1
MVREFDA: C96274.1 R2665.1 R2666.2 U2029.K17
MVREFDB: C96275.1 R77827.2 R77828.1 U2029.U10
MX0: C412.1 CN8.10 CN10.10 U13.58
MX1: C424.1 CN8.9 CN10.9 U13.59
MX2: C406.1 CN8.8 CN10.8 U13.60
MX3: C404.1 CN8.7 CN10.7 U13.61
MX4: C405.1 CN8.6 CN10.6 U13.62
MX5: C401.1 CN8.5 CN10.5 U13.63
MX6: C402.1 CN8.4 CN10.4 TP47.1 U13.64
MX7: C403.1 CN8.3 CN10.3 TP44.1 U13.65
MY0: C407.1 CN8.26 CN10.26 U13.36
MY1: C408.1 CN8.25 CN10.25 U13.37
MY2: C409.1 CN8.24 CN10.24 U13.38
MY3: C410.1 CN8.23 CN10.23 U13.39
MY4: C411.1 CN8.22 CN10.22 U13.40
MY5: C414.1 CN8.21 CN10.21 U13.41
MY6: C415.1 CN8.20 CN10.20 U13.42
MY7: C416.1 CN8.19 CN10.19 U13.43
MY8: C417.1 CN8.18 CN10.18 U13.44
MY9: C419.1 CN8.17 CN10.17 U13.45
MY10: C418.1 CN8.16 CN10.16 U13.46
MY11: C420.1 CN8.15 CN10.15 U13.51
MY12: C421.1 CN8.14 CN10.14 U13.52
MY13: C422.1 CN8.13 CN10.13 U13.53
MY14: C423.1 CN8.12 CN10.12 U13.54
MY15: C427.1 CN8.11 CN10.11 U13.55
MY16: C400.1 CN8.28 CN10.28 U13.56
MY17: C394.1 CN8.27 CN10.27 U13.57
NBSWON#: C676.2 CN8.1 D17.2 R362.1 R430.2 SW1.1 SW1.2 U13.107
NOVRP1: R566.1 U2033.25
NOVRP2: R563.1 U2033.24
NOVRP3: R552.1 U2033.20
NOVRP4: R551.1 U2033.19
OCP_DET: R244.1 R2719.1 U2034.16 U2035.3
ODD_PRSNT#: C703.1 R812.2 U2030.AR18
ODD_PRSNT#_C: C699.1 CN15.8 R806.1 R812.1
ODD_PWR: TP2032.1 U2030.AV18
PBA_FP_PWREN#: R418.1 U13.76
PBA_PWR: C425.2 Q19.1(S) R422.2 R438.1
PBA_PWR_C: CN13.8 R804.2
PBA_PWR_R: C455.2 C456.2 Q19.3 R438.2 R804.1
PCBEEP_EC: D35.2 U13.34
PCBEEP_EC_C: C638.2 C648.2 C660.2 R707.1 R718.2
PCH_AZ_CODEC_SDIN0_R: R751.1 U30.8
PCH_BLON_C: Q4.5 R12.2 R19.1 R20.1 R28.1
PCH_BLON_EC: R28.2 U13.88
PCH_PWROK: TP9103.1 U13.78
PCH_SUSPWRDNACK: TP9082.1 U13.15
PCIE_CLKREQ_LAN#: Q6.3 R44.1 R52.1 R2465.1 U2030.AN19
PCIE_CLKREQ_WLAN#: Q18.3 R2447.1 U2030.AP19
PCIE_REQ_LAN#_R: Q6.1(S) R44.2 R55.1 U1.12
PCIE_RST1#: R6024.2 R6642.2 U2030.BB6
PCIE_RST#: C2578.2 C8155.2 CN17.2 D2038.1(CATHODE) D2039.1(CATHODE) D2040.1(CATHODE) D6542.1 D6543.1 D8510.1(CATHODE) D8515.1(CATHODE) D8516.1(CATHODE) R2462.2 U1.19 U8001.1
PCIE_RST#_R: R2462.1 U2030.BD5
PCIE_RST#_SSD: D6542.3(COMMON ANODE) R497.1 R77878.1
PCIE_RXN0_SSD: R850.2 U2030.N9
PCIE_RXN1_SSD: R844.2 U2030.L9
PCIE_RXN2_SSD: R846.2 U2030.M11
PCIE_RXN3_SSD: R852.2 U2030.P11
PCIE_RXN4_LAN: C88.2 U2030.V7
PCIE_RXN5_WLAN: CN9.43 U2030.T9
PCIE_RXN13_SSD_C: CN18.5 R852.1
PCIE_RXN14_SSD_C: CN18.17 R846.1
PCIE_RXN15_SSD_C: CN18.29 R844.1
PCIE_RXN16_SSD_C: CN18.41 R850.1
PCIE_RXN_LAN_L: C88.1 U1.18
PCIE_RXP0_SSD: R849.2 U2030.N10
PCIE_RXP1_SSD: R843.2 U2030.L10
PCIE_RXP2_SSD: R845.2 U2030.L12
PCIE_RXP3_SSD: R851.2 U2030.P12
PCIE_RXP4_LAN: C94.2 U2030.V6
PCIE_RXP5_WLAN: CN9.41 U2030.T8
PCIE_RXP13_SSD_C: CN18.7 R851.1
PCIE_RXP14_SSD_C: CN18.19 R845.1
PCIE_RXP15_SSD_C: CN18.31 R843.1
PCIE_RXP16_SSD_C: CN18.43 R849.1
PCIE_RXP_LAN_L: C94.1 U1.17
PCIE_TXN0_SSD: C2633.1 CN18.47
PCIE_TXN0_SSD_C: C2633.2 U2030.P3
PCIE_TXN1_SSD: C2635.1 CN18.35
PCIE_TXN1_SSD_C: C2635.2 U2030.P2
PCIE_TXN2_SSD: C2637.1 CN18.23
PCIE_TXN2_SSD_C: C2637.2 U2030.R1
PCIE_TXN3_SSD: C2639.1 CN18.11
PCIE_TXN3_SSD_C: C2639.2 U2030.T2
PCIE_TXN4_LAN: C2641.2 U1.14
PCIE_TXN4_LAN_C: C2641.1 U2030.W4
PCIE_TXN5_WLAN: C2632.2 CN9.37
PCIE_TXN5_WLAN_C: C2632.1 U2030.V2
PCIE_TXP0_SSD: C2654.1 CN18.49
PCIE_TXP0_SSD_C: C2654.2 U2030.N2
PCIE_TXP1_SSD: C2634.1 CN18.37
PCIE_TXP1_SSD_C: C2634.2 U2030.P4
PCIE_TXP2_SSD: C2636.1 CN18.25
PCIE_TXP2_SSD_C: C2636.2 U2030.R3
PCIE_TXP3_SSD: C2638.1 CN18.13
PCIE_TXP3_SSD_C: C2638.2 U2030.T4
PCIE_TXP4_LAN: C2640.2 U1.13
PCIE_TXP4_LAN_C: C2640.1 U2030.W2
PCIE_TXP5_WLAN: C2631.2 CN9.35
PCIE_TXP5_WLAN_C: C2631.1 U2030.W3
PCIE_WAKE#: C2579.2 EC9.1 Q46.3 R2438.1 R6643.1 U2030.AV11
PCIE_ZVSS: R2645.1 U2029.AU41
PD#: C377.1 D36.2 D37.2 R355.1 R364.1 U30.47
PEG_RXN0: C8133.1 U2030.P9
PEG_RXN0_C: C8133.2 U2029.AU35
PEG_RXN1: C8132.1 U2030.N7
PEG_RXN1_C: C8132.2 U2029.AU39
PEG_RXN2: C8126.1 U2030.M9
PEG_RXN2_C: C8126.2 U2029.AR38
PEG_RXN3: C8116.1 U2030.L7
PEG_RXN3_C: C8116.2 U2029.AN38
PEG_RXP0: C8134.1 U2030.P8
PEG_RXP0_C: C8134.2 U2029.AV35
PEG_RXP1: C8127.1 U2030.N6
PEG_RXP1_C: C8127.2 U2029.AU38
PEG_RXP2: C8118.1 U2030.M8
PEG_RXP2_C: C8118.2 U2029.AR37
PEG_RXP3: C8110.1 U2030.L6
PEG_RXP3_C: C8110.2 U2029.AN37
PEG_TXN0: C2653.1 U2029.AT40
PEG_TXN1: C2651.1 U2029.AR40
PEG_TXN2: C2649.1 U2029.AP40
PEG_TXN3: C2647.1 U2029.AM40
PEG_TXP0: C2652.1 U2029.AT41
PEG_TXP1: C2650.1 U2029.AR41
PEG_TXP2: C2648.1 U2029.AP41
PEG_TXP3: C2646.1 U2029.AM41
PEGX_RST#: R8123.1 R8133.2 R8533.1 R77865.2 U8001.4 U8023.2
PEGX_RST#_R: R8533.2 U2029.AV41
PGANG: R559.2 U2033.23
PIRQA#: R400.1 R2428.1 U2030.BD15
PLLCHARZ_H: TP8011.1 U2029.AU15
PLLCHARZ_L: TP8009.1 U2029.AV15
PLTRST#_EC: C437.1 R441.2 R6572.1 R77864.2 U13.22
PMON: PC77.2 PR76.1 PR251.2 TP68.1
PP: R423.2 U15.4
PRE: R2709.1 U26.15
PROCHOT_EC: C440.2 Q20.2 R440.2 R6563.1 U13.17
PS_0: C28052.1 R77817.2 R77818.1 U2029.AM29
PS_1: C28053.1 R77819.2 R77820.1 U2029.AV29
PS_2: C28054.1 R77821.1 R77822.2 U2029.AU31
PS_3: C28055.1 R77825.2 R77826.1 U2029.AV31
PSELF: R556.1 U2033.22
PTP_PWR_EN#: TP35.1 U13.125
PWRLED#: CN6.19 U13.24
PX_EN: R2620.1 TP8068.1 U2029.AC41
R_SPK+: R445.1 U30.45
R_SPK+_1: C399.1 CN11.1 R445.2
R_SPK-: R444.1 U30.44
R_SPK-_1: C398.1 CN11.2 R444.2
RAM_ID0: R730.1 R763.2 U2030.AV8
RAM_ID1: R385.1 R392.2 U2030.AU10
RAM_ID2: R731.2 R732.1 U2030.AU6
RAM_ID3: R376.1 R389.2 U2030.AW13
RASA0B: U2029.D21 VRAM2001.G3
RASA1B: U2029.D19 VRAM2002.L3
REGN6V: PC80.1 PR75.1 PU12.24
REQ_WLAN#: CN9.53 Q18.1(S) R816.1
RESET#_USB: C2767.1 R2722.2 R6507.1 R6508.2 U2033.17
RF_EN: CN9.56 R487.2 R828.1
RING2: C332.2 CN6.6 CN6.7 CN6.8 R257.2 U30.17
ROMCSB: R2669.2 U2028.1
ROMSCK: R2657.2 U2028.6
ROMSI: R2656.2 U2028.5
ROMSO: R2664.2 U2028.2
RREF: R571.2 U2033.8
RSET: R6.2 U1.31
RSMRST#: D2026.1(CATHODE) U13.112
RSMRST#_R: C2574.1 D2026.2 R2400.1 U2030.AT16
RTC_CLK_APU: R6640.2 U2030.AW14
RTC_CLK_APU_C: R6640.1 U2039.2
S0A3_GPIO: R2452.1 U2030.AR8
S5_ON: PR100.2 PR257.2 PR566.2 PR2009.1 R333.1 U13.100
SATA_RXN0: C429.2 U2030.R7
SATA_RXN0_CN: C469.1 HD1.8
SATA_RXN0_IN: C429.1 U17.4
SATA_RXN1: C697.2 U2030.R10
SATA_RXN1A_C: C697.1 CN15.5
SATA_RXN_OUT: C469.2 U17.12
SATA_RXP0: C428.2 U2030.R6
SATA_RXP0_CN: C468.1 HD1.7
SATA_RXP0_IN: C428.1 U17.5
SATA_RXP1: C696.2 U2030.R9
SATA_RXP1A_C: C696.1 CN15.6
SATA_RXP_OUT: C468.2 U17.11
SATA_TXN0: C430.2 U2030.V3
SATA_TXN0_CN: C470.1 HD1.10
SATA_TXN0_IN: C430.1 U17.2
SATA_TXN1: C694.2 U2030.U4
SATA_TXN1A_C: C694.1 CN15.2
SATA_TXN_OUT: C470.2 U17.14
SATA_TXP0: C431.2 U2030.V1
SATA_TXP0_CN: C471.1 HD1.11
SATA_TXP0_IN: C431.1 U17.1
SATA_TXP1: C693.2 U2030.U2
SATA_TXP1A_C: C693.1 CN15.3
SATA_TXP_OUT: C471.2 U17.15
SCL: R2227.2 U2029.AC35
SDA: R2217.2 U2029.AC34
SEN_A0: R2240.1 VRAM2001.J10
SEN_A1: R2253.1 VRAM2002.J10
SENSEA: R360.1 R715.1 R734.1 U30.13
SERIRQ: R6559.2 R6570.2
SERIRQ_R: R6570.1 R77859.2 U13.5
SI_SS_SEL: R2650.1 R2651.2 U8021.5
SI_VDD: FB104.1 U8021.1
SI_XTALIN: C2656.1 R2648.2 R77830.1 U8021.2 Y2004.1
SI_XTALOUT: C2657.1 R2648.1 R77829.2 U8021.3(XOUT) Y2004.3
SIO_EXT_SCI#: R77882.1 U13.23 U2030.BA13
SL_CLK_100M: R2652.2 U8021.4
SLEEVE: C340.2 CN6.9 CN6.10 CN6.11 R260.2 U30.18
SMB_ALW_CLK: R450.2 R2453.1 U2030.AM9
SMB_ALW_DAT: R437.2 R2454.1 U2030.AM10
SMB_RUN_CLK: CN2019.253 R484.1 R2463.1 U2030.BC20
SMB_RUN_DAT: CN2019.254 R475.1 R2464.1 U2030.BA20
SMU_ZVDDP: R2509.1 U2030.V4
SPI_ROM_GNT: TP9098.1 U2030.BB8
SPI_ROM_REQ: TP9097.1 U2030.BC8
SPI_TPM_CS: R411.1 R412.1 R2427.1 U2030.BD8
SPI_TPM_CS_TPM: R412.2 U15.20
SSD_DET#: CN18.69 R492.1 R2440.1 U2030.AW10
SSD_PCIE_CLKREQ#: CN18.52 R2450.1 U2030.AT19
SUSB#: U13.119 U2030.AV13
SUSC#: U13.18 U2030.AT14
SUSCLK_32KHZ: CN9.50 R802.1
SUSCLK_WLAN: R802.2 U2039.4(Y)
SUSLED#: CN6.18 U13.28
SUSON: PR126.1 R348.1 U13.120
SVC_APU: R2515.2 U2030.F16
SVD_APU: R2516.2 U2030.H16
SVI2_CLK: PC9176.2 PR9036.2 PR9305.2 PR9308.2 R2243.2
SVI2_DATA: PC9177.2 PR9038.2 PR9306.2 PR9309.2 R2242.2
SVI2_SVT: PC9178.2 PR9041.2 R2241.2
SVID_EN: PR9034.2 R77850.1 U8023.4
SVT_APU: R2514.2 U2030.J16
SYS_HWPG: D9.1(CATHODE) PR237.2 PR273.2 U13.124
SYS_PWRGD: D2024.2 R2407.1 U2030.AV6
SYS_PWRGD_R: C2567.1 D2025.3(COMMON ANODE) R2390.2 R2406.2 R2407.2
SYS_RST#: D2024.1(CATHODE) R2309.2 R2311.1 U2030.AP10
SYS_SHDN#: PR70.1 PR77.2 PR193.1 PR276.2 Q14.3 R67418.1 U13.85
TEMP_FAIL: R8053.2 U2029.R38
TEMP_MBAT#: PR88.2 PR90.1 PR113.2 U13.73
TEST_PG: C2668.2 R2672.2 R67859.2 U2029.AY13
TEST_PG_BACO: C2666.2 R2670.2 U2029.BA13
TP_INTH#: R820.1 U2030.AU7
TP_INTH#_L: CN12.7 Q43.1(S) R797.1 R798.2
TP_PWR_C: C62.2 C67.2 CN2.30 CN2.31 R39.2 R41.2
TP_SMB_CLK: C460.1 CN12.6 Q21.3 R469.1
TP_SMB_DATA: C439.1 CN12.5 Q21.6 R429.1
TPCLK: L16.1 R787.2 U13.89
TPCLK-1: C681.1 CN12.2 L16.2
TPD_EN: R318.2 R795.1 R796.2
TPD_INT#_EC: R309.1 R310.2 R807.1
TPDAT-1: C680.1 CN12.3 L15.2
TPDATA: L15.1 R784.2 U13.90
TPM_LRESET#: D8515.2 R77879.2 U15.17
TRA_V_DAC: C97.1 U21.1 U21.4 U21.7 U21.10
TS_EN: R33.2 R410.1
TS_EN_C: C390.1 R410.2 U13.81
TS_EN_R: CN2.28 R33.1
TYPEC1_DDI1_HPD: TP8528.1 U2029.AU21
TYPEC_SBU1: CN14.A8 D19.2 TP45.1
TYPEC_SBU2: CN14.B8 D39.2 TP98.1
TYPEC_STRAP: R407.2 R421.2 U13.77
UART0_CTS: TP9109.1 U2030.BA18
UART0_INTR: TP9110.1 U2030.BD18
UART0_RTS: TP9108.1 U2030.BC17
UART0_RXD: TP9106.1 U2030.BA16
UART0_TXD: TP9107.1 U2030.BB18
ULT_EDP_HPD: C91.2 R32.1 R6590.1 U2030.C10
ULT_EDP_HPD_R: CN2.25 R32.2
USB1_DM0-_HUB: R2720.1 R77843.1
USB1_DM0-_HUB_R: R2720.2 U2033.1
USB1_DP0+_HUB: R2721.1 R77842.1
USB1_DP0+_HUB_R: R2721.2 U2033.2
USB3_SS0RX+: C700.1 U2032.8
USB3_SS0RX+_RE: C2780.2 U2032.4
USB3_SS0RX+_RE_C: C2780.1 R6525.1 U2034.5
USB3_SS0RX-: C695.1 U2032.7
USB3_SS0RX-_RE: C2781.2 U2032.5
USB3_SS0RX-_RE_C: C2781.1 R6526.1 U2034.4
USB3_SS0TX+: C684.1 U2032.11
USB3_SS0TX+_RE: C2778.2 U2032.1
USB3_SS0TX+_RE_C: C2778.1 R6522.1 U2034.7
USB3_SS0TX-: C675.1 U2032.10
USB3_SS0TX-_RE: C2779.2 U2032.2
USB3_SS0TX-_RE_C: C2779.1 R6524.1 U2034.6
USB30_RX0+: C700.2 U2030.AC2
USB30_RX0-: C695.2 U2030.AC4
USB30_RX1+: C287.2 C28067.2 U2030.AJ9
USB30_RX1+_C: C28067.1 CN5.6 U5.10
USB30_RX1-: C295.2 C28066.2 U2030.AJ8
USB30_RX1-_C: C28066.1 CN5.5 U5.1
USB30_RX2+: C363.2 C28063.2 U2030.AG7
USB30_RX2+_C: C28063.1 CN7.6 U11.10
USB30_RX2-: C368.2 C28062.2 U2030.AG6
USB30_RX2-_C: C28062.1 CN7.5 U11.1
USB30_RX3+: TP2025.1 U2030.Y1
USB30_RX3-: TP2026.1 U2030.Y3
USB30_RX+_TYPEC1: C2777.1 CN14.B11 R6520.1 RV1.1 RV1.10(NC#4)
USB30_RX+_TYPEC1_C: C2777.2 U2034.3
USB30_RX+_TYPEC2: C2773.1 CN14.A11 R6517.1 RV2.1 RV2.10(NC#4)
USB30_RX+_TYPEC2_C: C2773.2 U2034.1
USB30_RX-_TYPEC1: C2776.1 CN14.B10 R6518.1 RV1.2 RV1.9
USB30_RX-_TYPEC1_C: C2776.2 U2034.2
USB30_RX-_TYPEC2: C2772.1 CN14.A10 R6515.1 RV2.2 RV2.9
USB30_RX-_TYPEC2_C: C2772.2 U2034.24
USB30_TX0+: C684.2 U2030.AD2
USB30_TX0-: C675.2 U2030.AD4
USB30_TX1+: C272.2 U2030.AG3
USB30_TX1+_C: C272.1 R198.2
USB30_TX1+_C_R: C270.1 CN5.9 R198.1 U5.6
USB30_TX1-: C277.2 U2030.AG1
USB30_TX1-_C: C277.1 R200.2
USB30_TX1-_C_R: C280.1 CN5.8 R200.1 U5.5
USB30_TX2+: C349.2 U2030.AG4
USB30_TX2+_C: C349.1 R280.2
USB30_TX2+_C_R: C345.1 CN7.9 R280.1 U11.6
USB30_TX2-: C351.2 U2030.AG2
USB30_TX2-_C: C351.1 R284.2
USB30_TX2-_C_R: C352.1 CN7.8 R284.1 U11.5
USB30_TX3+: TP2027.1 U2030.AA2
USB30_TX3-: TP2028.1 U2030.AA4
USB30_TX+_TYPEC1: C2775.1 CN14.A2 RV2.5 RV2.6
USB30_TX+_TYPEC1_C: C2775.2 U2034.9
USB30_TX+_TYPEC2: C2771.1 CN14.B2 RV1.5 RV1.6
USB30_TX+_TYPEC2_C: C2771.2 U2034.10
USB30_TX-_TYPEC1: C2774.1 CN14.A3 RV2.4 RV2.7
USB30_TX-_TYPEC1_C: C2774.2 U2034.8
USB30_TX-_TYPEC2: C2770.1 CN14.B3 RV1.4 RV1.7
USB30_TX-_TYPEC2_C: C2770.2 U2034.11
USB_BC_ON: U7.4 U13.97
USB_CHARGE_ON: R234.1 U7.5 U13.96
USB_CLT1: U7.6 U13.79
USB_HUB_5V: TP2089.1 U2033.27
USB_OC0#: D8511.1(CATHODE) U7.13
USB_OC1#: D8512.1(CATHODE) U28.3
USB_OC2#: D8513.1(CATHODE) U35.3
USB_OCP_ALL#: D8511.2 D8512.2 D8513.2 R6650.2 U2030.AK10
USBON#: U13.99 U28.4 U35.4
USBP0+: R486.2 R77836.1
USBP0+_R: R77836.2 R77838.2 U2030.AE7
USBP0-: R489.2 R77837.1
USBP0-_R: R77837.2 R77839.2 U2030.AE6
USBP1+: R247.1 R252.1 U2030.AG10
USBP1+_C: R217.1 U7.10
USBP1+_C_R: R218.1 R252.2
USBP1+_C_R_N: CN5.3 R217.2 R218.2 U5.7
USBP1+_U14: R247.2 U7.3
USBP1-: R246.1 R251.1 U2030.AG9
USBP1-_C: R210.1 U7.11
USBP1-_C_R: R211.1 R251.2
USBP1-_C_R_N: CN5.2 R210.2 R211.2 U5.4
USBP1-_U14: R246.2 U7.2
USBP2+: R298.2 U2030.AF12
USBP2+_C: CN7.3 R298.1 U11.7
USBP2-: R293.2 U2030.AF11
USBP2-_C: CN7.2 R293.1 U11.4
USBP3+: CN9.3 U2030.AE10
USBP3-: CN9.5 U2030.AE9
USBP4+_DB: CN6.16 U2030.AD9
USBP4-_DB: CN6.15 U2030.AD8
USBP5+_CAM: R522.2 R77838.1
USBP5+_CAM_C: CN2.8 R522.1 R77848.1
USBP5+_CAM_HUB: R77848.2 U2033.7
USBP5-_CAM: R521.2 R77839.1
USBP5-_CAM_C: CN2.7 R521.1 R77849.1
USBP5-_CAM_HUB: R77849.2 U2033.6
USBP7+_FP: R77840.1 R77844.1
USBP7+_FP_APU: R77840.2 R77842.2 U2030.AJ12
USBP7+_FP_HUB: R77846.1 U2033.13
USBP7+_FP_R: CN13.7 EC6.2 R77844.2 R77846.2
USBP7-_FP: R77841.1 R77845.1
USBP7-_FP_APU: R77841.2 R77843.2 U2030.AJ11
USBP7-_FP_HUB: R77847.1 U2033.12
USBP7-_FP_R: CN13.6 EC7.1 R77845.2 R77847.2
USBP8+_TS: R520.2 U2033.4
USBP8-_TS: R519.2 U2033.3
USBP8_TS+_C: CN2.5 R520.1
USBP8_TS-_C: CN2.4 R519.1
USBP_TYPC+_C: CN14.A6 CN14.B6 R486.1 RV8.2
USBP_TYPC-_C: CN14.A7 CN14.B7 R489.1 RV9.2
USBPWRD2: C670.1 C671.2 C672.2 C673.2 C674.2 CN6.25 CN6.26 CN6.27 CN6.28 CN6.29 CN6.30 U35.1(OUT)
VA: PC8.1 PC14.1 PC143.1 PC145.1 PD2.1 PD4.2 PJ6.1 PQ3.5 PR71.1 PR245.1
VA2: PC6.1 PQ3.1 PQ3.2 PQ3.3(S3) PQ4.1 PQ4.2 PQ4.3(S3) PR248.1
