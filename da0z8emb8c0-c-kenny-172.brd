# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Nets (continued)
VADJ1: C61.1 CN2.27 R26.2 R27.1
VGA_AC_BATT: D8001.2 R8103.2 R8104.1 R8107.2 U2029.AA34
VGA_ALERT: R8069.2 TP8529.1 U2029.R37
VGA_RSTB: R2444.1 R8134.2
VGPU_CORE_PG: PR9043.2 PR9046.2 PR9118.1 U8023.1
VGPU_CORE_SENSE: PR9055.1 U2029.AR13
VL: PR117.1 PR191.1
VMON: R6521.2 R6527.2 U2034.17(VMON)
VQQD_VPPSNS: PR123.2 PU1.12
VREF_PINSET_CPU: PR6004.1 PR6011.1 PR6019.1 PR6058.1 PR6059.1 PR6060.1 PR6062.2 PR6063.1 PU6000.15
VREF_PINSET_GPU: PR9004.1 PR9008.1 PR9014.1 PR9056.2 PR9057.1 PR9058.1 PR9060.2 PR9061.1 PU9000.15
VREFC_A0: C2216.2 R2236.2 R2237.2 VRAM2001.J14
VREFC_A1: C2673.2 R2680.2 R2681.2 VRAM2002.J14
VREFD1_A0: C2658.2 R2641.2 R2642.2 VRAM2001.A10
VREFD1_A1: C2671.2 R2674.2 R2675.2 VRAM2002.A10
VREFD2_A0: C2662.2 R2654.2 R2655.2 VRAM2001.U10
VREFD2_A1: C2672.2 R2677.2 R2678.2 VRAM2002.U10
VRM_PWRGD: D8.1(CATHODE) D2025.2 PR6048.2 PR6049.2 R128.2 R130.2 R131.1
VRON: PR6028.1 R459.1 U13.69
VSEN_CPU: PR6056.1 PU6000.8(VSEN)
VSTBY_FSPI: R331.2 R344.2 U13.106
VSYNC: R2213.2 R2220.2 U2029.W35
WCKA0_0: U2029.D33 VRAM2001.D4
WCKA0_1: U2029.A34 VRAM2001.P4
WCKA0B_0: U2029.E33 VRAM2001.D5
WCKA0B_1: U2029.B34 VRAM2001.P5
WCKA1_0: U2029.A22 VRAM2002.D4
WCKA1_1: U2029.A8 VRAM2002.P4
WCKA1B_0: U2029.B21 VRAM2002.D5
WCKA1B_1: U2029.B9 VRAM2002.P5
WEA0B: U2029.G29 VRAM2001.L12
WEA1B: U2029.D11 VRAM2002.G12
WIGIG_LED: CN9.6 TP83.1
WLAN_RST#: D6543.3(COMMON ANODE) R819.1 R77877.1
WLAN_RST#_R: CN9.52 R819.2
WLANPWR#: TP48.1 U13.35
WRST#: C435.1 D13.2 R399.1 U13.14(WRST#)
XIN: C2765.1 U2033.10 Y2005.1
XOUT: C2766.1 U2033.11(XOUT) Y2005.3
XTAL1: R16.2 U1.28
XTAL2: R15.1 U1.29
XTAL2_R: C32.1 R15.2 Y1.3
XTALIN: R2652.1 R77829.1 U2029.BA39
XTALOUT: R77830.2 TP9079.1 U2029.AY39
ZQ_A0: R2640.2 VRAM2001.J13(ZQ)
ZQ_A1: R2679.2 VRAM2002.J13(ZQ)
N06325: Q43.3 R798.1 R807.2 R820.2
N301427: C2185.1 R2222.1 R2223.1
N9111136: R2215.2 R2226.1
N9111150: R2216.2 R2231.1
N17002655: C629.2 U30.39
N17002661: C615.2 U30.37
N17002676: C622.1 U30.34
N17002678: C635.1 U30.19
N17002722: R338.2 R366.1 U30.48
N17002952: C659.1 U30.7
N17002968: R754.1 R772.1 R782.2 U30.11
N17002995: C660.1 R746.1 R756.1 U30.12
N17003129: C615.1 U30.35
N17003186: R695.1 U30.20
N17004316: D37.1(CATHODE) Q45.3
N17046941: PJ11.3 PR119.1
N17047007: PQ4.5 PR12.1 PR18.2
N17047009: PR261.2 PU12.20
N17047028: PR267.2 PU12.19
N17047083: PJ11.5 PR113.1
N17047087: PC91.1 PL11.2 PQ11.1 PQ11.2 PQ11.3(S3) PR108.1 PR266.1 PR270.1
N17047112: PC6.2 PC8.2 PQ3.4 PQ4.4 PR247.1
N17047335: PC249.1 PR268.2
N17047399: PC243.2 PR254.2
N17047425: PJ11.4 PR120.1
N17047601: PC91.2 PQ11.4 PR99.2
N17398787: PR80.1 PU12.5
N17424918: PR253.1 PU12.11
N17424920: PR255.1 PU12.12
N17424921: PR249.1 PU12.7
N17424925: PR251.1 PU12.9
N17424950: PR86.2 PR88.1 PU12.15
N17661815: PR250.1 PU12.8
N18867651: PC109.1 PC112.1 PR107.1 PU7.8
N18867812: PC78.1 PC81.1 PR87.1 PU6.8
N19521323: PQ12.3 PR83.1
N19521733: PQ12.2 PR82.2 PR92.1 PR96.1
N19549602: PQ13.2 PR118.2 PR121.1 PR122.1
N25369938: Q21.1(S) R437.1
N25369947: Q21.4 R450.1
N26277307: PC6016.1 PC6018.1 PR6000.2 PR6053.1 PR6055.2 PR6056.2
N26277311: PR6006.1 PR6011.2
N26277331: PR6009.2 PR6010.1
N26277333: PR6004.2 PR6005.1
N26277349: PR6007.1 PR6020.2 PR6021.2
N26277351: PR6007.2 PR6024.2
N26277353: PR6019.2 PR6020.1
N26277375: PC6019.1 PR6060.2
N26277377: PR6012.1 PR6013.1 PR6018.1
N26277386: PR6006.2 PR6012.2 PR6017.1
N26277388: PC6009.2 PR6033.2
N26277392: PR6063.2 PR6065.2 PR6066.1
N26277394: PR6059.2 PR6065.1
N26277398: PC6004.2 PR6014.2
N26277400: PC6013.2 PR6043.2
N26277406: PR6016.1 PR6017.2
N26277420: PR6021.1 PR6022.1 PR6025.1
N26277422: PC6008.1 PR6027.1 PR6029.2 PR6030.2
N26277961: PC6031.1 PR6067.2
N26277963: PC6047.1 PR6070.2
N26277967: PC6065.1 PR6073.2
N26418322: PC2006.1 PC2007.1 PC2008.1 PC2009.1 PC2010.1 PC2011.1 PC2012.1 PC2013.1 PJ2000.2 PL2000.2 PR2008.2
N26418350: PC2000.1 PC2001.1 PC2002.1 PC2003.1 PJ2001.2 PR2001.2 PU2000.8 PU2000.9 PU2000.22 PU2000.24
N26418727: PC2015.1 PR2007.2
N26418739: PC2005.2 PR2003.1
N26547647: PC9091.1 PQ9003.2 PQ9006.3 PR9132.2
N27032306: PC6003.1 PR6003.2 PU6000.28
N27032510: PR6057.1 PR6062.1
N27032514: PR6054.1 PR6057.2 PR6058.2
N27752748: R694.2 R695.2 R697.1
N28087213: C525.2 R8.1 R9.1 R10.1 R11.1
N28100067: CN12.8 R796.1
N30442036: PC103.1 PC105.1 PR111.2 PU6.13(VOUT1)
N30442060: PC93.1 PR93.1 PU6.4
N30442062: PC98.1 PU6.12
N30442063: PC92.1 PU6.10
N30442080: PC87.1 PR89.2 PU6.5
N30442084: PC99.1 PR100.1 PU6.3
N30568314: PC70.2 PR78.1 PR84.2 PU11.12
N30568326: PC70.1 PR72.1
N30568332: PC261.2 PC262.1 PC263.2 PC264.1 PC270.1 PJ9010.1 PU15.5
N30568337: PC221.2 PC233.1 PC239.1 PC244.2 PJ3.1 PU11.5
N30568424: PC272.2 PR274.1 PR275.2 PU15.9
N30568429: PC272.1 PR278.1
N30568472: PC266.1 PR117.2 PU15.12
N30568498: PQ13.3 PR279.1
N30568535: PR230.2 PR234.2 PR237.1 PR244.2
N31069510: PC106.1 PC108.1 PR110.2 PU7.13(VOUT1)
N31161958: PC251.1 PR260.1 PU7.4
N31161974: PC111.1 PU7.12
N31161976: PC110.1 PU7.10
N31162017: PC250.1 PR259.2 PU7.5
N31162025: PC252.1 PR257.1 PU7.3
N33761123: CN18.38 R498.2 R501.1
N33761125: CN18.50 R497.2
N33761127: CN18.68(SUSCLK) TP49.1
N36953746: C393.2 Q19.2 R418.2
N36954805: R464.2 U16.7
N36977514: Q44.3 Q47.2 R827.2
N37139396: D16.2 R423.1
N37139539: R400.2 U15.18
N37162665: L13.1 R313.1 R690.2
N37162929: R366.2 TP41.1
N37164012: C638.1 U30.16
N37164724: R699.1 R707.2
N38521997: CN10.1 D18.1 R430.1
N38680042: D34.1(CATHODE) D35.1(CATHODE) R699.2
N38680880: Q16.2 R365.1
N38756738: C387.2 R402.1 U13.82
N38756749: TP43.1 U13.87
N38756787: C367.2 R318.1 U13.98
N38756834: Q7.3 R622.1 SW3.3 SW3.4
N38757336: C371.1 R310.1 U13.128
N38757362: C480.2 R487.1 U13.66
N38757406: C112.1 Q7.2 R37.2 SW2.3 SW2.4
N38758998: C389.2 R419.1
N38759178: C388.1 U13.12
N39785725: HD1.1 R834.1 R835.1
N40550359: Q2038.2 Q2038.5 R8122.2 R8123.2
N43565507: D8001.1(CATHODE) R8103.1 R77851.2 R77852.1
N43700942: CN2.24 R517.2
N43737419: CN2.29 R516.2
N44885066: PD4.3(COMMON ANODE) PR81.2
N45198823: PC128.1 PC129.1 PL1.2 PR123.1 PR127.1
N45477665: C37.2 Q2.2 R14.2
N47284656: PC571.1 PC572.1 PJ7005.1 PU3004.3(VIN)
N47284687: PC561.1 PC562.1 PC563.1 PC9163.1 PJ7004.2 PL551.2 PR569.2
N47284767: PC551.2 PR551.2
N47673465: R2684.1 TP9078.1
N47751595: C2733.1 R2697.1 R2698.1
N47855937: C1104.1 U26.17
N47859573: R104.1 U26.16
N48031337: R6519.1 U2034.18
N48031368: C2782.1 R6523.1 U2034.13
N48041869: PC9003.1 PR9003.2 PU9000.28
N48041894: PC9017.1 PC9019.1 PR9050.1 PR9052.2 PR9053.2 PR9055.2
N48041922: PR9015.2 PR9020.2 PR9024.1
N48041929: PR9054.1 PR9060.1
N48041930: PR9051.1 PR9054.2 PR9056.1
N48041941: PR9015.1 PR9021.1 PR9025.1
N48041971: PR9013.1 PR9017.2 PR9018.1
N48041975: PR9009.1 PR9018.2 PR9019.1
N48041983: PR9061.2 PR9063.2 PR9064.1
N48042007: PC9008.1 PR9027.1 PR9028.2 PR77849.2
N48042043: PR9008.2 PR9017.1
N48042051: PR9007.2 PR9016.1
N48042052: PR9004.2 PR9005.1
N48042059: PR9023.2 PR9024.2
N48042060: PR9014.2 PR9020.1
N48042070: PC9000.1 PR9058.2
N48042075: PC9010.2 PR9031.2
N48042078: PR9057.2 PR9063.1
N48042080: PC9004.2 PR9010.2
N48042081: PC9014.2 PR9040.2
N48042082: PR9012.1 PR9013.2
N48043954: PC9031.1 PR9065.2
N48043955: PC9041.1 PR9068.2
N48044973: D8510.2 R2722.1
N48073638: PC164.1 PR191.2 PU9006.5(VCC)
N48073642: PR194.1 PU9006.1
N48073650: PR193.2 PU9006.3
N48075617: PC6230.1 PC6231.1 PC9132.1 PJ7002.2 PL14.2 PR6414.2
N48075627: PC9162.1 PR283.1 PR6418.2 PU3003.6
N48075629: PC9164.1 PR9282.2 PU3003.4(VIN)
N48075639: PC9162.2 PR6414.1 PR6418.1
N48075651: PC6229.2 PR6417.2 PU3003.1
N48075664: PR284.1 PU3003.5
N48076363: PQ7.3 PR9285.2
N48076395: PQ9013.3 PR102.2
N48076401: PQ35.3 PR216.2
N48076451: PQ10.3 PR9286.2
N48095830: PR9308.1 PR9309.1 PR9310.2
N48275487: C2789.2 Q2039.2 R6529.1
N48413383: R498.1 TP9075.1
N48413443: D6542.2 R6024.1
N48418356: D6543.2 R6642.1
N48419029: R6643.2 U1.21
N48419358: R6644.1 U2030.AG29
N48419681: Q5403.2 R6646.2
N48512543: R2444.2 U2030.AW15
N48547452: PQ9057.3 PR9311.2
N48626371: C2569.2 Q2030.2 R2431.2
N48632675: C96269.1 R67855.2 U5400.1(VCC)
N48632807: R67418.2 U5400.4
N48758638: PC9065.1 PC9067.1 PC9075.1 PC9080.1 PJ9007.1 PR9120.2 PU9005.8 PU9005.9 PU9005.22 PU9005.24
N48758645: PC9066.1 PC9069.1 PC9070.1 PC9071.1 PC9073.1 PC9076.1 PC9078.1 PC9079.1 PC9095.2 PJ9008.1 PL9005.2 PR9125.1
N48758839: PC9068.1 PR9123.2
N48758857: PC9072.2 PR9137.1
N48838408: PR159.1 PR160.1 PU9.7
N48838426: PR161.2 PR77847.1 PU9.1
N48839459: PQ9007.3 PQ9008.2 PR9128.2 PR9135.1
N48839476: PQ9008.3 PR9129.2
N48839503: PQ9007.2 PR77835.2
N48839793: PQ9062.2 PQ9063.3 PR77850.1 PR77852.2
N48839805: PQ9062.3 PR77851.2
N48839825: PQ9063.2 PR77853.2
N48842289: PQ9065.2 PQ9066.3 PR77854.1 PR77857.2
N48842319: PQ9065.3 PR77855.2
N48842333: PQ9066.2 PR77858.2
N48844867: PQ9067.2 PQ9068.3 PQ9069.2 PR77859.1 PR77861.2
N48844873: PQ9067.3 PR77860.2
N48844882: PQ9068.2 PR77862.2
N48844885: PQ9069.3 PR77863.2
N48959770: Q14.2 R131.2
N48963506: R77866.2 U23.3(O\C\)
N48964387: D8509.1(CATHODE) R12295.1 R77867.1
N48976098: PC9050.1 PR9071.2
N48976699: PC9189.1 PR9106.1 PR9108.1
N48977175: PR9101.2 PR9102.2 PU9000.24
N475840780: TP46.1 U13.48
N4709329327: CN2019.162 TP2024.1
N4709329328: CN2019.165 TP2023.1

Pads without a net: CN2 38; CN4 13 14; CN9 8 9 10 11 12 14 15 16 17 20 21 22 23 32 34 36 38 40 42 44 46 48 59 61 65 67 71 73; CN13 1 2 3 4; CN16 3; CN17 5; CN18 6 8 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; CN2019 87 88 91 92 95 96 97 100 101 104 105 166; CN2020 3 4; HOLE24 1; HOLE25 1; NOREF#3 1; NOREF#4 1; NOREF#5 1; NOREF#7 1; NOREF#8 1; NOREF#9 1; PQ6001 2; PQ6002 2; PQ9000 2; PQ9001 2; PU9 5; PU2000 7; PU3004 5; PU9005 7; PU9007 5; U7 9; U15 2 3 5 6 7 9 10 11 12 13 14 15 25 26 27 28 29 30 31 32; U16 2 3; U26 20; U30 14 15 23 24; U2029 AA2 AA4 AA7 AA8 AB1 AB2 AC1 AC2 AC4 AC5 AC8 AD1 AD2 AE2 AE4 AE7 AE8 AE34 AE37 AE38 AF1 AF2 AG1 AG2 AG4 AG5 AG8 AG34 AG37 AG38 AH1 AH2 AH40 AH41 AJ2 AJ4 AJ7 AJ8 AJ37 AJ38 AJ40 AJ41 AK1 AK2 AK40 AK41 AL1 AL2 AL4 AL5 AL8 AL37 AL38 AL40 AL41 AM1 AM2 AM11 AM19 AM21 AN2 AN4 AN5 AN8 AN34 AP1 AP2 AP11 AP19 AP21 AP23 AP29 AP31 AR1 AR2 AR4 AR5 AR23 AR29 AT1 AT2 AU2 AU4 AU7 AU11 AU19 AU27 AV1 AV2 AV7 AV9 AV11 AV19 AV23 AV27 AW1 AW2 AY3 AY4 AY5 AY6 AY7 AY8 AY10 AY11 AY14 AY15 AY16 AY18 AY19 AY20 AY21 AY22 AY24 AY25 AY26 AY27 AY28 AY30 AY31 AY32 AY33 AY34 AY35 AY36 BA3 BA4 BA6 BA7 BA8 BA10 BA11 BA14 BA15 BA16 BA18 BA19 BA20 BA21 BA22 BA24 BA25 BA26 BA27 BA28 BA30 BA31 BA32 BA33 BA34 BA35 BA36 C1 C2 D1 D2 E2 E11 F1 F2 G1 G2 G4 G5 H1 H2 H29 J2 J4 J7 J8 K1 K2 K41 L1 L2 L4 L5 L8 M1 M2 N2 N4 N7 N8 N34 N35 N38 P1 P2 R1 R2 R4 R5 R8 R10 R34 R40 R41 T1 T2 T40 T41 U2 U4 U7 U8 U34 U40 U41 V1 V2 V40 V41 W1 W2 W4 W5 W8 Y1 Y2; U2030 A11 A13 A15 A18 AA3 AA6 AA8 AA9 AA11 AA12 AB2 AB4 AC1 AC3 AC6 AC7 AC9 AC10 AC29 AD3 AD6 AD11 AD12 AD29 AD31 AE1 AE3 AE30 AE32 AF2 AF3 AF4 AF6 AF8 AF9 AF29 AF30 AF31 AH2 AH4 AJ2 AJ3 AJ4 AJ6 AJ24 AJ29 AK1 AK3 AK6 AK7 AK23 AK27 AL3 AL6 AL11 AL29 AM6 AM7 AM29 AM30 AM31 AM32 AN3 AN8 AN9 AN16 AN29 AN31 AP1 AP2 AP4 AP6 AR6 AR13 AT13 AU12 AU14 AW8 AW12 B10 B11 B12 B13 B15 B16 B17 B18 B20 BA6 C11 C12 C13 C14 C15 C16 C18 C19 D10 D11 D12 D13 D15 D17 F7 F8 F10 F12 F13 F14 G3 G6 G8 H1 H2 H3 H4 H6 H7 H10 H12 J2 J4 J10 J11 J12 J13 J20 K2 K3 K4 K6 K8 K11 K13 K20 L16 M3 M6 M13 M14 M16 M29 M30 M31 N29 N30 N31 N32 P6 P22 P29 P30 P31 R26 R27 R32 T3 T6 T11 T12 T24 T25 T27 T29 T30 U31 V9 V10 V23 V24 V26 V27 V32 W6 W8 W9 W11 W12 W21 W22 W25 W27 Y6 Y7 Y9 Y10 Y21 Y27; U2031 A1 A2 A7 A8 A9 A10 A11 A12 A13 A14 B1 B7 B8 B9 B10 B11 B12 B13 B14 C1 C3 C5 C7 C8 C9 C10 C11 C12 C13 C14 D1 D2 D3 D4 D12 D13 D14 E1 E2 E3 E5 E8 E9 E10 E12 E13 E14 F1 F2 F3 F10 F12 F13 F14 G1 G2 G3 G10 G12 G13 G14 H1 H2 H3 H12 H13 H14 J1 J2 J3 J12 J13 J14 K1 K2 K3 K6 K7 K10 K12 K13 K14 L1 L2 L3 L12 L13 L14 M1 M2 M3 M7 M8 M9 M10 M11 M12 M13 M14 N1 N3 N6 N7 N8 N9 N10 N11 N12 N13 N14 P1 P2 P7 P8 P9 P10 P11 P12 P13 P14; U2039 1; U5400 6; VRAM2001 A5 U5; VRAM2002 A5 U5

## Via types
v1: diameter 0.457, hole 0.254, TOP to BOTTOM, 1107 vias
v2: diameter 0.508, hole 0.254, TOP to BOTTOM, 4528 vias
v3: diameter 0.61, hole 0.356, TOP to BOTTOM, 409 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.8V_PU9:
  vias: v2(108.27,85.2)
3.3V_PU9:
  vias: v2(118.93,83.81)
5V_HSMBCK: length 4.1
  TOP w0.102: D5.1 18.37,87.38 17.84,86.85 17.84,85.71 18.35,85.2 R163.1 v2(17.49,85.05)
5V_HSMBDT: length 1.6
  TOP w0.102: D5.2 19.25,86.08 19.39,85.94 19.39,85.48 19.24,85.33 R164.1
+0.95V:
  vias: v1(94.04,49.49) v1(94.04,48.37) v1(94.14,47.61) v1(94.88,49.49) v1(94.91,48.37) v1(94.93,47.61) v2(94.42,48.88) v2(110.69,43.74) v2(111.33,43.75) v2(111.96,43.75) v2(116.01,44.82) v2(116.01,44.18) v2(116.01,43.55)
+0.95V_SENSE_REMOTE: length 0.9
  BOTTOM w0.203: PR2012.2 PR9295.1
+0.95VS5:
  vias: v1(92.11,49.14) v1(92.64,48.88) v2(100.65,38.09)
+0.95VS5_SENSE_REMOTE: length 21.2
  BOTTOM w0.152: PR2008.1 130.72,36.97 130.77,36.92 140.45,36.92 141.11,37.58 v2(143.06,37.58) 144.56,37.58 146.21,39.23 147,39.23 147.38,39.61 PC2014.2
  BOTTOM w0.203: PC2014.2 147.75,39.86 147.92,40.02 PR9298.1
  BOTTOM w0.254: PR2010.1 146.31,40.3 146.76,39.86 PC2014.2
+1.2V: length 2.7
  BOTTOM w0.102: PQ9056.1 68.51,81.65 v2(68.77,81.39)
  BOTTOM w0.508: PQ9056.1 PR9311.1
+1.2VSUS: length 216.4
  TOP w0.178: U2013.J1 39.56,40.39 39.56,39.92 U2013.J2 39.33,39.36 39.33,38.52 v1(39.05,38.24)
  TOP w0.203: C2418.2 44.61,42.81 44.95,42.47 v2(45.28,42.47) 45.18,42.57 C2431.1 45.18,45.38 U2014.B9 ; U2014.L9 39.18,44.47 C2683.1 C2699.1 v2(40.57,43.65) ; v2(43.62,31.61) 43.47,31.45 C2697.1 ; C2718.2 32.67,75.27 33.34,75.93 34.52,75.93 U2017.R1 ; v2(41.73,80.11) 42.35,79.48 C2350.2 ; v2(51.62,68.31) 51.65,68.28 R2290.1 ; v2(41.16,54.49) 41.13,54.52 41.13,54.55 40.86,54.82 C2710.1 ; EC2007.1 51.85,70.25 52.01,70.08 C2391.2 ; C2380.1 38.64,31.33 v2(38.92,31.61) 39.21,31.33 C2688.2 ; R2683.2 v2(32.07,77.96) C2685.2 ; v2(29.66,70.68) 30.13,70.21 C2381.1 ; C2679.1 42.32,54.9 v2(42.73,54.49) 42.89,54.65 C2682.1 ; C2695.1 44.92,54.78 v2(44.64,54.49) 44.36,54.78 C2701.2 ; C2687.2 31.15,41.13 v2(31.35,41.34) ; v1(34.14,56.66) 34.58,56.22 C2352.1 ; U2014.T9 33.95,45.35 31.79,45.35 31.68,45.25 31.13,45.25 30.8,45.58 C2412.1 30.64,45.99 30.41,46.21 C2410.1 ; v2(32.19,33.26) 31.91,32.98 C2696.1 ; v2(31.68,33.77) 31.59,33.67 C2698.1 ; v2(31.63,53.96) 30.87,53.96 30.67,53.76 C2703.2 31.08,53.42 31.69,52.82 34.03,52.82 U2014.R1 ; R2284.2 47.69,62.98
  TOP w0.254: C2381.1 30.13,69.8 30.87,69.07 34.07,69.07 U2017.T9 ; C2718.2 29.93,75.27 v2(29.91,75.29) ; U2018.T9 32.96,80.51 32.95,80.5 v2(32.93,80.5) ; U2014.F8 v2(41.73,45.93) ; U2014.G9 v2(41.73,45.13)
  TOP w0.305: v2(40.13,33.75) U2013.J9 ; U2017.A9 v2(46.53,68.73) ; v2(38.16,79.97) 38.13,80.01 U2018.L9 ; U2018.J8 39.72,81.31 39.32,80.91 v2(39.32,80.9) 39.32,80.89 39.71,80.51 U2018.J9 ; U2018.R1 34.53,86.51 v2(34.52,86.51) ; v2(37.73,33.7) 37.73,33.75 U2013.L9
  TOP w0.356: v2(45.74,85.71) 45.73,85.71 U2018.B3 ; U2017.J8 v2(39.33,69.53) ; U2018.F2 42.53,86.51 v2(42.51,86.53) ; U2013.B9 44.93,33.76 v2(44.93,33.75) ; U2014.C1 44.52,51.93 v2(44.13,52.33) ; v2(45.74,74.33) 45.73,74.33 U2017.B3 ; U2013.D1 44.12,40.16 v2(44.12,40.14) 44.53,40.55 U2013.C1 ; U2018.A1 46.51,87.29 v2(46.54,87.31) ; v2(41.73,68.7) 41.73,68.72 41.33,69.12 U2017.G9 ; U2014.J8 v2(40.13,45.93) ; v2(42.53,50.72) 42.51,50.72 42.13,51.11 U2014.F2 ; U2013.F8 v2(41.73,34.55) ; v2(40.95,68.01) 40.56,68.01 39.92,68.65 39.92,68.93 U2017.J9 ; U2017.J2 39.92,74.93 39.92,75.33 U2017.J1 40.85,76.65 41.15,76.65 v2(41.34,76.84) ; v2(41.73,69.5) 41.73,69.53 U2017.F8 ; U2013.D9 43.33,33.75 v2(43.3,33.75) ; U2018.F8 v2(41.73,80.91) ; v2(46.62,39.33) 46.62,40.06 U2013.A1 ; U2014.A9 45.72,45.93 ; 45.72,45.93 45.72,45.92 U2014.B9 ; 45.72,45.93 v2(45.72,45.95) ; v2(45.73,33.75) 46.13,34.15 U2013.A9 ; v2(31.35,41.34) 34.14,41.34 U2013.R1 ; U2017.A1 46.51,75.92 v2(46.54,75.93) ; U2017.D1 44.11,75.92 v2(44.11,75.93) ; v2(41.73,70.3) 41.33,70.7 U2017.G7 ; U2014.A1 v2(46.53,51.53) ; v2(42.53,75.13) 42.53,75.13 U2017.F2 ; U2018.J1 v2(39.33,86.51) U2018.J2 ; v2(44.91,75.93) 44.91,75.92 U2017.C1 ; U2014.B3 v2(45.73,50.73) ; v2(41.16,54.49) 40.63,53.96 39.81,53.96 38.13,52.27 U2014.L1 ; v2(41.71,87.33) 41.71,87.29 U2018.G1 ; U2013.B3 46.04,38.24 v2(46.04,37.83) ; U2014.D1 v2(43.33,52.33) ; v2(42.03,53.31) 41.5,52.78 40.58,52.78 U2014.J1 39.74,51.93 39.99,51.67 39.99,51.39 U2014.J2 ; v2(31.68,33.77) 31.81,33.9 33.87,33.9 U2013.T9 ; v2(44.13,80.07) 43.73,80.47 U2018.D9 ; U2017.D9 v2(44.13,68.73) ; U2018.G7 v2(41.73,81.71) ; U2013.F2 42.13,39.76 41.73,40.15 v2(41.73,40.19) 41.69,40.19 U2013.G1 ; v2(37.74,86.52) U2018.L1 ; U2018.B9 45.33,80.47 v2(45.73,80.07) 46.13,80.47 U2018.A9 ; v2(40.18,41.76) 39.33,41.76 U2013.L1 ; v2(40.13,45.13) U2014.J9 ; U2013.G9 v2(41.73,33.75) ; U2018.G9 v2(41.73,80.11) ; v2(44.91,87.31) 44.91,87.29 U2018.C1 ; v2(39.26,67.99) 39.14,67.99 38.13,69 U2017.L9 ; v2(44.11,87.31) 44.11,87.29 U2018.D1 ; U2014.G1 v2(41.73,51.53) ; U2017.G1 v2(40.93,75.93) ; U2014.G7 v2(41.73,47.53) ; U2017.L1 38.53,75.93 v2(38.56,75.93) ; v2(45.73,68.73) 45.72,68.73 U2017.B9 ; U2013.G7 v2(40.93,35.35) ; v2(43.78,44.97) 43.73,45.02 U2014.D9 ; U2013.J8 v2(40.13,34.55)
  TOP w0.381: C2379.2 51.52,67.04 v2(51.53,67.03) ; C2501.1 C2393.2 v2(53.66,68.19) ; C2387.2 C2392.1 v1(51.62,60.82) ; v1(54.04,54.47) 54.04,53.96 54.42,53.58 C2406.1 ; C2396.2 51.88,56.88 51.55,56.55 v1(51.55,55.94) ; C2410.1 29.64,46.46 v2(29.5,46.6) ; v2(51.62,68.31) C2376.2 ; C2377.1 53.9,60.07 53.55,60.41 v1(53.55,60.82) ; C2389.2 v2(53.02,53.33) ; C2394.2 v1(56.96,60.82) ; v2(44.26,31.61) 44.25,31.6 C2434.1 ; C2391.2 52.39,69.5 v2(52.35,69.46) ; C2388.1 50.9,65.37 51.57,65.37 v1(51.61,65.41)
  BOTTOM w0.203: R6644.2 v2(72.96,53.2) ; v1(78.93,55.61) 79.21,55.89 U2030.AD32 ; U2030.W32 78.56,60.01 v2(78.42,60.15)
  BOTTOM w0.229: v2(78.62,52.06) 79.16,52.06 U2030.AJ32
  BOTTOM w0.254: CN2019.154 51.53,55.96 v1(51.55,55.94) ; CN2019.136 49.07,62.46 48.83,62.22 ; CN2019.123 57.28,65.71 57.09,65.9 55.87,65.9 54.7,67.07 v2(54.67,67.07) ; v1(60.39,54.47) 60.39,54.34 59.75,53.71 CN2019.163 ; v1(51.61,65.41) 51.6,65.41 51.56,65.46 CN2019.124 ; CN2019.141 57.34,61.21 v1(56.96,60.82) ; CN2019.112 51.48,68.46 v2(51.62,68.31) ; U2030.AC25 82.89,56.59 v1(82.89,56.54) 82.89,56.39 U2030.AD26 ; U2030.AA32 78.52,58.01 v2(78.5,58.03) ; v2(78.55,62.22) 79.05,62.01 U2030.T32 ; v2(53.02,53.33) 51.89,54.46 CN2019.160 ; U2030.AF32 78.5,54.72 v2(77.92,54.72) ; v1(56.32,63.57) 56.32,63.7 56.83,64.21 CN2019.129 ; U2030.AL32 78.91,49.71 78.62,49.71 78.44,49.54 v2(78.42,49.54) ; CN2019.111 59.49,68.71 59.88,68.31 v2(59.88,68.08) ; CN2019.135 59.49,62.71 v2(59.75,62.44) ; v1(57.08,55.96) 57.33,56.21 CN2019.153 ; CN2019.147 57.21,57.71 57.2,57.72 56.58,57.72 v1(56.08,58.22) ; 48.79,57.46 CN2019.148 52.05,57.46 v1(53.52,55.99) ; U2030.AJ20 87.38,51.81 v1(87.24,51.95) ; CN2019.117 57.13,67.21 56.37,67.96 v2(56.37,68.08) ; CN2019.130 51.98,63.96 v1(52.41,63.53) ; CN2019.142 51.49,60.96 v1(51.62,60.82) ; v2(51.53,67.03) 51.45,66.96 CN2019.118 ; CN2019.159 59.52,54.71 v1(59.75,54.47)
  BOTTOM w0.305: v1(87.25,57.75) U2030.AA20 ; U2030.Y28 81.61,59.51 v1(82.21,59.51) ; v1(82.82,58.54) 82.82,58.39 82.51,58.09 U2030.AA26 ; U2030.AD23 84.91,55.94 v1(85.3,55.55) ; v1(87.3,56.25) 87.4,56.25 87.71,56.56 U2030.AC20 ; U2030.AA23 84.92,58.01 v1(85.41,57.53) 85.41,57.39 85.71,57.08 U2030.AC22 ; U2030.Y22 85.69,59.01 v1(85.23,59.47) ; v1(87.34,54.61) 87.71,54.98 U2030.AE20 ; U2030.AC28 80.91,56.81 v1(80.91,56.56) 80.91,56.21 U2030.AD28 U2030.AE28 81.11,54.98 80.91,54.78 80.91,54.59 80.91,54.59 v1(80.91,54.52) 80.91,54.39 81.11,54.19 U2030.AF28 80.99,53.88 80.99,53.13 U2030.AG28 80.91,52.81 v1(80.91,52.56) 80.91,52.21 U2030.AJ28 80.91,51.81 v1(80.91,51.51) 80.91,51.21 U2030.AK28 U2030.AL28 ; U2030.AA28 80.91,58.21 v1(80.91,58.56) ; v1(84.52,51.42) 84.52,51.54 84.91,51.93 U2030.AJ23 ; U2030.AE22 85.3,54.6 v1(85.3,54.56) 84.91,54.17 U2030.AF23 ; U2030.AG25 83.31,53 83.65,52.66 v1(83.65,52.56) ; U2030.V28 U2030.W28 v2(80.56,60.01) ; U2030.AG20 87.71,53.38 v1(87.34,53.01) ; v1(85.3,52.56) 85.71,52.97 U2030.AG22 ; v1(82.82,52.57) 82.82,52.31 U2030.AJ26 ; v1(82.31,53.51) 82.31,53.8 U2030.AF26 ; v1(82.81,59.51) 82.83,59.51 83.31,59.03 U2030.Y25 ; v1(83.71,54.56) 83.31,54.95 U2030.AE25
  BOTTOM w0.508: PQ9056.3 64.26,83.36 61.78,80.89 v2(61.78,66.53)
  vias: v1(53.49,65.41) v1(53.74,63.53) v1(54.75,60.82) v1(55.81,55.96) v1(56.03,57.09) v1(56.07,65.41) v1(56.41,54.49) v2(40.09,66.79) v2(41.34,60.92) v2(41.84,63.59) v2(41.97,60.92) v2(42.61,63.59) v2(42.61,60.92) v2(42.73,64.88) v2(42.67,53.31) v2(43.24,66.41) v2(43.24,60.92) v2(43.3,53.31) v2(43.37,63.59) v2(43.94,53.31) v2(44,60.92) v2(44.13,67.91) v2(44.13,66.41) v2(44.13,63.59) v2(44.26,64.88) v2(44.51,67.04) v2(44.57,53.31) v2(44.75,90.47) v2(44.77,67.93) v2(44.77,60.92) v2(44.89,64.88) v2(44.89,63.59) v2(45.21,53.31) v2(45.27,67.04) v2(45.38,90.47) v2(45.53,64.88) v2(45.53,60.92) v2(45.65,67.91) v2(45.65,66.41) v2(46.02,90.47) v2(46.04,67.04) v2(46.16,64.88) v2(46.29,60.92) v2(46.42,67.91) v2(46.42,66.41) v2(46.65,90.47) v2(46.8,67.04) v2(47.05,60.92) v2(47.94,67.91) v2(47.94,66.79) v2(48.32,80.89) v2(48.32,80.07) v2(48.58,86.44) v2(48.58,85.62) v2(48.58,84.82) v2(48.6,44.94) v2(48.68,47.71) v2(48.7,46.19) v2(48.91,66.79) v2(48.96,80.89) v2(48.96,80.07) v2(48.96,53.33) v2(48.96,33.21) v2(52.89,67.02) v2(55.43,67.07) v2(61.66,50.91) v2(64.2,65.39) v2(65.59,50.91) v2(65.85,65.39) v2(67.12,65.39) v2(67.24,50.91) v2(68.64,50.91) v2(68.77,65.39) v2(70.04,65.39) v2(70.17,50.91) v2(70.93,50.91) v2(71.69,50.91) v2(72.45,50.91) v3(32.29,98.16) v3(32.29,97.4) v3(33.03,98.16) v3(33.03,97.4) v3(33.77,98.16) v3(33.77,97.4) v3(34.5,98.16) v3(34.5,97.4) v3(35.24,98.16) v3(35.24,97.4) v3(47.38,120.84) v3(47.38,120.1) v3(47.37,119.35) v3(48.14,120.84) v3(48.14,120.1) v3(48.14,119.35) v3(48.91,120.84) v3(48.91,120.1) v3(48.9,119.35) v3(53.34,119.23) v3(54.1,119.23) v3(54.87,119.23)
+1.5V: length 3.4
  TOP w0.381: R373.1 198.27,29.46 v2(198.54,29.2)
  IN3 w0.508: v2(198.54,18.99) 198.13,18.99 197.42,19.7 197.42,20.81
  vias: v2(199.07,18.15)
+1.05V_LAN: length 10.1
  TOP w0.203: U1.8 42.1,104 41.84,103.75 41.84,103.36 41.33,102.85 C93.1 ; U1.22 47.34,106 47.71,105.62 v2(47.94,105.62) ; C45.1 v2(43.11,109.2) C39.1 44.04,108.91 U1.30 ; U1.3 41.22,106 v2(40.75,105.53)
  TOP w0.381: C93.1 v2(41.33,101.74)
  BOTTOM w0.381: C64.1 v2(40.75,105.53)
  vias: v2(51.83,110.17) v2(51.82,109.46)
+1.5V_RTC: length 3.2
  TOP w0.508: 100.65,27.8 100.65,27.04 100.26,26.65 C2499.1 98.59,26.65 U2021.1
  vias: v2(100.77,28.18)
+1.8V: length 361.8
  TOP w0.152: U2031.P5 U2031.N4 ; U2031.N4 U2031.P3 ; U2031.N4 U2031.M4
  TOP w0.203: R2549.2 96.04,78.5 v1(95.49,78.5) ; R77869.2 112.17,18.28 111.49,17.6 v2(111.49,16.85) ; v1(67.24,30.85) 67.61,30.47 U2031.C6 ; U2031.P3 v1(69.11,36.37)
  TOP w0.381: v2(197.55,25.71) 197.41,25.85 R374.2 ; Q6565.5 109.66,16.88 v2(109.64,16.85) ; Q6565.2 111.52,16.88 v2(111.49,16.85)
  TOP w0.508: R2412.1 103.31,35.42 103.52,35.22 104.07,35.22 v1(106.03,33.26) 106.48,32.82 108.29,32.82 v2(108.69,32.41) 108.83,32.27 109.88,32.27 110.47,32.87 111.91,32.87 113.06,34.02 113.47,34.02 113.83,34.38 113.83,35.52 114.21,35.9 v2(114.57,35.9) ; v2(192.14,16.12) 192.72,16.7 192.72,19.54 193.1,19.93 v2(193.1,21.96)
  IN1 w0.508: 167.37,18.4 167.36,18.41 167.36,18.44 167.42,18.5 167.42,18.96 167.37,19.01 167.37,21.04 167.83,21.5 v2(167.83,21.88) ; 167.37,18.4 167.4,18.43 167.78,18.43 168.39,17.82 174.64,17.82 176.34,16.12 185.71,16.12 186.85,17.26 190.99,17.26 v2(192.14,16.12) ; 167.37,18.4 v1(167.36,18.39) ; v2(131.38,56.5) 131.86,56.98 139.51,56.98 140.11,56.37 142.56,56.37 143.57,55.36 144.33,55.36 144.71,55.74 150.18,55.74 150.81,56.37 150.81,59.5 v2(150.18,60.14) ; v2(193.1,21.96) 193.91,22.77 193.91,23.53 195.51,25.13 196.97,25.13 v2(197.55,25.71)
  IN2 w0.254: v1(106.03,33.26) 104.91,32.14 104.91,31.33 103.34,29.75 99.3,29.75 v2(98.18,28.64)
  IN2 w0.381: v2(80.29,91.76) 80.29,88.81 88.42,80.68 88.42,79.11 88.8,78.73 89.32,78.73 v2(89.84,78.2)
  IN2 w0.508: v2(89.84,78.2) 91.1,78.2 91.4,78.5 93.09,78.5 v2(93.17,78.57) 93.19,78.57 93.23,78.54 94.21,78.54 v1(94.27,78.6) 94.38,78.48 95.48,78.48 ; 95.48,78.48 95.83,78.48 96.2,78.85 96.2,79.41 96.94,80.15 105.45,80.15 106.68,78.91 v2(108.76,78.91) ; 95.48,78.48 v1(95.49,78.5) ; v2(111.16,75.14) 111.21,75.2 112.05,75.2 114.74,72.5 126.93,72.5 129.28,70.15 129.28,64.82 131.25,62.85 131.25,57.39 131.38,57.26 v2(131.38,56.5) 131,56.5 129.73,57.77 127.95,57.77 122.12,51.94 120.83,51.94 120.5,51.61 120.5,50.32 120.08,49.9 117.41,49.9 115.76,48.25 115.12,48.25 v2(111.57,44.69) 111.82,44.44 112.58,44.44 114.57,42.45 v2(114.57,35.9) ; 136.08,21.2 144.97,21.2 145.98,20.18 148.67,20.18 151.75,17.11 166.38,17.11 167.12,17.84 ; v2(197.55,25.71) 197.67,25.84 197.67,29.45 198.05,29.83 198.05,31.61 v2(199.45,33.01)
  IN3 w0.381: v2(193.1,21.96) 197.57,17.49 197.57,16.98 198.52,16.03 203.85,16.03 205.08,17.26 v2(205.42,17.26)
  IN3 w0.508: v2(108.76,78.91) 110.26,77.41 110.26,75.62 110.73,75.14 v2(111.16,75.14) ; v2(108.69,32.41) 108.69,31.48 107.43,30.21 107.43,29.84 105.52,27.94 105.52,23.91 102.3,20.69 100.77,20.69 98.23,18.15 v2(98.23,17.13)
  BOTTOM w0.203: v1(94.27,78.6) 94.71,78.16 R2513.2 ; v1(95.49,78.5) 95.72,78.27 R2512.2 ; C148.1 69.01,35.29 68.84,35.11 68.17,35.11 67.63,34.57 67.63,34.02 67.4,33.8 R2714.1 67.4,33.16 66.96,32.72 C150.1 66.96,31.12 v1(67.24,30.85) ; R2520.2 89.61,78.26 89.79,78.26 v2(89.84,78.2) 89.91,78.13 89.91,77.9 90.26,77.55 R2543.2 R2545.2 ; R2511.2 R2544.2 ; R2544.2 93.12,78.45 93.17,78.49 v2(93.17,78.57) ; R2544.2 R2551.2 ; v2(150.18,60.14) 150.94,59.38 150.94,57.77 151.06,57.64 PR2033.1 ; R2306.1 105.65,33.44 105.83,33.26 v1(106.03,33.26)
  BOTTOM w0.254: v2(98.18,28.64) 96.38,28.64 96.05,28.97 94.86,28.97 94.43,29.39 R77880.1
  BOTTOM w0.381: v2(167.83,21.88) 168.17,22.23 R794.1 ; v1(69.11,36.37) 69.01,36.27 C148.1 65.59,35.67 62.04,32.12 62.04,25.39 61.53,24.88 61.53,20.66 59.14,18.27 57.87,18.27 57.47,17.87 v2(57.47,17.64) ; v2(150.18,60.14) 149.93,59.89 148.49,59.89 147.95,59.36 PR6034.1 ; R2519.1 R2538.1 111.52,44.64 v2(111.57,44.69) ; Q2032.5 115,39.23 115.17,39.4 115.99,39.4 116.27,39.13 116.27,37.86 115.94,37.53 115.25,37.53 115,37.27 Q2032.2 115,36.33 v2(114.57,35.9) ; v2(205.42,17.26) 205.55,17.39 R313.2 ; Q2033.2 v2(108.76,78.91)
  BOTTOM w0.508: PR9285.1 81.08,90.8 80.71,91.17 80.71,91.34 v2(80.29,91.76) ; v2(193.1,21.96) 193.58,22.44 195.16,22.44 195.84,21.76 Q45.2
  vias: v2(15.17,22.21) v2(15.51,21.65) v2(15.84,22.21) v2(25.59,24.5) v2(26.22,24.5) v2(26.48,23.1) v2(26.48,22.47) v2(72.83,15.48) v2(73.47,15.48) v2(74.1,15.48) v2(74.61,21.96) v2(74.74,15.48) v2(79.77,16.12) v2(79.79,15.48) v2(80.4,16.12) v2(80.43,15.48) v2(97.98,15.1) v2(98.61,15.1) v2(99.25,15.1) v3(24.75,32.29) v3(25.21,31.69) v3(25.56,31.02) v3(25.97,31.69) v3(134.58,21.2)
+1.8V_GFX: length 100.1
  TOP w0.203: v2(120.08,123.18) 119.85,122.95 R2216.1 ; R8046.1 120.84,124.14 v2(120.97,124.27) ; R2215.1 119.23,124.72 v2(119.24,124.7) ; R8047.1 v2(123.25,121.73)
  IN2 w0.381: v2(101.53,120.13) v2(101.53,121.02) 102.17,121.02 103.57,122.41 106.23,122.41 106.78,122.96 108.43,122.96 111.24,125.77 114.95,125.77 115.89,124.83 116.9,124.83
  IN3 w0.381: v2(71.97,122.09) 72.65,122.09 73.98,120.76 73.98,119.75 74.62,119.1 77.18,119.1 77.88,119.8 83.96,119.8 84.65,119.11 84.65,117.94 85.25,117.33 88.71,117.33 89.74,116.31 95.83,116.31 97.12,115.02 97.12,113.37 v2(97.75,112.74) 98.28,112.2 98.28,110.43 98.49,110.22 98.49,104.76 v2(97.85,104.13) 97.85,102.61 99.12,101.34 99.12,100.7 100.14,99.68 100.77,99.68 101.74,98.72 102.12,98.72 103.16,97.67 v2(103.97,97.67) v2(104.74,97.67)
  BOTTOM w0.203: R2670.1 94.2,96.6 95.3,95.5 v2(95.91,95.5) 95.91,96.04 95.34,96.6 R2672.1 ; v2(120.08,123.18) 120.08,121.65 119.7,121.27 R2613.1 ; C96272.1 102.8,121.41 102.83,121.37 FB104.2 ; PR9310.1 69.6,120.81 70.07,121.28 71.52,121.28 71.79,121.55 71.79,121.91 v2(71.97,122.09) ; 101.63,119.29 101.9,119.01 R2650.2 ; R2615.1 121.32,119.85 122.57,121.09 v2(123.25,121.09) 124.62,119.73 R2616.1 ; R2610.1 117.26,119.75 v2(117.28,119.77) 117.31,119.75 R2611.1 ; R2614.1 119.92,119.75 v2(120.03,119.65) ; R2609.1 117.16,121.27 v2(117.28,121.4) 117.41,121.27 R2612.1
  BOTTOM w0.254: C2660.2 101.04,119.63
  BOTTOM w0.305: v2(71.97,122.09) 72.32,122.44 PR9032.1
  BOTTOM w0.381: 101.04,119.63 101.04,119.88 101.28,120.13 v2(101.53,120.13) 101.63,120.04 101.63,119.29 ; v2(101.53,121.02) 101.53,121.14 101.8,121.41 C96272.1 ; v2(97.75,112.74) 97.48,112.46 R77822.1 97.15,112.45 R77825.1 ; R77819.1 97.34,104.63 v2(97.85,104.13) 97.34,103.62 R77817.1
  vias: v2(104.71,100.19) v2(104.76,100.93) v2(105.5,100.93) v2(105.6,97.65) v2(106.59,100.27) v3(108.65,89.62) v3(109.41,89.62)
+1.8V_GFX_PG: length 76.4
  TOP w0.102: PR9105.1 89.09,117.21 v2(89.47,117.59)
  IN3 w0.089: v2(89.26,122.69) 89.47,122.9 91.64,122.9 92.28,122.26 92.28,117.73 92.01,117.46 90.61,117.46 90.49,117.59 v2(89.47,117.59) 89.47,117.08 89.91,116.64 95.97,116.64 98.68,113.94 98.68,110.83 98.94,110.56 98.94,103.1 100.72,101.32 100.72,100.32 101.98,99.05 102.37,99.05 103.27,98.16 104.89,98.16 105.2,97.85 105.2,97.48 105.52,97.16 105.52,94.83 105.93,94.42 105.93,94.03 107.33,92.64 110.08,92.64 113.45,89.27 113.45,88.86 v2(113.94,88.38)
  BOTTOM w0.102: v2(89.26,122.69) 88.93,122.36 87.62,122.36 87.3,122.67 77.66,122.67 76.75,123.58 74.51,123.58 74.23,123.3 PR9029.1
  BOTTOM w0.381: PR161.1 v2(113.94,88.38)
+1.8V_S5: length 125.8
  TOP w0.203: v2(177.18,31.84) 176.95,31.61 R331.1 ; U8022.5 C8165.1 ; C8165.1 117.67,46.98 118.12,47.43 R568.1 ; C8165.1 117.67,46.54 118.12,46.09 R569.1 119.11,45.83 v1(119.75,46.47)
  TOP w0.508: R773.1 32.57,21.7 30.12,24.15 29.88,24.15
  IN1 w0.381: v2(111.56,42.28) 112.58,43.3 112.58,44.31 112.44,44.45 112.44,48.59 111.29,49.74 v1(111.29,49.82)
  IN1 w0.508: v2(119.77,50.79) 119.06,50.07 119.06,47.1 119.7,46.47 v1(119.75,46.47) 119.75,45.25 119.14,44.64 119.14,41.18 119.44,40.88 v2(119.75,40.88)
  IN2 w0.508: v2(119.77,50.79) 116.9,50.79 116.27,51.42 111.82,51.42 111.29,50.89 v1(111.29,49.82)
  IN3 w0.508: v2(160.01,20.31) 160.02,20.3 160.02,20.12 158.81,18.91 158.81,18.02 158.09,17.3 147.48,17.3 146.09,18.69 136.53,18.69 v2(135.29,19.93) ; v2(119.75,40.88) 119.72,40.88 117.31,38.47 117.31,34.81 116,33.5 115.67,33.5
  BOTTOM w0.203: R12314.1 111.17,50.81 111.22,50.76 R12313.1 111.22,49.89 v1(111.29,49.82) 111.67,49.44 R626.1 ; R554.1 120.41,50.15 v2(119.77,50.79) ; R2445.2 103.21,35.17 103.31,35.07 R2427.2 103.69,34.91 103.47,34.69 R77857.2 103.47,33.99 104.05,33.41 v1(104.36,33.41) 104.38,33.41 104.38,33.42 R2307.2 ; v2(111.56,42.28) 111.44,42.28 111.14,42.58 R129.1 ; R77870.2 119.92,25.79 v2(119.79,25.91) ; R6544.1 v2(92.26,27.55) 92.22,27.5 R2400.2 91.27,27.32 91.12,27.16 90.1,27.16 89.85,26.91 89.85,23.86 90.23,23.48 92.01,23.48 92.26,23.23 R6550.1 ; R2425.2 101.56,34.77 v1(101.73,34.61)
  BOTTOM w0.508: v2(119.77,50.79) 119.77,50.86 118.96,51.68 CN2021.1 ; v2(119.75,40.88) 119.11,40.25 117.92,40.25 ; v2(160.01,20.31) 160.01,20.53 160.42,20.94 160.75,20.94 161.6,21.79 162.39,21.79 164.33,23.74 R803.1 164.34,25.15 166.19,27 166.19,27.6 168.81,30.21 173.92,30.21 174.31,30.59 174.31,31.1 174.86,31.66 177,31.66 v2(177.18,31.84)
  vias: v1(104.33,32.83) v2(28.26,30.34) v2(85.33,27.77) v2(85.33,27.14) v2(114.47,34.28) v2(114.48,33.65) v2(117.16,25.91) v2(117.79,25.91) v3(29.14,30.95) v3(29.14,30.21) v3(29.14,29.45) v3(29.91,30.97) v3(29.91,30.21) v3(29.91,29.45)
+1.8V_S5_1V8: length 1.7
  BOTTOM w0.203: R2308.1 105.85,34.66 105.65,34.45 R2306.2 105.32,34.12 105.06,33.87 R2307.1
+1.8V_SW: length 20.1
  TOP w0.203: U2032.3 v2(29.02,16.45)
  IN3 w0.508: v2(13.78,20.56) 13.96,20.38 15.89,20.38 18.73,17.54 23.39,17.54 23.56,17.7 25.02,17.7 v2(25.72,17) 26.15,17 26.91,16.24 28.81,16.24 v2(29.02,16.45) 30.24,16.45 30.67,16.88 v2(30.67,17)
  vias: v2(31.43,16.5)
+1.8V_TPM: length 13.3
  TOP w0.203: R411.2 v2(120.36,21.55)
  IN2 w0.508: v2(120.36,21.55) 122.04,23.23 v2(122.62,23.23) 123.63,23.23 124.42,22.44 128.87,22.44 v2(129.35,21.96)
  BOTTOM w0.508: v2(120.99,19.34) 120.92,19.41 120.92,20.99 v2(120.36,21.55)
+1.35V_GFX: length 41.3
  TOP w0.203: C2321.1 134.22,93.59 v2(134.39,93.42) ; C2259.1 134.4,104.48 134.77,104.85 v2(135.21,104.85) 135.21,104.66 135.06,104.5 C2260.1 ; R2641.1 148.52,113.02 148.4,113.14 147.76,113.14 147.51,112.89 146.87,112.89 ; v2(109.28,97.32) 109.43,97.17 C2305.1 ; C2227.1 v2(132.78,119.11) ; v2(133.47,105.03) 133.47,104.82 133.28,104.63 C2231.1 ; C2298.1 112.5,97.3 v2(112.48,97.32) ; C2263.1 118.96,104.99 118.53,105.42 v2(118.45,105.42) ; C2196.1 v2(134.81,119.11) ; C2304.1 108.21,97.17 v2(108.11,97.27) ; R2254.1 142.81,85.33 ; v2(111.49,97.27) 111.39,97.17 C2306.1 ; v2(118.17,110.1) 118.02,110.24 C2235.1 ; v2(118.41,107.63) 118.41,107.17 118.54,107.05 C2253.1 ; R2238.1 142.68,113.4 ; C2266.1 v2(133.64,119.09) ; R2239.1 142.68,112.64
  TOP w0.381: C2273.2 117.9,102.18 v2(117.82,102.09)
  TOP w0.508: PR77851.1 149.15,72.72 149.67,73.24 149.67,77.33 148.4,78.6 ; v2(118.17,110.1) 118.17,109.58 C2246.2 118.41,107.8 v2(118.41,107.63)
  BOTTOM w0.203: R2681.1 143.35,79.01 ; R2674.1 129.86,90.66 ; R2677.1 145.25,79.14
  BOTTOM w0.305: VRAM2002.P12 VRAM2002.P11 v2(143.98,86.19) VRAM2002.N10 ; VRAM2002.P3 v2(144.78,92.59) ; VRAM2001.B3 v2(146.38,106.98) ; VRAM2002.N5 v2(143.98,90.99) ; VRAM2002.R5 v2(145.57,90.21) ; VRAM2001.B12 v2(146.38,114.98) ; v2(109.28,97.32) 108.88,97.72 U2029.AG10 108.57,97.72 v2(108.11,97.27)
  BOTTOM w0.381: v2(117.61,98.84) 117.62,98.84 118,99.22 U2029.K13 ; v2(118.17,110.1) 118.17,109.39 U2029.K31 ; U2029.N10 116.83,97.29 v2(116.9,97.29) 117.07,97.29 U2029.L10 ; v2(118.3,97.65) 118,97.94 U2029.K11 ; U2029.W10 112.89,97.72 v2(112.48,97.32) ; U2029.K27 118.41,107.43 v2(118.41,107.63) ; U2029.K23 118,104.97 v2(118.45,105.42) ; v2(117.82,102.09) 118,102.28 U2029.K19 ; v2(111.49,97.27) 111.04,97.72 U2029.AC10
  vias: v2(135.24,112.54) v2(136.6,82.64) v2(136.85,112.51) v2(138.03,82.65) v2(138.36,87.11) v2(138.84,82.66) v2(141.58,114.18) v2(142.33,90.99) v2(142.37,107.79) v2(142.43,105.14) v2(142.41,94.31) v2(142.38,93.39) v2(142.36,82.81) v2(142.62,117.09) v2(142.56,98.68) v2(143.19,84.61) v2(143.98,114.18) v2(143.98,107.02) v2(144.06,109.68) v2(144.08,82.66) v2(144.24,88.55) v2(144.34,94.64) v2(144.78,112.29) v2(145.1,104) v2(145.61,109.41) v2(145.58,92.59) v2(145.58,84.59) v2(146.17,88.55) v2(146.38,110) v2(146.52,82.85) v2(146.98,95.23) v2(147,78.85) v2(147.31,114.94) v2(147.51,100.19) v2(147.51,99.55) v2(147.51,98.92) v2(148.14,100.19) v2(148.14,99.55) v2(148.14,98.92) v3(136.59,80) v3(136.59,79.23) v3(137.35,80) v3(137.35,79.23) v3(138.11,80) v3(138.11,79.23)
+1V_S5_ON: length 1.6
  TOP w0.102: TP9087.1 182.32,27.76 U13.95
+2.5V_SUS: length 214
  TOP w0.254: U2018.R9 34.29,79.87 ; 34.21,68.41 U2017.R9 ; 34.21,44.81 U2014.R9
  TOP w0.356: 47.69,53.45 47.69,54.85 47.31,55.23 C2692.2 46.93,54.73 45.91,53.71 45.91,52.51 U2014.B1 ; 47.29,89.71 46.35,89.71 45.45,88.81 45.45,87.03 U2018.B1 ; U2013.R9 34.93,33.92 34.72,33.71 ; 47.43,41.77 45.91,41.77 45.65,41.52 45.65,40.88 45.33,40.55 U2013.B1
  TOP w0.381: C2706.2 46.92,76.62 46.77,76.47 46.27,76.47 U2017.B1
  TOP w0.508: 34.72,33.71 32.81,31.8 C2416.2 33.11,30.87 33.7,30.28 ; 34.29,79.87 33.23,79.87 32.09,78.73 C2351.2 29.28,78.73 29.27,78.73 v2(29.25,78.73) ; v2(29.02,43.78) 29.17,43.93 30.1,43.93 30.41,44.24 C2448.2 34.05,44.65 34.21,44.81 ; v2(29.65,66.8) 29.9,66.8 30.41,67.31 C2403.2 32.56,68.27 32.7,68.41 34.21,68.41 ; C2706.2 46.92,78.15
  TOP w1.016: 49.85,90.28 49.85,92.7 48.83,93.71 v2(46.8,93.71) v2(45.65,93.71) ; 47.64,89.31 47.69,89.26 47.69,82.41 46.92,81.64 46.92,78.15 ; 47.49,45.2 47.69,45.39 47.69,53.45 ; 47.43,41.77 47.54,41.66 47.54,33.4 46.67,32.53 46.67,29.58
  IN3 w1.016: v2(46.8,93.71) v2(45.65,93.71) 43.88,93.71 42.35,92.19 32.7,92.19 30.61,90.09 29.59,90.09
  IN3 w1.524: 28.13,90.41 28.13,96.76 25.08,99.81 25.08,102.22 25.97,103.11 38.16,103.11 39.58,104.53 39.58,107.48 40.3,108.19 40.3,109.82 39.58,110.53 39.58,115.58 40.99,116.98 45.03,116.98 45.55,116.47 51.63,116.47 53,117.84 57.87,117.84
  BOTTOM w0.381: v2(29.65,66.8) 27.51,66.8 27.49,66.79 ; 27.49,43.93 28.87,43.93 v2(29.02,43.78)
  BOTTOM w1.016: 33.45,30.28 32.75,30.97 31.73,30.97 27.87,34.83 27.87,41.13 27.49,41.52 27.49,76.57 v2(27.87,76.95)
  vias: v2(27.87,77.96) v2(33.59,29.45) v2(34.22,29.45) v2(56.96,28.82) v2(57.59,28.82) v2(58.74,117.84) v2(59.37,117.84)
+3V: length 315.2
  TOP w0.102: 21.78,76.18 C205.2
  TOP w0.203: Q6.2 61.08,98.6 61.25,98.44 R55.2 61.53,98.03 61.4,97.9 v2(61.38,97.9) 60.87,97.4 R52.2 ; v2(144.76,44.74) 144.76,48.33 144.28,48.81 PR6048.1 ; PR6416.1 v2(195.26,32.32) ; R77833.2 104.58,40.5 104.87,40.78 R77862.2 106.08,40.78 106.74,40.12 106.74,36.44 107.66,35.52 112.3,35.52 113.35,36.56 v2(113.73,36.56) ; R264.1 16.19,20.56 16.32,20.69 v2(17.08,20.69) ; R369.2 162.37,18.95 v2(162.24,18.83) ; C2323.2 57.47,31.09 v2(57.08,30.71) 56.59,31.21 C2322.2 ; R2449.2 87.41,29.86 R6647.2 88.17,29.86 89.23,28.8 R2391.1 ; R31.2 v2(50.86,104.25) ; v2(60.89,24.24) 60.89,22.85 60.77,22.72 R431.1 ; v1(68.62,31.85) 68.59,31.87 U2031.F5 67.89,31.87 67.61,31.6 U2031.E6 ; 122.62,50.66 R2349.2 122.24,51.2 R2351.2 121.58,51.58 v2(121.3,51.3) ; R463.2 124.14,16.12 v2(123.55,16.71) ; v2(196.34,22.67) 196.77,23.1 197.17,23.1 197.58,23.51 R752.2 ; R488.2 202.25,14.59 ; v2(168.18,32.63) 168.08,32.52 R325.2 ; C205.2 21.66,76.81 21.65,76.82 R2710.2 ; v2(54.04,104.51) 54.04,105.14 54.54,105.65 54.54,106.69 R21.1 ; v2(92.01,79.11) 92.38,79.11 92.99,79.72 93.96,79.72 94.88,80.63 96.16,80.63 96.32,80.47 99.16,80.47 99.22,80.41 100.62,80.41 101.28,79.74 101.92,79.74 103.06,78.6 103.06,77.71 103.58,77.19 v2(104.2,77.19) ; R12.1 58.3,106.41 v2(58.43,106.29) 58.74,106.59 R39.1 ; R13.2 57.06,109.05 v2(57.34,109.33) ; v1(100.73,76.57) 100.85,76.45 R2524.1 ; R106.2 v2(23.05,83.3) ; R77868.2 107.6,17.36 106.87,16.62 106.87,16.12 108.52,14.46 113.22,14.46 v2(113.73,14.97) ; v2(43.24,24.75) PR9283.1
  TOP w0.381: v2(198.44,20.71) 198.44,20.35 198.91,19.87 R780.1 ; R128.1 114.61,35.14 115.14,35.66 115.14,36.17 114.86,36.44 R2406.1 v2(113.73,36.56) ; v2(199.08,17.11) 199.08,16.48 200.97,14.59 202.25,14.59 ; C182.1 23.42,86.21 v2(23.18,85.97) ; C205.2 22.13,76.06 v2(22.29,75.91) ; v2(120.08,43.93) 120.2,43.93 122.36,46.09 122.36,50.41 122.62,50.66 ; R2391.1 90.14,28.8 v3(90.16,28.82)
  IN1 w0.381: v2(121.22,27.8) 121.22,31.6 120.9,31.92 120.9,32.97 121.35,33.42 121.35,41.9 120.08,43.17 v2(120.08,43.93) ; v2(199.08,17.11) 199.08,18.01 198.82,18.27 198.18,18.27 196.78,19.67 196.78,21.96 196.34,22.41 v2(196.34,22.67) ; v2(144.76,44.74) 144.46,44.44 144.46,35.17 145.94,33.68 145.94,30.17 145.27,29.5 v2(145.27,28.97)
  IN1 w0.508: v2(60.26,117.84) 58.23,115.81 41.62,115.81 v2(40.75,114.95)
  IN2 w0.508: v2(57.34,109.33) 56.74,109.93 56.74,110.93 60.26,114.45 v2(60.26,117.84) ; v2(162.24,18.83) 162.24,19.39 163.2,20.36 164.7,20.36 165.25,20.9 167.28,20.9 167.46,21.08 168.24,21.08 v2(168.86,21.7) ; v2(113.73,36.56) 113.73,36.94 111.81,38.86 v1(111.14,38.86)
  IN3 w0.381: v2(28.13,28.05) 28.89,27.29 28.89,22.59 26.73,20.43 18.1,20.43 17.84,20.69 v2(17.08,20.69)
  IN3 w0.508: v2(113.73,36.56) 113.73,36.23 112.63,35.13 112.63,33.26 114.72,31.17 114.72,26.93 v2(115.02,26.63) ; 197.42,29.96 197.57,29.81 197.57,27.57 195.64,25.64 195.64,23.37 v2(196.34,22.67)
  BOTTOM w0.152: v2(144.76,44.74) 145.02,45 145.38,45 145.73,45.36 PR2000.1
  BOTTOM w0.198: v2(22.29,75.91) 22.29,76.35 22.16,76.47 U26.11 ; U26.30 v2(20.25,82.41)
  BOTTOM w0.203: C149.1 65.47,33.49 v1(65.11,33.84) ; R365.2 178.33,22.47 178.69,22.82 v2(178.69,22.87) 179.17,23.35 180.53,23.35 181.04,23.86 R371.1 ; R18.2 v2(54.04,104.51) ; R2451.2 95.57,30.95 95.11,31.41 v1(94.7,31.41) ; R2448.2 R2463.2 84.39,35.04 84.36,35.07 R2464.2 83.5,34.66 83.53,34.63 R2450.2 83.53,33.66 84.19,33.01 R2465.2 R2447.2 R2526.1 84.29,31.05 84.62,30.72 84.62,30.03 84.39,29.81 84.1,29.81 83.75,29.46 83.75,28.79 v1(83.73,28.76) ; R77866.1 67.83,94.57 v3(68.13,94.27) ; R734.2 199.99,32.9 200.11,33.03 v2(200.32,33.03) ; R791.2 168.56,21.4 v2(168.86,21.7) ; v2(121.3,51.3) 121.3,51.44 R2354.2 ; v2(114.13,24.24) 114.28,24.09 114.28,20.61 113.7,20.02 R77876.2 113.42,20.02 113.07,19.67 113.07,18.05 113.47,17.64 113.47,15.23 v2(113.73,14.97) 114.34,14.36 121.86,14.36 122.77,15.28 122.77,15.64 123.2,16.07 123.2,16.37 v2(123.55,16.71) 123.84,17 R806.2 ; v2(111.4,74.55) 111.92,75.07 R2527.1 ; R2523.2 v2(92.01,79.11) ; R2499.1 v2(106.39,74.89)
  BOTTOM w0.254: v2(161.22,28.05) 161.22,28.05 162.11,28.94 163.38,28.94 165.42,30.97 166.53,30.97 v2(168.18,32.63) ; v2(60.26,117.84) 60.26,119.38 61.8,120.91 63.39,120.91 64,121.53 65.06,121.53 PR131.1 ; CN2019.255 v2(57.08,30.71)
  BOTTOM w0.381: v1(65.11,33.84) 65.04,33.84 63.69,32.5 v2(63.69,28.05) ; v2(196.34,22.67) 196.34,22.34 196.43,22.24 196.43,21.17 197.04,20.56 198.28,20.56 v2(198.44,20.71) ; 59.37,101.97 59.88,101.46 59.88,100.19 61.38,98.69 v2(61.38,97.9) ; v2(113.73,36.56) 113.35,36.94 R2547.1 ; C147.1 69.38,31.85 v1(68.62,31.85) ; v2(55.94,27.67) 55.94,29.56 v2(57.08,30.71) ; R2522.1 v2(104.2,77.19) ; PR9133.1 115.27,78.1 v2(115.5,77.86) ; R2546.1 111.65,38.86 111.65,38.86 v1(111.14,38.86) ; v2(117.92,79.36) PC9091.2 PR9132.1 ; R2723.1 v2(102.42,80.89) ; PQ9003.1 v2(112.73,81.45) ; Q2031.2 v2(109.41,74.89) Q2031.5
  BOTTOM w0.508: v3(171.69,23.18) 171.44,22.92 170.09,22.92 169.64,23.37 R77881.1
  vias: v2(18.45,82.23) v2(19.37,82.41) v2(22.54,74.79) v2(22.92,74.28) v2(23.56,39.48) v2(24.19,39.48) v2(24.83,74.15) v2(25.46,74.15) v2(27.24,32.24) v2(27.24,31.61) v2(35.24,14.08) v2(36,14.08) v2(36,13.45) v2(36.64,13.45) v2(58.63,103.44) v2(59.27,103.44) v2(103.95,84.82) v2(104.51,84.31) v2(106,82.66) v2(106,82.03) v2(195.77,29.96) v3(65.62,91.63) v3(66.31,91.1) v3(66.67,90.44) v3(68.44,93.56) v3(69,93) v3(146.9,24.93) v3(147.23,24.27) v3(147.48,28.82) v3(147.74,24.8) v3(171.87,22.44) v3(172.53,28.43) v3(173.06,27.9) v3(187.51,29.48) v3(187.89,30.11)
+3V_DMIC: length 2.9
  BOTTOM w0.508: CN1.4 37.87,116.1 38.8,115.18
+3V_EC:
  vias: v2(165.16,24.75) v2(166.81,24.55)
+3V_GFX: length 203.2
  TOP w0.203: R8069.1 123.25,119.49 123.03,119.72 R2221.1 122.74,120.05 v2(122.92,120.23) ; R2217.1 v2(118.65,124.37) R2227.1 ; R2219.1 v2(121.6,124.27) ; v2(125.16,122.06) 125.44,121.78 R8107.1 ; v2(109.03,125.46) 108.9,125.34 107.76,125.34 107.41,124.98 R2667.1 ; v2(120.84,122.8) 120.84,122.39 R2218.1 ; R77853.1 112.13,119.52 v2(111.69,119.52) ; R2660.1 107.41,122.72 v2(107.1,122.41) ; R2220.1 v2(122.49,124.32)
  TOP w0.508: U2028.3 v2(111.77,122.16) ; U2028.8 117.03,124.7 117.22,124.51 C2663.1 v2(117.66,123.81) ; v2(114.49,123.43) U2028.7
  IN1 w0.508: v2(75.35,104.86) 75.38,104.82 75.38,104.82 75.42,104.79 75.42,104.75 75.54,104.63 77.4,104.63 79.18,106.41 79.18,110.22 80.68,111.72 84.92,111.72 85.41,112.2 85.41,113.73 84.19,114.95 v2(83.73,114.95) 83.73,115.61 85.2,117.08 88.71,117.08 89.6,116.19 92.44,116.19 95.62,119.37 98.87,119.37 101.53,122.03 v2(102.04,122.03) ; v2(147.79,63.76) 147.25,64.29 147.25,73.77 146.49,74.54 142.3,74.54 140.9,75.93 133.92,75.93 131.63,73.65 119.7,73.65 118.86,74.48 118.86,77.15 117.16,78.85 117.16,80.73 v2(116.83,81.06) 116.83,83.6 119.7,86.47 v2(119.7,87.77) 119.67,87.79 119.67,88.2 118.38,89.5 117.66,89.5 114.34,92.82 109.36,92.82 107.4,94.78 107.4,95.62 106.31,96.71 106.31,97.8 105.98,98.13 105.98,100.52 106.16,100.7 106.16,102.35 103.24,105.27 103.24,107.02 104.84,108.62 104.84,108.95 105.49,109.61
  IN2 w0.508: v2(86.82,89.45) 86.68,89.6 86.68,91.43 88.72,93.48 95.69,93.48 96.61,92.57 99.23,92.57 100.24,91.55 101.22,91.55 102.36,90.41 103.13,90.41 107.3,86.24 114.95,86.24 116.83,84.36 v2(116.83,81.06)
  IN3 w0.508: v2(102.04,122.03) 102.93,122.03 103.44,122.54 106.97,122.54 v2(107.1,122.41)
  BOTTOM w0.152: v2(147.79,63.76) 147.98,63.57 147.98,63.11 148.3,62.78 PR9122.1
  BOTTOM w0.203: R2606.1 114.23,121.27 v2(114.49,121.02) 114.74,121.27 R2607.1 ; v2(111.69,119.52) 112,119.52 R2603.1 ; R2605.1 v2(114.49,119.75) R2608.1 ; R2604.1 113.95,123.15 114.23,123.43 v2(114.49,123.43) ; R8527.1 105.85,120.76 v2(106.23,121.14) 106.3,121.21 106.55,121.21 107.1,121.75 107.2,121.75 R2629.2
  BOTTOM w0.254: U8001.5 84.91,89.83 85.17,90.08 85.42,90.08 86.04,89.46 C2655.1
  BOTTOM w0.508: PR9129.1 127.45,123.04 v2(127.95,122.54) ; PC9092.1 116.83,80.95 v2(116.83,81.06) 116.62,81.06 PQ9003.3 ; C2655.1 v2(86.82,89.45)
  vias: v2(105.49,109.73) v2(109.08,119.75) v2(111.82,125.21) v2(123.81,123.05)
+3V_LAN: length 29.8
  TOP w0.203: C31.1 44.04,101.05 U1.11 ; U1.23 47.7,106.4 v2(47.81,106.29)
  TOP w0.381: C31.1 C42.1 44.14,99.44 43.75,99.05
  TOP w0.508: v2(42.73,99.05) 43.75,99.05
  IN1 w0.508: v2(48.45,110.86) v2(47.81,110.86) 42.1,110.86 41.97,110.73 v2(40.98,110.73)
  IN2 w0.508: v2(42.73,99.05) 43.24,99.05 44.13,99.94 44.13,101.74 46.92,104.53 46.92,105.47 47.74,106.29 v2(47.81,106.29) 49.08,107.56 49.08,110.22 v2(48.45,110.86) v2(47.81,110.86)
  vias: v2(41.21,110.1)
+3V_LDO_EC: length 55.4
  TOP w0.305: PR68.1 v2(151.57,36.88) 154.17,36.88 157.7,35.42 159.07,35.42 159.7,34.79 v2(159.7,34.69)
  IN2 w0.305: v2(159.7,34.69) 161,33.39 163.44,33.39 165.64,31.19 166.72,31.19 167.36,30.55 169.07,30.55 169.3,30.33 173.85,30.33 174.5,30.97 175.09,30.97 v2(175.14,31.02)
  IN3 w0.305: v2(173.8,32.75) 174.67,31.88 175.5,31.88 176.09,31.29 178.55,31.29 178.88,31.61 181.42,31.61 181.77,31.96 181.77,32.27 v2(181.65,32.4)
  BOTTOM w0.305: R399.2 170.4,20.21 170.63,20.44 R401.1 171.04,20.98 171.26,21.2 172.53,21.2 172.84,21.5 D13.1 172.84,22.87 172.01,23.7 172.01,24.97 171,25.98 171,28.05 172.4,29.45 174.26,29.45 175.14,30.34 v2(175.14,31.02)
+3V_S5: length 179.1
  TOP w0.203: R2438.2 R2510.1 94.55,27.87 v2(94.47,27.79) ; R469.2 70.42,20.94 69.9,20.42 v2(69.9,20.13) ; v1(115.76,49.44) 115.89,49.31 R2439.2 ; R429.2 72.8,20.66 72.56,20.41 v2(72.56,20.13) ; v2(176.41,33.01) 176.69,32.73 R344.1 ; v2(171.38,33.51) 171.39,33.51 172.25,32.66 R314.2 172.25,32.09 172.15,31.99 R315.2 ; v1(115.63,39.95) 115.59,39.99 R2309.1 114.71,40.27 114.49,40.5 112.58,40.5 112.08,39.99 112.08,36.82 111.57,36.31 107.98,36.31 107.53,36.76 107.53,41.03 107.76,41.26 R731.1 R392.1 R763.1 ; v2(71.65,14.77) 71.72,14.84 R2453.2 ; v2(70.7,14.77) R2454.2 ; v1(96.56,36.08) 96.57,36.08 R77882.2
  TOP w0.305: v2(69.98,17.64) 70.06,17.72 Q21.2 ; Q21.5 73.21,17.72 v2(73.28,17.64)
  TOP w0.381: v2(69.12,17.64) 69.12,17.16 69.28,17 69.28,15.73 70.24,14.77 v2(70.7,14.77) ; v1(113.22,34.63) 112.86,34.63 111.67,33.44 106.67,33.44 104.32,35.79 103.75,35.79 103.32,36.22 102.26,36.22 101.76,36.72 v3(100.85,36.72)
  TOP w0.508: R358.1 164.24,29.17 163.12,28.05 v2(162.24,28.05) 162.11,28.05 161.48,27.41 160.34,27.41 157.12,24.19 155.52,24.19 154.76,23.43 153.5,23.43 v3(152.92,24.01)
  IN1 w0.381: v2(71.65,14.77) 70.7,14.77 v2(70.7,14.77)
  IN2 w0.381: v2(176.41,33.01) 176.41,32.55
  IN2 w0.508: 53.4,111.77 53.4,110.1 51.62,108.32 51.62,107.56 52.13,107.05 53.95,107.05 56.2,104.8 56.2,101.46 57.34,100.32 59.54,100.32 60.86,99 62.71,99 64.45,97.27 66.08,97.27 70.1,93.24 70.1,91.33 72.37,89.06 79.11,89.06 87.59,80.58 87.59,79.16 88.57,78.18 89,78.18 89.59,77.59 91.51,77.59 91.71,77.79 96.03,77.79 96.81,78.57 96.81,79.16 97.19,79.54 99.04,79.54 99.57,79.01 v2(99.57,78.85)
  IN3 w0.381: v1(113.22,34.63) 113.94,35.36 115.95,35.36 116.32,35.72 116.32,38.3 115.63,38.99 v1(115.63,39.95) 115.72,39.86 116.22,39.86 117.16,40.8 117.16,48.04 v1(115.76,49.44)
  BOTTOM w0.203: R77872.2 96.2,36.49 96.56,36.12 v1(96.56,36.08) ; R2360.2 90.59,33.7 90.41,33.51 R2364.2 89.82,33.33 89.58,33.09 88.87,33.09 88.71,33.26 R2358.2 88.43,33.54 88.35,33.62 87.92,33.62 87.72,33.42 R2376.2 87.18,33.26 87.16,33.23 R2362.2 87.16,32.15 87.34,31.96 R2455.2 ; R795.2 67.12,22.85 67.5,23.23 67.5,23.62 Q43.2 68.5,23.62 68.87,23.26 R797.2 70.29,22.47 69.9,22.07 v2(69.9,20.13)
  BOTTOM w0.508: v2(162.24,28.05) 163.38,28.05 165.67,30.34 166.83,30.34 168.97,32.49 168.97,32.88 169.61,33.51 v2(171.38,33.51)
  vias: v2(48.45,23.23) v2(49.08,23.23) v2(49.08,22.21) v2(49.72,23.23) v2(49.97,113.85) v2(50.35,23.23) v2(50.61,113.85) v2(51.24,113.85) v2(76.9,22.21) v2(83.3,114.24) v2(83.83,113.88) v2(93.08,29.83) v3(86.8,31) v3(150.33,24.94) v3(151.06,24.86) v3(151.25,24.04) v3(151.81,24.76) v3(151.99,24.04) v3(193.53,29.12) v3(193.53,28.39) v3(193.81,32.68) v3(194.55,32.75) v3(197.58,33.13)
+3V_SSD: length 0.5
  TOP w0.203: R492.2 v2(24.17,9)
  vias: v2(21.91,2.65) v2(35.75,3.29) v2(36.51,3.29) v2(38.8,3.42) v2(39.43,3.42) v3(22.67,5.57) v3(22.67,4.81) v3(22.67,4.05) v3(22.67,3.31)
+3V_USB: length 16.9
  BOTTOM w0.279: U2033.5 96.21,82.04 96.2,82.03 C2758.2
  BOTTOM w0.305: U2033.9 93.55,84.84 93.03,84.32 C2762.2 ; C2760.2 93.03,88 93.68,87.34 U2033.14
  BOTTOM w0.457: v2(95.52,81.61) 95.59,81.53 C2758.2 ; C2762.2 92.26,84.62 v2(92.59,84.95) ; C2760.2 v2(93.66,88.5)
  BOTTOM w0.508: 95.95,92.95 95.36,93.53 91.71,93.53 91.12,92.95 R6507.2 ; R556.2 v2(101.79,88.89) ; R566.2 102.18,84.96 v2(102.8,85.58) 102.34,86.05 R563.2
  vias: v2(99.97,83.78) v2(100.43,83.32)
+3V_WLAN_P:
  vias: v2(181.93,13.04) v2(188.53,24.88) v2(190.43,11.42) v2(191.2,11.42) v2(192.06,30.77) v2(192.06,30.11) v2(193.36,11.64) v2(194.24,11.67)
+3VLCD_CON:
  vias: v2(64.5,92.57) v3(63.66,105.37) v3(63.69,94.73) v3(64.02,104.46) v3(64.35,94.4) v3(64.37,105.12) v3(64.63,93.71)
+3VLCD_CON_R:
  vias: v2(60.26,105.78) v3(60.89,106.16) v3(60.89,105.4) v3(61.66,105.45)
+3VLCD_CON_R_C:
  vias: v3(61.89,108.34)
+3VPCU: length 201.1
  TOP w0.508: v2(51.98,20.08) v2(51.98,23.38) v2(51.24,24.12) ; v2(53.86,108.01) 53.86,108.02 C28.2 54.48,108.64 Q2.1 ; v2(138.02,28.4) 138.18,28.56 139,28.56 139.74,29.3 139.74,31.74 v2(140.88,32.88) 142.02,34.02 142.05,34.02
  IN1 w0.508: v2(101.36,31.07) 101.36,30.87 102.98,29.25 102.98,24.67 102.3,23.99 v2(102.3,22.47)
  IN2 w0.508: v3(121.22,80.76) 120.84,81.14 118.55,81.14 117.79,80.38 116.52,80.38 116.01,80.89 116.01,83.68 115,84.7 112.46,84.7 111.69,85.46 105.04,85.46 103.36,87.13 103.36,88.33 101.92,89.78 100.94,89.78 98.91,91.81 95.88,91.81 95.45,92.23 91.84,92.23 91.4,92.67 88.99,92.67 87.54,91.22 87.54,89.24 86.83,88.53 85.05,88.53 84.01,87.49 82.86,87.49 81.24,89.11 81.24,92.15 80.65,92.74 77.73,92.74 76.41,91.43 76.41,90.49 75.75,89.83 72.68,89.83 70.86,91.65 70.86,93.56 66.39,98.03 64.76,98.03 63.03,99.76 61.17,99.76 59.22,101.71 v2(58.61,101.71) 58.61,102.22 58.99,102.6 59.5,102.6 60.01,103.11 60.01,105.65 58.48,107.17 55.05,107.17 54.21,108.01 v2(53.86,108.01) 53.07,108.01 v2(53.02,107.96) ; v2(102.3,22.47) 102.3,22.18 100.16,20.05 95.44,20.05 95.01,19.62 92.19,19.62 91.02,20.78 88.3,21.91 82.6,21.91 80.21,19.52 62.82,19.52 62.04,20.31 52.21,20.31 v2(51.98,20.08)
  BOTTOM w0.305: CN6.23 212.42,31.9 v2(212.25,31.74)
  BOTTOM w0.508: v2(53.02,107.96) 53.07,108.01 v2(53.86,108.01) 53.86,108.65 54.42,109.21 54.42,114.16 52.89,115.68 46.42,115.68 43.97,118.13 R507.1 ; R697.2 203.65,36.05 v2(203.01,36.05)
  vias: v1(99.67,32.41) v1(99.67,31.83) v2(129.98,78.98) v2(129.98,78.35) v2(185.96,21.7) v2(192.11,23.71) v3(121.98,80.76) v3(153.41,36.09) v3(153.68,35.39) v3(154.27,35.9) v3(154.39,35.17) v3(155.15,35.17) v3(155.89,35.17)
