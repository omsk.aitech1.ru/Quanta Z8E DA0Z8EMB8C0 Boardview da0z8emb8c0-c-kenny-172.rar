# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TEMP_FAIL: length 13.3
  IN2 w0.089: v2(115.83,112.63) 115.38,113.08 115.38,121.65 v2(114.49,122.54)
  BOTTOM w0.102: U2029.R38 115.6,112.63 v2(115.83,112.63) ; R8053.2 115.48,122.32 115.25,122.54 v2(114.49,122.54) 114.49,122.8 114.74,123.05 v2(115,123.05)
TEMP_MBAT#: length 98.5
  TOP w0.102: v2(145.55,22.2) 145.55,22.91 144.95,23.51 144.95,24.25 142.52,26.68 141.44,26.68 141.34,26.77 141,26.77 140.63,27.14 137.83,27.14 137.47,27.5 v2(137.14,27.5) ; v2(180.11,19.21) 180.11,19.09 180.24,18.96 U13.73
  IN2 w0.089: v2(101.28,22.52) 101.51,22.52 102.1,23.1 120.47,23.1 121.82,24.45 123.83,24.45 124.88,23.4 144.35,23.4 v2(145.55,22.2) 146.42,21.33 154.98,21.33 155.3,21.01 161.62,21.01 161.91,21.3 163.36,21.3 163.84,21.78 166.1,21.78 166.57,21.3 166.9,21.3 167.08,21.48 167.99,21.48 168.92,22.4 170.23,22.4 171.07,21.56 176.09,21.56 177.34,20.31 179.26,20.31 180.11,19.45 180.11,19.21 v2(180.11,19.21)
  BOTTOM w0.203: v2(137.14,27.5) 136.83,27.5 PR88.2
  BOTTOM w0.305: PR113.2 101,22.87 101.28,22.59 v2(101.28,22.52)
  BOTTOM w0.432: v2(101.28,22.52) 101.36,22.52 101.51,22.66 PR90.1
TEST_PG: length 7.9
  BOTTOM w0.102: R2672.2 C2668.2 R67859.2 95.97,99.1 v2(96.58,99.1) 100.39,99.1 100.49,99 100.85,99 101.17,99.32 U2029.AY13
TEST_PG_BACO: length 9.1
  BOTTOM w0.102: U2029.BA13 100.47,99.55 94.55,99.55 v2(94.42,99.43) 94.42,98.67 94.65,98.44 C2666.2 R2670.2
TP_INTH#: length 45.3
  IN2 w0.089: v1(98.96,44.54) 98.55,44.94 96.84,44.94 96.58,44.69 95.82,44.69 95.18,44.06 93.45,44.06 93.26,44.25 92.33,44.25 92.14,44.06 90.93,44.06 90.67,43.79 90.67,40.7 90.99,40.37 90.99,39.86 90.39,39.26 90.39,35.48 88.96,34.05 88.96,33.32 88.41,32.76 88.02,32.76 87.78,33.01 85.37,33.01 84.07,31.72 83.12,31.72 82.46,31.06 82.46,29.38 80.73,27.65 72.09,27.65 v2(71.69,28.05)
  BOTTOM w0.102: v1(98.96,44.54) 98.96,44.56 U2030.AU7 ; R820.1 v2(71.51,26.53) 71.51,27.87 v2(71.69,28.05)
TP_INTH#_L: length 7.9
  BOTTOM w0.102: Q43.1 68.38,25.52 68.77,25.13 68.77,24.12 69.18,23.71 R797.1 70.52,23.71 70.7,23.89 R798.2 71.05,23.61 71.18,23.48 v2(71.18,22.95) 70.32,22.08 CN12.7
TP_PWR_C:
  vias: v2(58.2,108.06) v2(58.84,108.06)
TP_SMB_CLK: length 5.7
  TOP w0.102: Q21.3 71.37,17.07 71.56,17.26 71.56,19.25 C460.1 71.32,20.1 v2(71.28,20.13) R469.1
  BOTTOM w0.102: CN12.6 71.32,20.17 v2(71.28,20.13)
TP_SMB_DATA: length 5.2
  TOP w0.102: v2(72.58,21.83) 72.35,21.6 R429.1 72.35,20.72 71.92,20.28 v2(71.92,20.13) 72.44,19.61 C439.1 72.44,19.15 72.43,19.14 Q21.6
  BOTTOM w0.102: CN12.5 72.32,20.54 v2(71.92,20.13)
TPCLK: length 117.8
  TOP w0.102: v2(178.84,24.62) 179.57,25.36 U13.89
  IN2 w0.089: v2(178.84,24.62) 178.44,24.22 175.81,24.22 175.73,24.14 175.73,23.44 175.64,23.35 175.22,23.35 175.13,23.44 175.13,24.14 175.04,24.22 174.53,24.22 174.3,23.99 174.01,23.99 173.82,23.81 173.82,23.66 173.57,23.4 172.79,23.4 172.57,23.63 172.57,23.82 172.39,23.99 171.56,23.99 170.76,23.2 167.96,23.2 167.62,23.54 162.04,23.54 161.42,22.92 151.36,22.92 148.79,25.49 140.75,25.49 140.19,24.92 131.5,24.92 131.02,25.4 121.04,25.4 120.33,24.69 116.66,24.69 116.07,25.28 110.8,25.28 110.2,24.69 98.3,24.69 96.66,23.04 91.49,23.04 90.51,24.03 86,24.03 85.39,23.42 81.93,23.42 81.23,22.72 78.17,22.72 77.02,21.58 75.63,21.58 75.5,21.7 75.5,21.86 v2(75.86,22.21)
  BOTTOM w0.102: v2(75.86,22.21) 76.01,22.36 76.01,24.24 75.85,24.4 R787.2 L16.1
TPCLK-1: length 2.7
  BOTTOM w0.102: CN12.2 75.32,22.29 75.5,22.47 L16.2 C681.1
TPD_EN: length 129.1
  TOP w0.102: v2(182.03,29.17) 182.28,29.17 182.53,29.42 R318.2
  IN2 w0.089: v2(65.59,24.15) 66.19,24.75 84.84,24.75 86.4,26.31 88.22,26.31 88.8,25.74 91.22,25.74 92.2,24.76 95.95,24.76 97.66,26.47 109.39,26.47 111.93,29.01 119.11,29.01 120.99,27.13 131.99,27.13 132.43,26.69 132.48,26.64 139.17,26.64 140.89,28.35 143.29,28.35 144.25,27.39 153.88,27.39 154.57,26.7 154.96,26.7 155.64,26.02 157.43,26.02 157.86,25.6 158.88,25.6 159.6,26.32 165.31,26.32 165.7,26.71 167.79,26.71 168.37,26.13 169.33,26.13 169.66,26.46 174.07,26.46 174.8,27.18 175.04,27.18 175.34,27.48 175.34,27.69 175.58,27.93 177.12,27.93 178.09,28.9 181.76,28.9 v2(182.03,29.17)
  BOTTOM w0.102: R796.2 R795.1 66.71,22.21 65.59,23.33 v2(65.59,24.15)
TPD_INT#_EC: length 121.1
  TOP w0.102: R309.1 R310.2 163.92,31.43 164.2,31.15 164.2,30.8 164.7,30.29 164.91,30.29 165.46,29.74 165.46,29.36 167.03,27.79 v2(167.03,27.11)
  IN2 w0.089: v2(167.03,27.11) 165.83,27.11 165.23,26.51 156.52,26.51 155.45,27.58 144.33,27.58 143.37,28.54 140.81,28.54 139.09,26.83 132.56,26.83 132.06,27.33 121.05,27.33 119.19,29.2 111.84,29.2 109.3,26.66 97.58,26.66 95.87,24.95 92.28,24.95 91.3,25.93 88.87,25.93 88.3,26.5 86.32,26.5 84.76,24.94 65.75,24.94 v2(64.96,24.15)
  BOTTOM w0.102: v2(64.96,24.15) 66.95,26.15 69.53,26.15 69.91,25.77 R807.1
TPDAT-1: length 3.3
  BOTTOM w0.254: L15.2 72.7,22.84 72.75,22.89 C680.1 73.6,22.89 74.32,22.17 CN12.3
TPDATA: length 119.6
  TOP w0.102: U13.90 179.34,25.76 v2(178.21,24.62) ; v2(71.82,22.21) 71.82,22.85 v2(71.94,22.97)
  IN2 w0.089: v2(71.82,22.21) 72.32,21.7 74.78,21.7 75.74,22.66 77.84,22.66 78.09,22.91 81.15,22.91 81.85,23.61 85.31,23.61 85.92,24.22 90.59,24.22 91.57,23.23 96.58,23.23 98.22,24.88 110.13,24.88 110.72,25.47 116.15,25.47 116.74,24.88 120.25,24.88 120.96,25.59 131.1,25.59 131.58,25.11 140.09,25.11 140.66,25.68 148.87,25.68 151.38,23.16 161.36,23.16 161.93,23.73 167.7,23.73 168.04,23.39 170.68,23.39 171.48,24.19 174.22,24.19 174.45,24.41 178,24.41 v2(178.21,24.62)
  BOTTOM w0.102: v2(71.82,22.21) 71.82,24.24 71.97,24.4 R784.2 L15.1
TPM_LRESET#: length 5.2
  TOP w0.102: R77879.2 121.85,24.29 122.19,24.62 D8515.2 122.7,24.16 123.09,23.77 123.09,22.85 122.96,22.72 122.62,22.72 122.49,22.59 122.49,22.34 122.62,22.21 U15.17
TRA_V_DAC: length 14.9
  TOP w0.508: v2(28.9,101.71) 28.9,102.09 C97.1
  IN1 w0.508: v2(28.9,101.71) v2(31.9,101.71) v2(34.9,101.71) v2(37.36,101.71)
  BOTTOM w0.508: U21.4 v2(34.9,101.71) ; U21.7 v2(31.9,101.71) ; v2(37.36,101.71) 37.61,101.71 37.9,102 U21.1 ; U21.10 v2(28.9,101.71)
TS_EN: length 193
  TOP w0.102: R33.2 v2(58.38,110.63) v2(58.86,111.11) ; R410.1 v1(185.81,23.1)
  IN3 w0.089: v2(58.38,110.63) 58.77,110.24 59.49,110.24 59.67,110.42 61.73,110.42 63.62,108.53 66.34,108.53 68.54,106.33 72.03,106.33 74.5,103.86 78.01,103.86 78.21,104.05 81.78,104.05 82.61,103.22 82.61,99.53 83.08,99.07 83.08,99.06 85.08,97.06 91.34,97.06 92.19,96.21 93.42,96.21 94.27,95.36 95.09,95.36 95.7,94.76 98.5,94.76 99.31,93.96 99.31,92.67 100.4,91.57 100.4,86.2 102.9,83.7 103.24,83.7 105.8,81.14 106.93,81.14 108.03,80.03 108.03,77.96 109.49,76.5 109.49,75.82 111.97,73.34 112.92,73.34 113.23,73.03 114.78,73.03 117.86,69.95 117.86,68.67 118.73,67.8 118.73,65.57 120.19,64.11 120.19,53.68 119.32,52.81 119.32,45.52 121.66,43.18 121.66,41.65 124.35,38.97 124.35,37.85 124.66,37.54 129.61,37.54 130.55,38.48 144.71,38.48 145.84,37.35 145.84,33.16 148.8,30.2 155.55,30.2 156.45,31.1 161.87,31.1 163.01,29.96 164.83,29.96 165.67,29.13 170.26,29.13 174.29,25.11 180.43,25.11 181.29,24.24 184.34,24.24 184.85,23.74 185.2,23.74 185.79,23.15 185.79,23.13 v1(185.81,23.1)
TS_EN_C: length 4.2
  TOP w0.102: U13.81 182.63,22.16 182.81,22.33 C390.1 184.08,22.33 184.41,22.67 184.77,22.67 184.9,22.8 R410.2
TS_EN_R: length 3.8
  TOP w0.102: R33.1 v2(58.38,109.21)
  BOTTOM w0.102: v2(58.38,109.21) 57.97,109.21 57.47,108.7 57.08,108.7 56.83,108.44 56.83,107.96 57.22,107.57 CN2.28
TYPEC1_DDI1_HPD: length 9.6
  TOP w0.102: TP8528.1 95.95,101.71 96.48,101.18 99.28,101.18 99.94,101.84 100.33,101.84 102.24,103.75 102.68,103.75 v2(103.19,104.25)
  BOTTOM w0.102: v2(103.19,104.25) 103.6,103.84 U2029.AU21
TYPEC_SBU1: length 15.7
  TOP w0.102: D19.2 TP45.1 12.51,8.62 v2(12.51,9.21)
  IN1 w0.089: v2(12.51,9.21) 11.54,9.21 10.98,9.77 10.98,14.34 10.73,14.59 10.73,16.75 9.59,17.89 9.08,17.89 v2(8.7,17.51)
  BOTTOM w0.102: v2(8.7,17.51) 8.7,17.26 8.19,16.75 7.55,16.75 7.45,16.65 CN14.A8
TYPEC_SBU2: length 9.3
  TOP w0.102: D39.2 10.85,19.13 10.7,18.98 10.04,18.98 9.71,18.66 TP98.1 v2(8.95,19.16)
  IN1 w0.089: CN14.B8 5.65,15.48 5.65,16.5 5.78,16.62 5.78,16.85 5.65,16.98 5.65,17.41 6.01,17.77 6.84,17.77 8.24,19.16 v2(8.95,19.16)
TYPEC_STRAP: length 4.1
  TOP w0.102: U13.77 182.43,20.56 182.97,21.1 R421.2 183.92,21.1 184.02,21.2 184.65,21.2 R407.2
UART0_CTS: length 9.1
  BOTTOM w0.089: 89.62,39.29 89.62,39.44 89.32,39.74 89.32,40.43 89.19,40.56 89.19,40.81 89.31,40.93 89.31,41.23 89.01,41.53 U2030.BA18
  BOTTOM w0.102: TP9109.1 88.17,34.33 88.54,34.33 88.94,34.72 88.94,35.09 89.62,35.77 89.62,39.29
UART0_INTR: length 6
  BOTTOM w0.089: U2030.BD18 89.51,39.82 89.85,39.48 89.85,39.29
  BOTTOM w0.102: TP9110.1 89.85,35.34 89.85,39.29
UART0_RTS: length 4.2
  BOTTOM w0.089: 90.49,39.29 90.49,39.61 90.1,39.99 90.1,41.02 U2030.BC17
  BOTTOM w0.102: 90.49,39.29 90.49,37.27 TP9108.1
UART0_RXD: length 5.4
  BOTTOM w0.089: U2030.BA16 91.01,41.57 91.32,41.26 91.32,40.99 91.21,40.88 91.21,40.58 91.34,40.46 91.34,40.03 91.4,39.97 91.4,38.89
  BOTTOM w0.102: 91.4,38.89 91.4,38.31 91.88,37.83 TP9106.1
UART0_TXD: length 5.9
  BOTTOM w0.089: 90.1,39.29 90.1,39.61 89.85,39.86 89.85,40.79 89.6,41.05 89.6,41.42 U2030.BB18
  BOTTOM w0.102: 90.1,39.29 90.1,36.13 TP9107.1
ULT_EDP_HPD: length 63.3
  TOP w0.102: v2(96.57,76.75) 96.59,76.75 96.88,77.04 R6590.1
  IN2 w0.089: v2(96.57,76.75) 96.03,76.75 95.33,76.06 91.65,76.06 90.57,74.98 90.05,74.98 89.47,75.56 89.47,75.89 86.55,78.81 86.55,79.37 82.66,83.25 82.66,83.94 79.36,87.25 72.79,87.25 62.64,97.4 61.07,97.4 59.42,99.05 58.17,99.05 v2(57.59,98.47)
  BOTTOM w0.102: R32.1 56.88,104.38 57.01,104.25 57.2,104.25 C91.2 57.03,103.5 57.03,99.6 57.59,99.05 v2(57.59,98.47) ; v2(96.57,76.75) 96.57,76.73 95.95,76.11 95.95,73.42 96.36,73 96.36,72.66 U2030.C10
ULT_EDP_HPD_R: length 2.5
  BOTTOM w0.102: CN2.25 55.72,106.12 56.02,105.83 56.29,105.83 R32.2
USB1_DM0-_HUB: length 0.6
  BOTTOM w0.102: R77843.1 98.49,80.5 98.36,80.63 R2720.1
USB1_DM0-_HUB_R: length 2
  BOTTOM w0.102: R2720.2 98.11,81.62 98.11,82.54 98.21,82.64 U2033.1
USB1_DP0+_HUB: length 0.6
  BOTTOM w0.102: R2721.1 97.6,80.63 97.47,80.5 R77842.1
USB1_DP0+_HUB_R: length 2
  BOTTOM w0.102: R2721.2 97.85,81.62 97.85,82.54 97.71,82.68 U2033.2
USB3_SS0RX+: length 2.5
  TOP w0.102: C700.1 29.84,20.81 29.99,20.66 29.99,20.36 29.51,19.88 29.51,19.53 29.42,19.44 U2032.8
USB3_SS0RX+_RE: length 2.2
  TOP w0.102: U2032.4 29.42,16.72 29.96,16.18 29.96,15.79 C2780.2
USB3_SS0RX+_RE_C: length 28.8
  TOP w0.102: C2780.1 29.87,14.93 30.09,14.93 30.22,14.8 30.22,14.27 29.46,13.51 29.46,10.72 28.89,10.15 23.43,10.15 22.41,9.13 21.02,9.13 20.14,8.25 17.32,8.25 15.05,10.53 15.05,11.34 14.81,11.58 14.81,12.06 15.23,12.49 15.23,13.12 15.31,13.19 15.48,13.19 15.58,13.3 R6525.1 15.58,13.83 15.42,14 15.42,14.57 15.54,14.69 16.04,14.69 16.43,15.09 16.97,15.09 17.08,14.97 17.2,14.86 U2034.5
USB3_SS0RX-: length 2.5
  TOP w0.102: U2032.7 29.82,19.46 29.73,19.55 29.73,19.79 30.21,20.27 30.21,20.68 30.33,20.81 C695.1
USB3_SS0RX-_RE: length 2.2
  TOP w0.102: C2781.2 30.17,15.98 30.17,16.27 29.82,16.63 U2032.5
USB3_SS0RX-_RE_C: length 28.8
  TOP w0.102: C2781.1 30.43,14.47 30.43,14.18 29.68,13.42 29.68,10.63 28.98,9.93 23.52,9.93 22.5,8.91 21.11,8.91 20.23,8.04 17.23,8.04 14.83,10.44 14.83,11.25 14.59,11.49 14.59,12.15 15.02,12.58 R6526.1 15.02,13.83 15.2,14.01 15.2,14.66 15.45,14.91 15.95,14.91 16.34,15.3 17.15,15.3 17.21,15.36 U2034.4
USB3_SS0TX+: length 2.6
  TOP w0.102: C684.1 27.58,20.81 27.7,20.68 27.7,20.29 28.31,19.69 28.31,19.55 28.22,19.46 U2032.11
USB3_SS0TX+_RE: length 2.2
  TOP w0.102: U2032.1 28.22,16.64 27.9,16.32 27.9,16.02 C2778.2
USB3_SS0TX+_RE_C: length 21.7
  TOP w0.102: C2778.1 27.88,14.71 28.04,14.55 28.04,13.54 27.77,13.27 27.77,12.46 26.48,11.16 23.42,11.16 22.36,10.1 20.57,10.1 19.42,8.95 17.64,8.95 16.52,10.07 16.52,10.98 16.73,11.19 R6522.1 16.73,11.67 16.57,11.83 16.57,12.43 17.08,12.94 17.71,12.94 17.97,12.69 18.48,12.69 18.62,12.83 U2034.7
USB3_SS0TX-: length 2.6
  TOP w0.102: U2032.10 28.62,19.44 28.53,19.53 28.53,19.78 27.92,20.38 27.92,20.68 28.05,20.81 C675.1
USB3_SS0TX-_RE: length 2.3
  TOP w0.102: U2032.2 28.62,16.73 28.12,16.23 28.12,15.88 C2779.2
USB3_SS0TX-_RE_C: length 21.7
  TOP w0.102: U2034.6 17.13,14.36 16.95,14.18 16.95,13.14 16.34,12.53 16.34,11.85 16.16,11.67 R6524.1 16.16,11.06 16.29,10.94 16.29,10 17.55,8.74 19.51,8.74 20.65,9.88 22.45,9.88 23.51,10.95 26.57,10.95 27.99,12.37 27.99,13.18 28.26,13.45 28.26,14.46 C2779.1
USB30_RX0+: length 108.2
  TOP w0.102: v2(29.78,22.32) 29.93,22.17 29.93,21.73 29.79,21.58 C700.2
  IN1 w0.089: v1(104.1,55.31) 104.1,55.3 103.91,55.12 103.91,55.02 104,54.93 105.07,54.93 106.06,53.94 106.06,50.7 104.15,48.8 104.15,47.65 102.93,46.43 102.93,44.82 103.41,44.33 103.41,40.99 101.15,38.73 99.64,38.73 97.22,36.31 97.22,35.77 96.53,35.08 96.53,34.04 96.18,33.69 95.87,33.69 95.18,33.01 95.18,32.19 94.84,31.84 94.4,31.84 93.68,31.12 93.68,29.56 91.71,27.59 91.71,27.24 87.85,23.39 77.88,23.39 77.16,22.66 62.78,22.66 61.64,21.53 51.89,21.53 51.63,21.27 48.21,21.27 47.06,22.42 38.59,22.42 37.65,23.37 35.69,23.37 34.91,22.59 31.71,22.59 30.75,21.63 30.27,21.63 30.03,21.87 30.03,22.07 v2(29.78,22.32)
  BOTTOM w0.102: U2030.AC2 101.45,56.55 103.06,56.55 103.9,55.71 103.9,55.51 v1(104.1,55.31)
USB30_RX0-: length 108.2
  TOP w0.102: v2(30.41,22.32) 30.15,22.05 30.15,21.71 30.27,21.58 C695.2
  IN1 w0.089: v2(30.41,22.32) 30.23,22.14 30.23,21.96 30.36,21.83 30.67,21.83 31.63,22.79 34.82,22.79 35.6,23.57 37.73,23.57 38.68,22.62 47.15,22.62 48.3,21.47 51.55,21.47 51.8,21.73 61.56,21.73 62.69,22.87 77.07,22.87 77.8,23.59 87.77,23.59 91.51,27.33 91.51,27.68 93.48,29.65 93.48,31.21 94.31,32.04 94.75,32.04 94.98,32.27 94.98,33.09 95.79,33.9 96.1,33.9 96.33,34.12 96.33,35.17 97.01,35.85 97.01,36.4 99.55,38.94 101.07,38.94 103.21,41.08 103.21,44.25 102.73,44.73 102.73,46.52 103.95,47.74 103.95,48.88 105.85,50.79 105.85,53.86 104.99,54.72 103.92,54.72 103.71,54.93 103.71,55.09 v1(103.5,55.3)
  BOTTOM w0.102: U2030.AC4 101.19,56.29 101.27,56.2 101.57,56.2 101.71,56.33 102.97,56.33 103.68,55.62 103.68,55.48 v1(103.5,55.3)
USB30_RX1+: length 116.9
  TOP w0.102: v2(25.38,42.53) 25.17,42.74 25.17,43.25 26.1,44.18 26.1,53.96 25.1,54.96 24.17,54.96 23.78,55.35 C287.2 23.61,55.15 23.41,54.96 22.47,54.96 22.39,55.05 C28067.2
  IN1 w0.089: v1(97.4,52.51) 97.67,52.23 97.67,51.33 97.46,51.12 97.01,51.12 96.09,50.21 96.09,47.21 95.47,46.59 95.47,45.61 94.55,44.69 94.55,44.36 93.42,43.23 93.42,42.16 91.88,40.63 91.88,39.97 89.77,34.88 88.61,33.72 87.9,33.72 86.98,32.8 86.98,32.11 85.95,31.08 83.09,31.08 82.61,30.59 82.61,29.55 80.72,27.65 74.21,27.65 74.19,27.63 56.53,27.63 56.18,27.27 55.57,27.27 55.07,26.77 53.66,26.77 52.91,27.52 50.92,27.52 49.93,28.51 43.81,28.51 43.67,28.36 36.16,28.36 33.84,30.69 33.21,30.69 29.65,34.25 29.65,37.96 26.66,40.96 25.89,40.96 25.16,41.69 25.16,42.32 v2(25.38,42.53)
  BOTTOM w0.102: v1(97.4,52.51) 97.4,52.26 97.14,52.01 U2030.AJ9
USB30_RX1+_C: length 11.4
  TOP w0.102: C28067.1 21.93,55.12 21.72,54.91 21.02,54.91 20.08,53.96 17.44,53.96 U5.10 17.2,53.96 16.4,53.96 14.83,52.4 14.32,52.4 13.54,51.61 13.2,51.61 13.1,51.72 CN5.6
USB30_RX1-: length 116.9
  TOP w0.102: v2(24.74,42.53) 24.95,42.74 24.95,43.34 25.88,44.27 25.88,53.87 25.01,54.74 24.17,54.74 23.78,54.35 C295.2 23.61,54.56 23.43,54.74 22.5,54.74 22.39,54.62 C28066.2
  IN1 w0.089: v2(24.74,42.53) 24.96,42.32 24.96,41.6 25.81,40.75 26.57,40.75 29.45,37.87 29.45,34.16 33.13,30.49 33.76,30.49 36.08,28.16 43.75,28.16 43.9,28.31 49.85,28.31 50.84,27.31 52.83,27.31 53.58,26.56 55.15,26.56 55.66,27.07 56.26,27.07 56.62,27.42 74.27,27.42 74.3,27.45 80.8,27.45 82.82,29.46 82.82,30.51 83.18,30.87 86.04,30.87 87.18,32.02 87.18,32.72 87.98,33.51 88.7,33.51 89.95,34.77 90.59,36.31 92.09,39.93 92.09,40.54 93.62,42.07 93.62,43.14 94.75,44.28 94.75,44.61 95.67,45.53 95.67,46.51 96.3,47.13 96.3,50.12 97.09,50.91 97.55,50.91 97.88,51.24 97.88,52.4 v1(97.98,52.51)
  BOTTOM w0.102: U2030.AJ8 97.71,52.24 v1(97.98,52.51)
USB30_RX1-_C: length 11.4
  TOP w0.102: C28066.1 21.93,54.53 21.77,54.69 21.11,54.69 20.17,53.75 19.19,53.75 U5.1 19.06,53.75 16.49,53.75 14.92,52.18 14.41,52.18 13.63,51.4 13.23,51.4 13.1,51.27 CN5.5
USB30_RX2+: length 103.2
  TOP w0.102: C28063.2 22.26,33.16 22.4,33.02 22.88,33.02 23.37,33.51 C363.2 23.43,33.21 23.54,33.1 23.78,33.1 23.93,33.25 23.93,34.01 24.45,34.53 26.14,34.53 v2(26.35,34.74)
  IN1 w0.089: v2(26.35,34.74) 26.57,34.52 28.42,34.52 31.67,31.28 31.67,29.28 33.26,27.69 42.37,27.69 43.22,26.84 52.63,26.84 53.38,26.09 55.35,26.09 55.85,26.6 56.46,26.6 56.81,26.95 74.75,26.95 74.77,26.98 82.55,26.98 85.91,30.34 86.92,30.34 87.84,31.26 87.84,32.3 88.21,32.67 88.55,32.67 90.36,34.47 90.68,35.26 92.42,36.99 92.42,39.18 93.03,39.79 93.03,40.63 95.36,42.96 95.36,44.49 95.68,44.81 96.32,44.81 96.45,44.94 96.45,46.52 96.8,46.87 97.53,46.87 98.29,47.63 98.29,50.88 98.63,51.22 98.63,52.46 99.17,53 99.17,53.24 v1(98.92,53.5)
  BOTTOM w0.102: U2030.AG7 98.51,53.37 98.64,53.5 v1(98.92,53.5)
USB30_RX2+_C: length 11.2
  TOP w0.102: CN7.6 13.1,31.65 13.2,31.55 13.54,31.55 14.2,32.21 15.47,32.21 17.03,33.77 17.84,33.77 U11.10 18.08,33.77 20.15,33.77 20.93,32.99 21.63,32.99 21.81,33.17 C28063.1
USB30_RX2-: length 103.2
  TOP w0.102: v2(26.35,34.1) 26.14,34.31 24.54,34.31 24.14,33.92 24.14,33.16 23.87,32.88 23.56,32.88 23.43,32.76 C368.2 23.32,32.51 23.02,32.8 22.44,32.8 22.26,32.63 C28062.2
  IN1 w0.089: v2(26.35,34.1) 26.57,34.32 28.34,34.32 31.46,31.2 31.46,29.2 33.17,27.49 42.28,27.49 43.13,26.64 52.55,26.64 53.3,25.89 55.43,25.89 55.94,26.4 56.54,26.4 56.9,26.75 74.83,26.75 74.86,26.78 82.64,26.78 86,30.14 87.01,30.14 88.04,31.17 88.04,32.21 88.3,32.47 88.64,32.47 90.53,34.36 90.86,35.15 92.62,36.91 92.62,39.09 93.23,39.7 93.23,40.54 95.57,42.88 95.57,44.4 95.77,44.6 96.4,44.6 96.66,44.86 96.66,46.43 96.89,46.66 97.61,46.66 98.49,47.55 98.49,50.79 98.84,51.14 98.84,52.37 99.38,52.91 99.38,53.37 v1(99.5,53.5)
  BOTTOM w0.102: U2030.AG6 99.5,53.3 v1(99.5,53.5)
USB30_RX2-_C: length 11.2
  TOP w0.102: C28062.1 21.81,32.65 21.68,32.78 20.84,32.78 20.06,33.56 19.82,33.56 U11.1 19.69,33.56 17.12,33.56 15.56,31.99 14.29,31.99 13.63,31.33 13.2,31.33 13.1,31.23 CN7.5
USB30_RX3+: length 8.9
  BOTTOM w0.089: 102.61,59.05 102.59,59.05 102.58,59.04 102.21,59.04 102.07,58.9 101.92,58.9 U2030.Y1
  BOTTOM w0.102: 102.61,59.05 103.44,59.05 103.58,58.91 107.25,58.91 108.67,60.33 108.67,60.77 108.56,60.87 TP2025.1
USB30_RX3-: length 9.6
  BOTTOM w0.089: 102.61,58.84 102.59,58.84 102.58,58.85 102.28,58.85 102.14,58.71 101.68,58.71 101.53,58.86 101.16,58.86 U2030.Y3
  BOTTOM w0.102: 102.61,58.84 103.35,58.84 103.49,58.69 107.34,58.69 108.88,60.24 108.88,60.77 108.98,60.87 TP2026.1
USB30_RX+_TYPEC1: length 12.1
  TOP w0.102: CN14.B11 5.53,13.7 6.41,13.7 7.97,15.26 10.31,15.26 10.46,15.12 RV1.10 RV1.1 11.98,15.12 12.13,15.26 12.24,15.26 12.64,14.87 12.94,14.87 13.12,14.69 R6520.1 13.5,14.69 13.67,14.86 14.03,14.86 14.31,15.14 14.31,15.63 14.48,15.8 14.95,15.8 15.08,15.67 C2777.1
USB30_RX+_TYPEC1_C: length 2.6
  TOP w0.102: U2034.3 17.21,15.86 17.08,15.99 16.83,15.99 16.65,15.81 15.98,15.81 C2777.2
USB30_RX+_TYPEC2: length 11.9
  TOP w0.102: v2(13.73,18.82) 13.94,18.61 13.94,18.36 14.2,18.1 15.33,18.1 15.46,17.98 C2773.1
  BOTTOM w0.102: CN14.A11 7.68,18.15 7.82,18.01 8.13,18.01 8.3,18.19 9.29,18.19 9.71,17.77 9.71,17.39 10.13,16.97 10.32,16.97 10.46,17.12 RV2.10 RV2.1 11.86,17.12 12,16.97 12.13,16.97 12.25,17.1 12.25,17.64 12.51,17.89 12.73,17.89 R6517.1 13.14,18.05 13.31,17.87 13.51,17.87 13.94,18.31 13.94,18.61 v2(13.73,18.82)
USB30_RX+_TYPEC2_C: length 3.6
  TOP w0.102: C2773.2 16.34,18.07 17.31,18.07 17.43,17.94 17.43,17.74 17.09,17.39 17.09,17 17.23,16.86 U2034.1
USB30_RX-_TYPEC1: length 12.1
  TOP w0.102: C2776.1 15.08,16.17 14.92,16.01 14.39,16.01 14.1,15.72 14.1,15.23 13.94,15.08 13.67,15.08 13.5,15.25 R6518.1 13.15,15.25 12.97,15.08 12.73,15.08 12.33,15.48 12.13,15.48 11.99,15.61 RV1.2 RV1.9 10.48,15.61 10.35,15.48 7.88,15.48 6.32,13.92 5.51,13.92 CN14.B10
USB30_RX-_TYPEC1_C: length 2.6
  TOP w0.102: U2034.2 17.2,16.36 17.05,16.22 16.73,16.22 16.55,16.04 15.98,16.04 C2776.2
USB30_RX-_TYPEC2: length 11.9
  TOP w0.102: v2(14.37,18.82) 14.16,18.61 14.16,18.45 14.29,18.32 15.31,18.32 15.46,18.47 C2772.1
  BOTTOM w0.102: CN14.A10 7.68,17.65 7.82,17.79 8.22,17.79 8.39,17.97 9.21,17.97 9.5,17.68 9.5,17.3 10.04,16.76 10.34,16.76 10.48,16.62 RV2.9 RV2.2 11.86,16.62 12,16.76 12.22,16.76 12.47,17.01 12.47,17.55 12.6,17.68 12.69,17.68 R6515.1 13.11,17.48 13.29,17.66 13.59,17.66 14.16,18.22 14.16,18.61 v2(14.37,18.82)
USB30_RX-_TYPEC2_C: length 3.6
  TOP w0.102: C2772.2 16.39,18.3 17.99,18.3 18.1,18.4 18.52,18.4 18.62,18.3 U2034.24
USB30_TX0+: length 107.5
  TOP w0.102: v2(27.47,23.1) 27.65,22.92 27.65,21.71 27.53,21.58 C684.2
  IN1 w0.089: v1(105.17,54.01) 105.01,53.86 105.01,53.02 105.32,52.72 105.32,50.98 103.39,49.05 103.39,47.91 101.87,46.39 101.87,41.98 98.55,38.66 97.79,38.66 95.74,36.61 95.74,35.09 95.52,34.86 95.52,34.32 95.09,33.9 94.94,33.9 93.53,32.49 93.53,32.12 91.63,30.21 91.63,29.33 90.87,28.57 90.87,27.42 87.51,24.06 77.6,24.06 76.92,23.38 62.54,23.38 61.79,22.62 52.03,22.62 51.39,21.98 48.64,21.98 47.53,23.09 38.87,23.09 37.93,24.04 35.41,24.04 34.67,23.3 29.85,23.3 28.94,22.39 27.95,22.39 27.71,22.63 27.71,22.87 v2(27.47,23.1)
  BOTTOM w0.102: U2030.AD2 101.51,55.61 102.04,55.61 102.84,54.81 104.67,54.81 104.98,54.5 104.98,54.2 v1(105.17,54.01)
USB30_TX0-: length 107.5
  TOP w0.102: v2(28.11,23.1) 27.87,22.86 27.87,21.76 28.05,21.58 C675.2
  IN1 w0.089: v1(104.56,54.01) 104.81,53.76 104.81,52.94 105.12,52.63 105.12,51.07 103.19,49.14 103.19,47.99 101.67,46.47 101.67,42.06 98.47,38.86 97.71,38.86 95.54,36.7 95.54,35.17 95.31,34.94 95.31,34.41 95.01,34.1 94.86,34.1 93.33,32.57 93.33,32.2 91.43,30.3 91.43,29.41 90.66,28.65 90.66,27.5 87.42,24.26 77.52,24.26 76.84,23.58 62.46,23.58 61.7,22.83 51.95,22.83 51.31,22.19 48.73,22.19 47.62,23.3 38.96,23.3 38.01,24.24 35.32,24.24 34.58,23.5 29.77,23.5 28.86,22.59 28.04,22.59 27.91,22.72 27.91,22.9 v2(28.11,23.1)
  BOTTOM w0.102: v1(104.56,54.01) 104.76,54.22 104.76,54.41 104.58,54.6 102.75,54.6 101.95,55.4 101.73,55.4 101.54,55.2 101.34,55.2 101.03,55.34 100.77,55.45 U2030.AD4
USB30_TX1+: length 133
  TOP w0.102: C272.2 24.84,58.36 25.63,58.36 26.94,57.06 26.94,42.1 26.39,41.55 26.39,40.11 v2(26.6,39.89)
  IN1 w0.089: v2(26.6,39.89) 26.43,39.72 26.43,37.02 25.23,35.83 25.23,33.62 26.83,32.02 26.83,26.47 27.54,25.76 38.4,25.76 39.51,24.64 41.16,24.64 41.91,25.39 49.21,25.39 49.88,24.72 55.91,24.72 56.31,25.11 59.41,25.11 59.88,25.58 76.31,25.58 76.33,25.61 84.74,25.61 87.87,28.74 87.87,29.32 90.54,31.99 90.54,32.68 93.28,35.42 93.41,35.42 94.17,36.18 94.17,38.75 96.5,41.08 97.14,41.08 97.74,41.68 98.62,41.68 99.93,43 99.93,43.84 99.43,44.35 99.43,46.2 101.23,48 101.23,49.7 103.04,51.51 103.04,52 v1(102.87,52.17)
  BOTTOM w0.102: v1(102.87,52.17) 103.04,52.33 103.04,52.45 102.89,52.6 101.77,52.6 101.55,52.82 101.2,52.82 U2030.AG3
USB30_TX1+_C: length 1.7
  TOP w0.102: C272.1 23.7,58.27 23.04,58.27 22.89,58.41 R198.2
USB30_TX1+_C_R: length 11.6
  TOP w0.102: CN5.9 13.1,57.65 13.23,57.52 13.65,57.52 14.16,57.01 15.12,57.01 15.33,57.21 17.25,57.21 U5.6 17.4,57.21 19.39,57.21 20.43,58.25 21,58.25 C270.1 21.79,58.26 22.3,58.26 22.44,58.4 R198.1
USB30_TX1-: length 133
  TOP w0.102: C277.2 25.05,58.15 25.54,58.15 26.72,56.97 26.72,42.19 26.17,41.64 26.17,40.1 v2(25.97,39.89)
  IN1 w0.089: v1(103.46,52.17) 103.24,51.95 103.24,51.42 101.43,49.62 101.43,47.92 99.63,46.11 99.63,44.44 100.14,43.93 100.14,42.91 98.7,41.48 97.82,41.48 97.23,40.88 96.58,40.88 94.37,38.67 94.37,36.1 93.49,35.22 93.36,35.22 90.74,32.59 90.74,31.91 88.07,29.24 88.07,28.65 84.82,25.41 76.42,25.41 76.39,25.38 59.96,25.38 59.49,24.91 56.39,24.91 56,24.52 49.79,24.52 49.13,25.18 41.99,25.18 41.25,24.44 39.43,24.44 38.32,25.55 27.45,25.55 26.62,26.38 26.62,31.94 25.03,33.53 25.03,35.91 26.22,37.1 26.22,39.64 v2(25.97,39.89)
  BOTTOM w0.102: U2030.AG1 101.81,52.92 101.91,52.82 102.98,52.82 103.25,52.54 103.25,52.37 v1(103.46,52.17)
USB30_TX1-_C: length 1.7
  TOP w0.102: R200.2 22.89,57.89 23.05,58.05 23.69,58.05 C277.1
USB30_TX1-_C_R: length 11.6
  TOP w0.102: CN5.8 13.1,57.18 13.23,57.31 13.56,57.31 14.07,56.79 15.21,56.79 15.42,57 19.01,57 U5.5 19.23,57 19.48,57 20.52,58.04 21.01,58.04 C280.1 21.79,58.04 22.32,58.04 22.44,57.92 R200.1
USB30_TX2+: length 119.1
  TOP w0.102: C349.2 25.1,38.54 25.63,38.54 v2(25.74,38.66)
  IN1 w0.089: v2(25.74,38.66) 24.87,38.66 24.62,38.41 24.62,37.5 23.86,36.74 23.86,31.68 25.59,29.95 25.59,26.28 26.98,24.88 38.04,24.88 39.15,23.77 50.58,23.77 50.92,23.42 55.86,23.42 56.67,24.24 59.77,24.24 60.23,24.69 77,24.69 77.04,24.73 85.39,24.73 89.6,28.94 89.6,29.7 91.76,31.86 91.76,32.59 93.62,34.45 93.75,34.45 95.06,35.77 95.06,37.45 98.41,40.8 99.33,40.8 101.2,42.67 101.2,46.71 102.12,47.63 102.12,48.83 104.63,51.34 104.63,52.42 104.24,52.82 103.89,52.82 103.74,52.97 103.74,53.98 v1(103.76,54)
  BOTTOM w0.102: v1(103.76,54) 103.13,53.37 101.74,53.37 101.53,53.17 101.29,53.17 100.95,53.51 U2030.AG4
USB30_TX2+_C: length 1.5
  TOP w0.102: C349.1 24.35,38.62 24.17,38.45 23.67,38.45 R280.2
USB30_TX2+_C_R: length 12.3
  TOP w0.102: R280.1 22.82,38.59 22.7,38.47 22.15,38.47 C345.1 21.41,38.47 21.09,38.47 20.17,37.54 20.17,37.16 20.03,37.02 18.03,37.02 U11.6 17.89,37.02 14.21,37.02 13.69,37.54 13.23,37.54 13.1,37.67 CN7.9
USB30_TX2-: length 119.1
  TOP w0.102: v2(25.74,38.02) 25.44,38.33 24.94,38.33 24.8,38.18 C351.2
  IN1 w0.089: v1(103.15,54) 102.93,53.78 102.93,53.69 103.06,53.57 103.41,53.57 103.53,53.44 103.53,52.89 103.8,52.61 104.15,52.61 104.43,52.34 104.43,51.43 101.92,48.91 101.92,47.71 100.99,46.79 100.99,42.75 99.25,41.01 98.33,41.01 94.85,37.54 94.85,35.85 93.66,34.66 93.53,34.66 91.55,32.68 91.55,31.95 89.39,29.79 89.39,29.03 85.3,24.94 76.95,24.94 76.92,24.9 60.15,24.9 59.69,24.44 56.59,24.44 55.77,23.63 51,23.63 50.66,23.97 39.24,23.97 38.12,25.08 27.07,25.08 25.79,26.36 25.79,30.03 24.06,31.76 24.06,36.66 24.83,37.42 24.83,38.33 24.95,38.45 25.21,38.45 25.33,38.33 25.33,37.83 25.46,37.71 25.59,37.71 25.74,37.86 v2(25.74,38.02)
  BOTTOM w0.102: U2030.AG2 101.28,53.51 101.19,53.6 101.19,53.74 101.28,53.83 101.56,53.83 101.8,53.59 103.04,53.59 103.24,53.79 103.24,53.91 v1(103.15,54)
USB30_TX2-_C: length 1.5
  TOP w0.102: C351.1 24.35,38.07 24.18,38.23 23.67,38.23 R284.2
USB30_TX2-_C_R: length 12.3
  TOP w0.102: CN7.8 13.1,37.17 13.25,37.32 13.6,37.32 14.12,36.8 19.65,36.8 U11.5 19.87,36.8 20.12,36.8 20.38,37.07 20.38,37.45 21.18,38.25 21.37,38.25 C352.1 22.14,38.2 22.7,38.2 22.82,38.07 R284.1
USB30_TX3+: length 4.6
  TOP w0.102: v1(103.47,57.87) 103.62,57.72 103.62,56.68 103.19,56.25 TP2027.1
  BOTTOM w0.089: U2030.AA2 102.52,58.51 102.53,58.52 102.55,58.52
  BOTTOM w0.102: 102.55,58.52 103.06,58.52 103.28,58.29 103.28,58.05 v1(103.47,57.87)
USB30_TX3-: length 4.6
  TOP w0.102: v1(102.88,57.87) 102.88,57.56 102.75,57.43 102.75,57.09 102.88,56.96 103.06,56.96 103.19,57.09 TP2028.1
  BOTTOM w0.089: U2030.AA4 100.97,58.51 101.28,58.2 101.56,58.2 101.68,58.32 102.52,58.32 102.53,58.31 102.54,58.31 102.55,58.3
  BOTTOM w0.102: 102.55,58.3 102.97,58.3 103.07,58.2 103.07,58.06 v1(102.88,57.87)
USB30_TX+_TYPEC1: length 17.6
  TOP w0.102: v2(18.98,9.99) 18.85,10.13 18.85,10.49 19,10.65 C2775.1
  BOTTOM w0.102: CN14.A2 7.68,13.65 7.82,13.79 9.09,13.79 9.59,14.29 9.59,14.84 9.95,15.21 10.37,15.21 10.46,15.12 RV2.6 RV2.5 12.02,15.12 12.08,15.18 12.53,15.18 13.31,14.4 13.31,13.41 14.45,12.27 14.45,11.76 14.79,11.42 16.95,9.26 18.55,9.26 18.83,9.54 18.83,9.83 v2(18.98,9.99)
USB30_TX+_TYPEC1_C: length 2.8
  TOP w0.102: U2034.9 19.62,12.83 19.48,12.69 19.48,12.46 18.78,11.76 18.78,11.52 18.87,11.42 C2775.2
USB30_TX+_TYPEC2: length 24.4
  TOP w0.102: v2(23.09,12.69) 22.93,12.53 22.93,11.36 22.32,10.74 22,10.74 C2771.1 ; v2(13.61,16.22) 13.48,16.35 13.48,16.72 13.17,17.03 12.1,17.03 12.02,17.12 RV1.5 RV1.6 10.46,17.12 10.36,17.01 10.09,17.01 9.78,17.32 9.71,17.38 9.71,17.77 9.28,18.2 7.99,18.2 7.81,18.02 7.05,18.02 6.96,18.11 5.52,18.11 CN14.B2
  IN3 w0.089: v2(23.09,12.69) 22.93,12.85 22.93,13.22 22.36,13.78 19.16,13.78 17.18,15.76 13.58,15.76 13.46,15.89 13.46,16.07 v2(13.61,16.22)
USB30_TX+_TYPEC2_C: length 3.7
  TOP w0.102: C2771.2 20.74,10.8 20.42,10.8 20.04,11.18 20.04,12.14 20.27,12.37 20.27,12.69 20.12,12.83 U2034.10
USB30_TX-_TYPEC1: length 17.6
  TOP w0.102: C2774.1 18.48,10.65 18.63,10.49 18.63,10.28 v2(18.35,9.99)
  BOTTOM w0.102: CN14.A3 7.68,14.15 7.82,14.01 9,14.01 9.37,14.37 9.37,14.93 9.86,15.42 10.29,15.42 10.48,15.61 RV2.7 RV2.4 11.99,15.61 12.21,15.4 12.62,15.4 13.52,14.49 13.52,13.5 14.67,12.36 14.67,11.85 17.04,9.47 18.46,9.47 18.61,9.63 18.61,9.73 v2(18.35,9.99)
USB30_TX-_TYPEC1_C: length 2.8
  TOP w0.102: C2774.2 18.41,11.42 18.57,11.58 18.57,11.85 19.27,12.55 19.27,12.69 19.12,12.83 U2034.8
USB30_TX-_TYPEC2: length 24.4
  TOP w0.102: v2(12.97,16.22) 13.26,16.5 13.26,16.63 13.08,16.81 12.19,16.81 11.99,16.62 RV1.4 RV1.7 10.48,16.62 10.3,16.8 10,16.8 9.69,17.11 9.5,17.3 9.5,17.68 9.19,17.98 8.08,17.98 7.9,17.8 6.96,17.8 6.87,17.89 5.52,17.89 CN14.B3 ; v2(22.46,12.69) 22.72,12.43 22.72,11.45 22.23,10.96 21.91,10.96 21.79,11.09 C2770.1
  IN3 w0.089: v2(22.46,12.69) 22.72,12.95 22.72,13.13 22.28,13.58 19.08,13.58 17.1,15.56 13.5,15.56 13.25,15.8 13.25,15.94 v2(12.97,16.22)
USB30_TX-_TYPEC2_C: length 3.7
  TOP w0.102: U2034.11 20.62,12.83 20.48,12.69 20.48,12.28 20.25,12.05 20.25,11.27 20.51,11.02 20.88,11.02 21.01,11.14 C2770.2
USB_BC_ON: length 187
  TOP w0.102: U7.4 20.88,46.62 21.03,46.47 v2(24.19,46.47) ; U13.97 179.62,28.38 179.13,27.9 179.13,27.29 178.3,26.46 178.3,26 178.02,25.72 177,25.72 v2(176.57,26.15)
  IN2 w0.089: v2(24.19,46.47) 24.19,46.46 26.73,43.92 26.73,41.77 28.22,40.28 28.22,29.1 31.68,25.64 38.91,25.64 39.82,24.73 41.68,24.73 42.34,25.39 46.57,25.39 46.76,25.2 52.76,25.2 53.68,24.28 53.68,23.9 55.58,22 70.6,22 71.27,22.66 75.44,22.66 75.63,22.85 77.76,22.85 78.01,23.1 81.07,23.1 81.77,23.8 85.23,23.8 85.84,24.41 90.66,24.41 91.65,23.42 96.5,23.42 98.14,25.07 110.05,25.07 110.64,25.66 116.23,25.66 116.82,25.07 119.94,25.07 120.65,25.78 131.18,25.78 131.66,25.3 140.01,25.3 140.58,25.87 152.98,25.87 154.18,24.66 154.46,24.66 155.77,23.35 161.25,23.35 161.82,23.92 167.77,23.92 168.12,23.58 170.6,23.58 171.4,24.38 174.14,24.38 174.58,24.81 175.23,24.81 v2(176.57,26.15)
USB_CHARGE_ON: length 187.8
  TOP w0.102: v2(179.46,26.22) 179.89,26.66 179.89,27.67 180.38,28.16 U13.96 ; U7.5 22.28,47.88 22.49,47.66 R234.1 23.2,47.46 23.56,47.1 v2(24.19,47.1)
  IN2 w0.089: v2(24.19,47.1) 24.7,47.1 27.11,44.69 27.11,42.04 28.61,40.55 28.61,29.3 31.85,26.06 39.03,26.06 39.98,25.11 41.53,25.11 42.18,25.77 46.72,25.77 46.91,25.58 52.91,25.58 53.87,24.62 59.23,24.62 60.75,23.1 70.9,23.1 71.03,23.23 75.2,23.23 75.39,23.42 77.52,23.42 78.47,24.37 84.99,24.37 86.56,25.93 88.07,25.93 88.64,25.36 91.06,25.36 92.04,24.38 96.1,24.38 97.75,26.02 109.48,26.02 110.68,27.22 115.54,27.22 115.73,27.03 120.54,27.03 120.84,26.73 131.85,26.73 132.32,26.26 139.36,26.26 141.08,27.97 143.06,27.97 144.03,27.01 153.45,27.01 154.66,25.81 154.94,25.81 155.91,24.83 158.65,24.83 159.76,25.94 165.47,25.94 165.86,26.33 167.63,26.33 168.21,25.75 169.22,25.75 169.67,25.3 170.23,25.3 170.55,24.98 173.13,24.98 174.96,26.8 175.39,26.8 175.62,27.03 177.52,27.03 178.33,26.22 v2(179.46,26.22)
USB_CLT1: length 190.2
  TOP w0.102: U13.79 180.06,21.36 v2(179.39,20.69) ; v2(24.32,49.01) 24.19,48.88 v2(24.19,48.37) 24.19,48.38 U7.6
  IN2 w0.089: v2(24.19,48.37) 23.79,47.97 23.79,45.7 24.65,44.84 25.14,44.84 25.89,44.09 25.89,43.12 26.29,42.72 26.29,41.59 27.84,40.04 27.84,30.31 27.42,29.89 27.42,26.4 28.07,25.76 30.49,25.76 31.5,24.75 38.72,24.75 39.5,23.97 43.57,23.97 44.03,24.43 50.36,24.43 53.56,21.23 67.79,21.23 68.3,20.72 80.36,20.72 82.29,22.66 88.45,22.66 91.45,21.41 92.06,20.8 94.43,20.8 95.52,21.89 96.58,21.89 98.05,23.35 120.46,23.35 121.74,24.64 125.29,24.64 125.91,24.01 130.4,24.01 130.55,24.16 144.16,24.16 146.8,21.52 155.06,21.52 155.38,21.2 161.54,21.2 162.17,21.83 162.76,21.83 163.08,22.15 163.38,22.15 163.57,21.97 165.19,21.97 165.32,22.1 167.46,22.1 167.95,22.59 170.31,22.59 171.15,21.75 176.17,21.75 177.23,20.69 v2(179.39,20.69)
USB_HUB_5V: length 2.4
  BOTTOM w0.102: TP2089.1 100.34,84.84 U2033.27
USB_OC0#: length 18.6
  TOP w0.102: v2(17.59,49.14) 17.83,49.38 U7.13
  IN1 w0.089: v2(21.91,34.78) 21.78,34.91 21.78,36.31 21.91,36.44 21.91,37.71 21.27,38.34 21.02,38.34 20.38,38.98 20.38,39.99 19.24,41.13 19.24,42.02 17.59,43.67 v2(17.59,49.14)
  BOTTOM w0.102: D8511.1 21.52,33.89 21.91,34.28 v2(21.91,34.78)
USB_OC1#: length 9.1
  BOTTOM w0.102: D8512.1 21.92,39.74 21.3,40.37 19.7,40.37 19.37,40.7 19.37,42.66 20,43.29 20,44.56 19.43,45.13 U28.3
USB_OC2#: length 1.6
  TOP w0.102: D8513.1 v2(212.79,23.48)
  BOTTOM w0.102: U35.3 212.41,23.1 v2(212.79,23.48)
USB_OCP_ALL#: length 249.5
  TOP w0.102: R6650.2 98.94,37.86 v1(97.85,37.86) ; D8513.2 209.73,22.8 210.07,22.47 211.75,22.47 212.13,22.08 212.13,21.4 v2(212.02,21.3)
  IN2 w0.089: v2(188.48,25.84) 188.48,27.2 185.49,30.19 182.95,30.19 182.52,29.76 181.71,29.76 181.24,29.28 175.21,29.28 173.15,27.22 169.34,27.22 169.01,26.89 168.68,26.89 167.49,28.08 165.66,28.08 164.85,27.27 156.84,27.27 155.77,28.34 144.65,28.34 143.68,29.31 140.02,29.31 139.7,28.99 137.76,28.99 135.98,27.21 132.72,27.21 131.61,28.32 121.53,28.32 119.7,30.15 113.09,30.15 110.86,32.37 109.56,32.37 105.62,36.31 105.6,36.31 103.72,38.19 102.83,38.19 102.42,38.59 98.59,38.59 v1(97.85,37.86)
  IN3 w0.089: v1(97.12,49.52) 97.62,49.01 97.98,49.01 98.29,48.7 98.29,46.79 98.49,46.6 98.49,42.4 97.85,41.77 v1(97.85,37.86) 97.85,35.37 98.49,34.74 98.49,31.72 97.47,30.7 97.47,29.7 93.01,25.25 89.1,25.25 88.16,24.31 83.48,24.31 81.83,22.66 72.68,22.66 72.01,23.33 63.71,23.33 60.77,26.28 52.13,26.28 50.97,27.44 47.78,27.44 44.43,30.78 31.24,30.78 30.19,31.84 v2(29.14,31.84) ; v2(188.48,25.84) 188.71,25.61 192.25,25.61 192.82,25.05 192.82,24.17 192.96,24.02 192.96,22.8 198.04,17.73 198.04,16.99 198.66,16.36 203.71,16.36 205.14,17.79 206.03,17.79 208.47,20.23 211.57,20.23 212.02,20.69 v2(212.02,21.3)
  BOTTOM w0.102: D8511.2 21.4,36.92 21.92,37.44 D8512.2 22.68,37.44 25.59,34.53 25.59,34.15 26.99,32.75 28.23,32.75 v2(29.14,31.84) ; v1(97.12,49.52) 96.84,49.52 96.53,49.82 96.53,50.33 96.11,50.75 U2030.AK10
USBON#: length 229.6
  TOP w0.102: v2(177.84,26.15) 177.84,26.5 178.82,27.48 U13.99
  IN2 w0.089: v2(25.36,45.86) 26.92,44.3 26.92,41.96 28.41,40.47 28.41,29.22 31.77,25.87 38.95,25.87 39.9,24.92 41.6,24.92 42.26,25.58 46.65,25.58 46.84,25.39 52.84,25.39 53.87,24.36 53.87,23.98 55.65,22.19 70.52,22.19 71.19,22.85 75.36,22.85 75.55,23.04 77.68,23.04 77.93,23.29 80.99,23.29 81.69,23.99 85.15,23.99 85.76,24.6 90.74,24.6 91.73,23.61 96.42,23.61 98.07,25.26 109.97,25.26 110.56,25.85 116.31,25.85 116.9,25.26 119.86,25.26 120.57,25.97 131.26,25.97 131.73,25.49 139.93,25.49 140.5,26.06 153.06,26.06 154.26,24.85 154.54,24.85 155.79,23.61 161.19,23.61 161.7,24.12 167.84,24.12 168.2,23.77 170.53,23.77 171.32,24.57 173.85,24.57 175.52,26.24 175.52,26.66 175.7,26.84 177.14,26.84 v2(177.84,26.15) 178.16,25.82 183.29,25.82 183.82,26.35 186.92,26.35 188.09,25.18 191.09,25.18 191.87,24.4 v2(192.14,24.4)
  IN3 w0.089: v2(192.14,24.4) 192.63,23.91 192.63,21.87 197.24,17.26 197.24,16.84 198.38,15.69 203.99,15.69 205.16,16.86 205.63,16.86 207.38,18.61 210.94,18.61 211.72,19.39 211.9,19.39 v2(212.74,20.23)
  BOTTOM w0.102: U28.4 22.22,45.13 22.95,45.86 v2(25.36,45.86) ; U35.4 212.61,20.1 v2(212.74,20.23)
USBP0+: length 1.7
  TOP w0.102: R486.2 11.54,11.42 11.62,11.34 12.28,11.34 12.41,11.47 R77836.1
USBP0+_R: length 135
  TOP w0.102: R77836.2 v2(12.86,11.22)
  IN1 w0.089: v2(12.86,11.22) 12.86,10.84 13.01,10.69 13.43,10.69 14.13,9.99 16.6,9.99 20.29,13.68 22.68,13.68 24.09,15.09 24.09,18.62 26.62,21.16 30.95,21.16 31.74,21.95 46.87,21.95 48.11,20.71 52.39,20.71 52.59,20.92 61.76,20.92 62.19,21.35 64.73,21.35 65.11,21.73 76.98,21.73 78.17,22.92 88.27,22.92 92.9,27.55 92.9,27.95 94.19,29.25 94.19,29.49 94.87,30.16 95.21,30.16 97.01,31.96 97.01,34.75 97.75,35.49 97.75,36.18 99.78,38.21 101.3,38.21 103.9,40.81 103.9,46.73 104.71,47.55 104.71,48.63 106.61,50.53 106.61,54.05 104.87,55.79 101.65,55.79 100.77,54.9 99.34,54.9 99.1,55.15 99.1,55.34 v1(98.93,55.51)
  BOTTOM w0.102: U2030.AE7 98.51,55.38 98.64,55.51 v1(98.93,55.51)
USBP0-: length 1.6
  TOP w0.102: R489.2 11.54,10.96 11.67,11.09 12.28,11.09 12.41,10.96 R77837.1
USBP0-_R: length 135.1
  TOP w0.102: v2(12.86,10.05) R77839.2
  IN1 w0.089: v2(12.86,10.05) 12.86,10.36 12.96,10.46 13.34,10.46 14.03,9.77 16.7,9.77 20.38,13.45 22.77,13.45 24.32,15 24.32,18.53 26.72,20.93 31.04,20.93 31.84,21.72 46.77,21.72 48.01,20.48 52.48,20.48 52.68,20.69 61.85,20.69 62.29,21.12 64.83,21.12 65.21,21.5 77.08,21.5 78.26,22.69 88.36,22.69 93.13,27.45 93.13,27.86 94.42,29.15 94.42,29.4 94.96,29.93 95.3,29.93 97.24,31.87 97.24,34.66 97.98,35.39 97.98,36.09 99.88,37.98 101.39,37.98 104.13,40.72 104.13,46.64 104.94,47.45 104.94,48.53 106.84,50.44 106.84,54.14 104.97,56.02 101.56,56.02 100.67,55.13 99.44,55.13 99.33,55.24 99.33,55.32 v1(99.51,55.51)
  BOTTOM w0.102: v1(99.51,55.51) 99.21,55.2 U2030.AE6
USBP1+: length 105.6
  TOP w0.102: v2(21.37,46.03) R252.1
  IN1 w0.089: v1(96.68,53.53) 96.86,53.35 96.86,53.22 96.77,53.13 96.39,53.13 96.09,52.84 96.09,52.48 95.99,52.38 95.99,51.34 95.69,51.04 94.73,51.04 93.43,49.73 93.43,45.03 92.38,43.99 92.38,42.14 91.15,40.91 91.15,40.14 89.24,35.53 88.53,34.67 88.32,34.53 87.69,34.53 86.04,32.88 83.81,32.88 81.72,30.79 81.72,29.65 80.43,28.36 74.43,28.36 74.1,28.69 59.88,28.69 59.52,28.33 55.64,28.33 54.78,27.46 53.95,27.46 53.2,28.21 51.4,28.21 50.22,29.4 36.12,29.4 33.7,31.82 33.07,31.82 30.8,34.09 30.8,38 23.78,45.02 21.56,45.02 21.37,45.21 v2(21.37,46.03)
  BOTTOM w0.102: U2030.AG10 96.21,53.01 96.68,53.48 v1(96.68,53.53)
USBP1+_C: length 2.9
  TOP w0.102: R217.1 20.92,51.94 20.79,52.07 20.4,52.07 20.13,51.81 20.13,51.04 20.38,50.79 U7.10
USBP1+_C_R: length 13.1
  TOP w0.102: R218.1 21.97,51.54 22.16,51.54 22.26,51.64 22.26,51.96 22.39,52.08 24.19,52.08 25.08,51.19 25.08,46.55 23.48,44.94 21.95,44.94 21.82,45.07 R252.2
USBP1+_C_R_N: length 16.6
  TOP w0.102: v2(19.83,56.58) 19.63,56.37 17.43,56.37 U5.7 17.21,56.37 16.19,56.37 v2(16.01,56.55) ; R217.2 v2(21.37,51.09)
  IN3 w0.089: v2(21.37,51.09) R217.2 21.25,51.79 20.58,51.79 18.88,53.49 18.88,55.96 19.3,56.37 19.63,56.37 v2(19.83,56.58) ; CN5.3 15.17,54.01 15.29,54.01 16.67,55.39 16.67,56.11 16.44,56.35 16.22,56.35 v2(16.01,56.55)
USBP1+_U14: length 3.1
  TOP w0.102: R247.2 20.92,45.12 20.79,44.99 20.4,44.99 20.13,45.26 20.13,46.22 20.38,46.46 U7.3
USBP1-: length 105.7
  TOP w0.102: v2(21.37,43.98) R246.1
  IN1 w0.089: v1(97.24,53.53) 97.09,53.37 97.09,53.13 96.87,52.91 96.49,52.91 96.32,52.74 96.32,52.39 96.22,52.28 96.22,51.24 95.79,50.81 94.83,50.81 93.66,49.64 93.66,44.94 92.61,43.9 92.61,42.05 91.37,40.81 91.37,40.09 89.81,36.31 89.43,35.41 88.69,34.5 88.39,34.3 87.79,34.3 86.14,32.65 83.91,32.65 81.95,30.69 81.95,29.55 80.53,28.13 74.34,28.13 74.01,28.46 59.97,28.46 59.61,28.1 55.73,28.1 54.87,27.24 53.86,27.24 53.11,27.99 51.31,27.99 50.13,29.17 36.02,29.17 33.6,31.59 32.97,31.59 30.57,34 30.57,37.91 23.68,44.79 21.48,44.79 21.37,44.68 v2(21.37,43.98)
  BOTTOM w0.102: U2030.AG9 97.24,53.34 v1(97.24,53.53)
USBP1-_C: length 2.9
  TOP w0.102: R210.1 20.81,52.32 20.29,52.32 19.88,51.91 U7.11
USBP1-_C_R: length 13.1
  TOP w0.102: R251.2 21.95,44.69 23.58,44.69 25.33,46.44 25.33,51.29 24.29,52.34 21.93,52.34 R211.1
USBP1-_C_R_N: length 16.6
  TOP w0.102: v2(19.83,55.94) 19.66,56.12 19.16,56.12 U5.4 19.09,56.12 16.22,56.12 v2(16.01,55.92) ; R210.2 v2(21.37,53.02)
  IN3 w0.089: v2(21.37,53.02) 21.37,52.11 21.28,52.02 20.67,52.02 19.11,53.58 19.11,55.87 19.39,56.15 19.63,56.15 v2(19.83,55.94) ; CN5.2 14.35,55.19 14.35,54.37 14.47,54.24 15.2,54.24 16.44,55.49 16.44,56.02 16.34,56.12 16.22,56.12 v2(16.01,55.92)
USBP1-_U14: length 3.2
  TOP w0.102: R246.2 20.74,44.74 20.29,44.74 19.88,45.16 U7.2
USBP2+: length 111
  TOP w0.102: R298.2 23.53,36.05 26.33,36.05 v2(26.38,36.1)
  IN1 w0.089: v2(26.38,36.1) 26.11,35.83 25.98,35.83 25.72,35.57 25.72,33.83 26.38,33.16 28.51,33.16 30.69,30.98 30.69,28.98 32.89,26.79 41.84,26.79 42.73,25.89 49.84,25.89 50.27,25.46 52.62,25.46 52.89,25.19 55.72,25.19 56.11,25.58 56.72,25.58 57.19,26.05 75.66,26.05 75.68,26.08 82.99,26.08 86.13,29.21 87.08,29.21 89.34,31.48 89.34,32.15 93.33,36.14 93.33,38.8 93.95,39.43 93.95,39.96 95.86,41.87 96.27,41.87 98.54,44.14 98.54,45.97 99.63,47.06 99.63,50.59 99.93,50.89 100.37,50.89 100.75,51.27 100.75,53.81 100.43,54.13 95.65,54.13 95.41,54.37 95.12,54.37 v1(94.96,54.52)
  BOTTOM w0.102: U2030.AF12 94.51,54.07 v1(94.96,54.52)
USBP2+_C: length 11.7
  TOP w0.102: v2(15.99,36.13) 16.19,35.93 16.72,35.93 16.97,36.18 17.85,36.18 U11.7 18.07,36.18 20.23,36.18 20.5,35.91 22.68,35.91 R298.1
  IN1 w0.089: v2(15.99,36.13) 16.19,35.93 16.41,35.93 16.64,35.7 16.64,34.91 15.78,34.05 15.21,34.05 CN7.3
USBP2-: length 111
  TOP w0.102: R293.2 23.4,35.67 23.53,35.8 26.05,35.8 v2(26.38,35.47)
  IN1 w0.089: v2(26.38,35.47) 26.25,35.6 26.07,35.6 25.94,35.47 25.94,33.92 26.48,33.39 28.61,33.39 30.92,31.07 30.92,29.07 32.98,27.02 41.93,27.02 42.83,26.12 49.93,26.12 50.37,25.69 52.71,25.69 52.98,25.42 55.62,25.42 56.02,25.81 56.62,25.81 57.09,26.28 75.56,26.28 75.59,26.31 82.9,26.31 86.03,29.44 86.98,29.44 89.11,31.58 89.11,32.24 93.1,36.23 93.1,38.9 93.72,39.52 93.72,40.05 95.77,42.1 96.17,42.1 98.31,44.23 98.31,46.07 99.4,47.16 99.4,50.68 99.84,51.12 100.28,51.12 100.52,51.36 100.52,53.71 100.33,53.9 95.56,53.9 95.32,54.14 94.85,54.14 94.69,53.99 94.69,53.77 v1(94.96,53.51)
  BOTTOM w0.102: v1(94.96,53.51) 94.86,53.61 94.86,53.91 95.05,54.09 95.23,54.09 U2030.AF11
USBP2-_C: length 11.7
  TOP w0.102: v2(15.99,35.5) 16.17,35.67 16.83,35.67 17.08,35.93 19.72,35.93 U11.4 19.79,35.93 20.13,35.93 20.39,35.66 22.68,35.66 R293.1
  IN1 w0.089: CN7.2 14.6,34.43 14.75,34.28 15.68,34.28 16.41,35 16.41,35.61 16.32,35.7 16.19,35.7 v2(15.99,35.5)
USBP3+: length 146
  IN1 w0.089: v1(96.69,55.51) 96.88,55.7 96.88,55.92 97.08,56.12 100.51,56.12 101.13,56.73 105.24,56.73 107.61,54.37 107.61,50.18 105.73,48.3 105.73,47.25 105.11,46.64 105.11,42.26 105.47,41.9 105.47,37.14 105.7,36.91 105.7,35.64 106.61,34.73 106.61,34.15 107.48,33.29 107.48,31.83 107.63,31.68 107.63,26.29 108.24,24.81 112.61,20.45 123.74,20.45 124.06,20.13 128.2,20.13 128.56,20.49 134.89,20.49 135.48,21.07 148.83,21.07 149.85,22.08 154.54,22.08 155.48,23.02 158.13,23.02 158.66,23.56 164.88,23.56 166,22.44 167.45,22.44 167.56,22.54 168.92,22.54 170.51,20.95 175.19,20.95 175.96,20.17 181.55,20.17 182.76,18.96 186.74,18.96 186.97,18.72 186.97,18.5 v2(187.18,18.3)
  BOTTOM w0.102: CN9.3 184.18,30.63 184.28,30.53 184.76,30.53 185.96,29.33 185.96,28.23 187.79,26.4 187.79,25.79 188.12,25.46 188.12,23.54 188.93,22.73 188.93,20.77 188.31,20.15 188.31,19.44 v2(187.18,18.3) ; U2030.AE10 96.61,55.51 v1(96.69,55.51)
USBP3-: length 146
  IN1 w0.089: v1(97.3,55.51) 97.11,55.7 97.11,55.82 97.18,55.89 100.61,55.89 101.22,56.5 105.15,56.5 107.38,54.27 107.38,50.28 105.5,48.4 105.5,47.35 104.88,46.73 104.88,42.16 105.24,41.8 105.24,37.04 105.47,36.82 105.47,35.55 106.39,34.63 106.39,34.05 107.25,33.19 107.25,31.74 107.4,31.58 107.4,26.24 108.05,24.68 112.51,20.22 123.65,20.22 123.97,19.9 128.3,19.9 128.65,20.26 134.99,20.26 135.57,20.84 148.92,20.84 149.94,21.86 154.64,21.86 155.58,22.8 158.22,22.8 158.75,23.33 164.79,23.33 165.91,22.21 167.55,22.21 167.65,22.31 168.82,22.31 170.41,20.72 175.09,20.72 175.87,19.94 181.46,19.94 182.67,18.73 186.64,18.73 186.75,18.63 186.75,18.5 v2(186.54,18.3)
  BOTTOM w0.102: U2030.AE9 97.2,55.01 97.4,55.21 97.4,55.41 v1(97.3,55.51) ; v2(186.54,18.3) 186.45,18.3 186.32,18.43 186.32,18.66 186.61,18.95 186.84,18.95 187.01,18.78 187.3,18.78 188.06,19.54 188.06,20.26 188.68,20.88 188.68,22.63 187.87,23.44 187.87,25.36 187.54,25.69 187.54,26.3 185.71,28.13 185.71,29.22 184.65,30.28 184.28,30.28 184.13,30.13 CN9.5
USBP4+_DB: length 178.2
  IN1 w0.089: v1(96.69,56.51) 96.88,56.7 96.88,56.92 97.11,57.14 99.82,57.14 99.98,56.98 100.3,56.98 100.75,57.44 106.25,57.44 107.5,56.2 107.5,55.46 108.3,54.66 108.3,49.87 106.46,48.02 106.46,46.87 105.81,46.23 105.81,42.64 106.52,41.93 106.52,35.85 107.62,34.75 107.62,34.23 108.17,33.68 108.17,32.36 108.65,31.89 108.65,26.2 109.22,24.83 112.9,21.15 120.53,21.15 120.78,21.4 128.6,21.4 128.71,21.51 131.06,21.51 131.48,21.93 138.64,21.93 138.8,21.78 148.32,21.78 150.1,23.56 154.75,23.56 155.05,23.86 157.79,23.86 158.23,24.29 165.7,24.29 166.28,23.71 167.73,23.71 168.18,23.25 169.27,23.25 170.88,21.65 175.63,21.65 176.33,20.95 177.49,20.95 177.86,21.32 181.67,21.32 183.32,19.67 188.09,19.67 188.73,19.04 191.4,19.04 194.59,15.84 194.59,14.54 194.93,14.2 199.66,14.2 199.92,14.46 206.31,14.46 207.64,15.8 207.64,16.34 212.46,21.16 212.46,21.9 212.05,22.31 212.05,26.27 212.79,27 212.79,33.06 212.66,33.19 212.66,35.09 212.49,35.26 212.31,35.26 v2(212.06,35.01)
  BOTTOM w0.102: U2030.AD9 96.63,56.01 96.5,56.14 96.5,56.32 v1(96.69,56.51) ; v2(212.06,35.01) 212.08,35.01 212.47,35.4 CN6.16
USBP4-_DB: length 178.2
  IN1 w0.089: v2(212.06,35.64) 212.21,35.49 212.58,35.49 212.89,35.18 212.89,33.29 213.02,33.16 213.02,26.91 212.28,26.17 212.28,22.41 212.69,22 212.69,21.06 207.87,16.24 207.87,15.7 206.4,14.24 200.01,14.24 199.75,13.98 194.84,13.98 194.37,14.44 194.37,15.74 191.3,18.81 188.63,18.81 188,19.44 183.23,19.44 181.58,21.09 177.96,21.09 177.58,20.72 176.24,20.72 175.54,21.42 170.78,21.42 169.18,23.02 168.09,23.02 167.63,23.48 166.18,23.48 165.6,24.07 158.32,24.07 157.88,23.63 155.14,23.63 154.84,23.33 150.19,23.33 148.42,21.55 138.7,21.55 138.55,21.7 131.58,21.7 131.16,21.29 128.81,21.29 128.7,21.17 120.88,21.17 120.62,20.92 112.8,20.92 109.02,24.7 108.42,26.15 108.42,31.79 107.94,32.27 107.94,33.58 107.39,34.14 107.39,34.66 106.29,35.76 106.29,41.84 105.58,42.55 105.58,46.32 106.23,46.97 106.23,48.11 108.08,49.96 108.08,54.56 107.27,55.37 107.27,56.1 106.16,57.21 100.85,57.21 100.39,56.76 99.88,56.76 99.73,56.91 97.2,56.91 97.11,56.82 97.11,56.7 v1(97.3,56.51)
  BOTTOM w0.102: v2(212.06,35.64) 212.31,35.9 CN6.15 ; U2030.AD8 97.71,56.1 v1(97.3,56.51)
USBP5+_CAM: length 127.3
  TOP w0.102: R77838.1 13.31,11.4 13.4,11.31 13.73,11.31 v2(13.92,11.5)
  IN1 w0.089: v2(46.72,103.47) 46.52,103.26 45.99,103.26 43.9,101.17 43.9,99.39 42.49,97.99 40.14,97.99 37.05,94.89 25.18,94.89 21.02,90.72 21.02,86.12 22.31,84.83 22.31,82.12 21.88,81.69 21.88,76.51 21.63,76.26 21.63,74.05 23.71,71.97 23.71,70.7 24.58,69.83 24.58,55.36 24.72,55.22 24.72,49.79 21.75,46.82 20.92,46.82 20.08,45.98 20.08,41.74 23.07,38.75 23.07,31.58 22.22,30.72 20.64,30.72 20.38,30.97 18.73,30.97 17.74,29.98 17.74,22.36 16.45,21.07 16.45,15.36 14.41,13.32 14.41,11.43 14.29,11.3 14.12,11.3 v2(13.92,11.5)
  BOTTOM w0.102: R522.2 47.18,104.63 47.05,104.51 46.77,104.51 46.26,104 46.26,103.47 46.42,103.32 46.57,103.32 v2(46.72,103.47)
USBP5+_CAM_C: length 12.9
  BOTTOM w0.102: R77848.1 40.8,114.16 41.13,114.16 41.6,113.69 41.6,112.38 42.18,111.81 43.46,111.81 47.12,108.14 47.12,107.74 47.22,107.64 CN2.8 47.22,106.53 47.1,106.4 47.1,105.95 46.92,105.78 46.92,105.49 R522.1
USBP5+_CAM_HUB: length 83.9
  IN3 w0.089: v2(41.36,99.96) 41.51,100.11 43.25,100.11 44.9,98.46 51.74,98.46 52.15,98.87 59.48,98.87 60.04,98.31 63.66,98.31 65.8,96.18 67.11,96.18 69.66,93.63 73.41,93.63 74.19,92.86 81.04,92.86 82.57,91.33 85.54,91.33 87.72,89.15 91.95,89.15 93.87,87.23 93.87,82.38 94.25,82.01 v2(94.25,81.11)
  BOTTOM w0.102: R77848.2 40.22,114 40.16,113.93 39.75,113.93 39.41,113.59 39.41,109.81 39.94,109.28 39.94,106.77 39.43,106.26 39.43,100.85 40.15,100.13 41.2,100.13 v2(41.36,99.96) ; U2033.7 95.21,82.79 95.08,82.66 94.83,82.66 94.46,82.29 94.46,81.33 v2(94.25,81.11)
USBP5-_CAM: length 127.3
  TOP w0.102: v2(13.92,10.87) 13.73,11.06 13.43,11.06 13.31,10.94 R77839.1
  IN1 w0.089: v2(46.72,102.83) 46.52,103.03 46.09,103.03 44.13,101.08 44.13,99.3 42.59,97.76 40.24,97.76 37.14,94.66 25.28,94.66 21.25,90.63 21.25,86.22 22.54,84.92 22.54,82.03 22.11,81.6 22.11,76.41 21.86,76.16 21.86,74.15 23.94,72.06 23.94,70.79 24.81,69.92 24.81,55.45 24.95,55.31 24.95,49.69 21.85,46.6 21.02,46.6 20.31,45.89 20.31,41.84 23.3,38.85 23.3,31.48 22.31,30.49 20.54,30.49 20.29,30.75 18.83,30.75 17.97,29.89 17.97,22.27 16.68,20.98 16.68,15.26 14.64,13.23 14.64,11.33 14.38,11.07 14.12,11.07 v2(13.92,10.87)
  BOTTOM w0.102: R521.2 46.42,104.51 46.01,104.11 46.01,103.37 46.31,103.06 46.49,103.06 v2(46.72,102.83)
USBP5-_CAM_C: length 12.8
  BOTTOM w0.102: R521.1 46.67,105.49 46.67,105.88 46.85,106.06 46.85,106.4 46.72,106.53 CN2.7 46.72,107.59 46.87,107.74 46.87,108.04 43.35,111.56 42.07,111.56 41.35,112.28 41.35,113.58 41.03,113.91 40.73,113.91 40.67,113.85 R77849.1
USBP5-_CAM_HUB: length 83.9
  IN3 w0.089: v2(41.36,100.6) 41.36,100.47 41.49,100.34 43.34,100.34 44.99,98.69 51.65,98.69 52.06,99.1 59.57,99.1 60.13,98.54 63.76,98.54 65.89,96.4 67.21,96.4 69.75,93.86 73.51,93.86 74.28,93.09 81.14,93.09 82.66,91.56 85.63,91.56 87.81,89.37 92.05,89.37 94.1,87.32 94.1,82.48 94.47,82.1 94.47,81.67 94.6,81.55 94.87,81.55 94.99,81.42 94.99,81.23 v2(94.88,81.11)
  BOTTOM w0.102: R77849.2 40.07,113.68 39.85,113.68 39.66,113.48 39.66,109.92 40.19,109.38 40.19,106.67 39.69,106.16 39.69,100.95 40.26,100.38 41.15,100.38 v2(41.36,100.6) ; U2033.6 95.71,82.81 95.31,82.41 94.94,82.41 94.72,82.19 94.72,81.28 v2(94.88,81.11)
USBP7+_FP: length 19.8
  IN1 w0.089: v2(97.42,78.88) 97.6,78.7 97.78,78.7 97.9,78.83 97.9,82.29 97.15,83.04 95.69,83.04 93.69,85.05 93.69,87.56 91.02,90.23 91.02,90.77 90.74,91.05 89.56,91.05 89.41,90.89 89.41,90.73 89.55,90.59 v2(89.9,90.59)
  BOTTOM w0.102: v2(97.42,78.88) 97.47,78.93 R77840.1 ; v2(89.9,90.59) 89.85,90.54 R77844.1
USBP7+_FP_APU: length 34.1
  IN3 w0.089: v2(98.53,77.58) 98.53,77.67 98.33,77.87 98.01,77.87 97.36,77.21 96.47,77.21 95.95,76.69 95.95,73.82 94.65,72.53 94.65,66.13 93.76,65.24 93.76,63.38 94.3,62.85 94.3,59.11 94.5,58.91 94.5,52.23 94.73,52 95.12,52 95.25,52.12 95.25,52.33 95.12,52.46 v1(94.94,52.46)
  BOTTOM w0.102: v1(94.94,52.46) 94.94,52.14 94.81,52.01 U2030.AJ12 ; v2(98.53,77.58) 98.21,77.9 98.1,77.9 97.85,78.15 97.85,79.74 97.72,79.87 R77842.2
