# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
NGFF-NASM0-S6701-TSH4-KM-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
O-Z8E-1P2
  custom 1.625x1.625 hole 2.591: 1(0,0)
POWER-3X3-65-5P-ADNR21357
  rect 0.508x0.356 smd: 1(1.4,-0.975) 2(1.4,-0.325) 3(1.4,0.325) 4(1.4,0.975)
  custom 0.57x0.57 smd: 5(0,0)
POWER-5_2X5_55-1_27-5P
  rect 0.66x0.508 smd: 1(2.755,-1.905) 2(2.755,-0.635) 3(2.755,0.635) 4(2.755,1.905)
  custom 1.15x1.15 smd: 5(0,0)
POWER-5_67X4_8-1_27-5P
  rect 0.94x0.61 smd: 1(2.875,-1.905) 2(2.875,-0.635) 3(2.875,0.635) 4(2.875,1.905)
  custom 1.138x1.138 smd: 5(0,0)
POWER-5X6-1_27-7P-0_8H
  rect 0.66x0.635 smd: 1(-1.905,-2.84) 5(1.905,2.84) 6(0.635,2.84) 7(-0.635,2.84) 8(-1.905,2.84)
  custom 0.488x0.488 smd: 2(0,-2.18)
  rect 3.988x2.667 smd: 9(0,0.795)
POWER-5X6-1_27-10P
  rect 0.61x0.61 smd: 1(-1.905,-2.75) 2(-0.635,-2.75) 3(0.635,-2.75) 4(1.905,-2.75) 5(1.905,2.75) 6(0.635,2.75) 7(-0.635,2.75)
  rect 0.61x1.676 smd: 8(-1.905,2.21)
  rect 4.191x1.041 smd: 9(0,-1.535)
  custom 0.617x0.617 smd: 10(0,0)
PWQFN20-4X4-5-26P-0_8H
  rect 0.279x0.991 smd: 1(-1,-1.9) 2(-0.5,-1.9) 3(0,-1.9) 4(0.5,-1.9) 5(1,-1.9) 11(1,1.9) 12(0.5,1.9) 13(0,1.9) 14(-0.5,1.9) 15(-1,1.9)
  rect 0.991x0.279 smd: 6(1.9,-1) 7(1.9,-0.5) 8(1.9,0) 9(1.9,0.5) 10(1.9,1) 16(-1.9,1) 17(-1.9,0.5) 18(-1.9,0) 19(-1.9,-0.5) 20(-1.9,-1)
  rect 2.159x2.159 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-0.75,-0.75) 23(0.75,-0.75) 24(0.75,0.75) 25(-0.75,0.75) 26(0,0)
QFN12-1_25X2_1-4
  rect 0.203x0.889 smd: 1(-0.8,-0.775) 2(-0.4,-0.775) 3(0,-0.775) 4(0.4,-0.775) 5(0.8,-0.775) 7(0.8,0.775) 8(0.4,0.775) 9(0,0.775) 10(-0.4,0.775) 11(-0.8,0.775)
  rect 1.194x0.254 smd: 6(1.05,0) 12(-1.05,0)
QFN12-3X3-45-0_6H
  rect 0.229x0.787 smd: 1(-0.619,-1.5) 6(-0.619,1.5)
  rect 0.229x1.346 smd: 2(0.101,-1.225) 3(1.001,-1.225)
  rect 0.229x2.286 smd: 4(0.551,0.76)
  rect 0.229x2.261 smd: 5(-0.169,0.76)
  rect 0.787x0.229 smd: 7(-1.5,1.125) 8(-1.5,0.675) 9(-1.5,0.225) 10(-1.5,-0.225) 11(-1.5,-0.675) 12(-1.5,-1.125)
QFN16-3X3-5-17P-TPS2546RTER
  rect 0.305x0.991 smd: 1(-0.75,-1.6) 2(-0.25,-1.6) 3(0.25,-1.6) 4(0.75,-1.6) 9(0.75,1.6) 10(0.25,1.6) 11(-0.25,1.6) 12(-0.75,1.6)
  rect 0.991x0.305 smd: 5(1.6,-0.75) 6(1.6,-0.25) 7(1.6,0.25) 8(1.6,0.75) 13(-1.6,0.75) 14(-1.6,0.25) 15(-1.6,-0.25) 16(-1.6,-0.75)
  rect 1.702x1.702 smd: 17(0,0)
QFN18-3X3-5
  custom 0.145x0.145 smd: 1(-1.25,-1.24) 6(1.25,-1.24) 10(1.25,1.24) 15(-1.25,1.24)
  custom 0.062x0.062 smd: 2(-0.75,-1.4) 3(-0.25,-1.4) 4(0.25,-1.4) 5(0.75,-1.4) 11(0.75,1.4) 12(0.25,1.4) 13(-0.25,1.4) 14(-0.75,1.4)
  custom 0.05x0.05 smd: 7(0.58,-0.45) 8(1.349,0) 9(0.58,0.45) 16(-1.405,0.65) 17(-0.583,0) 18(-1.405,-0.65)
QFN23-4X4-5-25P
  rect 0.254x0.787 smd: 1(-1.25,-2) 2(-0.75,-2) 3(-0.25,-2) 4(0.25,-2) 5(0.75,-2) 6(1.25,-2) 12(1.25,2) 13(0.75,2) 14(0.25,2) 15(-0.25,2) 16(-0.75,2) 17(-1.25,2)
  rect 0.787x0.254 smd: 7(2,-1.25) 8(2,-0.75) 9(2,-0.25) 10(2,0.75) 11(2,1.25) 18(-2,1.25) 19(-2,0.75) 20(-2,0.25) 21(-2,-0.25) 22(-2,-0.75) 23(-2,-1.25)
  rect 2.591x1.295 smd: 24(0,-0.65)
  rect 2.591x0.889 smd: 25(0,0.85)
QFN24-4X4-5-25P-RT9921CGQV
  rect 0.305x0.991 smd: 1(-1.25,-2.1) 2(-0.75,-2.1) 3(-0.25,-2.1) 4(0.25,-2.1) 5(0.75,-2.1) 6(1.25,-2.1) 13(1.25,2.1) 14(0.75,2.1) 15(0.25,2.1) 16(-0.25,2.1) 17(-0.75,2.1) 18(-1.25,2.1)
  rect 0.991x0.305 smd: 7(2.1,-1.25) 8(2.1,-0.75) 9(2.1,-0.25) 10(2.1,0.25) 11(2.1,0.75) 12(2.1,1.25) 19(-2.1,1.25) 20(-2.1,0.75) 21(-2.1,0.25) 22(-2.1,-0.25) 23(-2.1,-0.75) 24(-2.1,-1.25)
  rect 2.515x2.515 smd: 25(0,0)
QFN28-4X4-4-38P
  custom 0.05x0.05 smd: 1(-1.2,-2) 2(-0.8,-2) 3(-0.4,-2) 4(0,-2) 5(0.4,-2) 6(0.8,-2) 7(1.2,-2) 8(2,-1.2) 9(2,-0.8) 10(2,-0.4) 11(2,0) 12(2,0.4) 13(2,0.8) 14(2,1.2) 15(1.2,2) 16(0.8,2) 17(0.4,2) 18(0,2) 19(-0.4,2) 20(-0.8,2) 21(-1.2,2) 22(-2,1.2) 23(-2,0.8) 24(-2,0.4) 25(-2,0) 26(-2,-0.4) 27(-2,-0.8) 28(-2,-1.2)
  rect 2.591x2.591 smd: 29(0,0)
  round 0.508 hole 0.254: 30(-1,-1) 31(0,-1) 32(1,-1) 33(1,0) 34(1,1) 35(0,1) 36(-1,1) 37(-1,0) 38(0,0)
QFN28-5X5-5-29P-GL850G
  rect 0.305x0.991 smd: 1(-1.5,-2.6) 2(-1,-2.6) 3(-0.5,-2.6) 4(0,-2.6) 5(0.5,-2.6) 6(1,-2.6) 7(1.5,-2.6) 15(1.5,2.6) 16(1,2.6) 17(0.5,2.6) 18(0,2.6) 19(-0.5,2.6) 20(-1,2.6) 21(-1.5,2.6)
  rect 0.991x0.305 smd: 8(2.6,-1.5) 9(2.6,-1) 10(2.6,-0.5) 11(2.6,0) 12(2.6,0.5) 13(2.6,1) 14(2.6,1.5) 22(-2.6,1.5) 23(-2.6,1) 24(-2.6,0.5) 25(-2.6,0) 26(-2.6,-0.5) 27(-2.6,-1) 28(-2.6,-1.5)
  rect 3.505x3.505 smd: 29(0,0)
QFN32-4X4-4-33P-0_9H
  custom 0.051x0.051 smd: 1(-1.4,-2.1) 8(1.4,-2.1) 9(2.1,-1.4) 16(2.1,1.4) 17(1.4,2.1) 24(-1.4,2.1) 25(-2.1,1.4) 32(-2.1,-1.4)
  rect 0.203x0.991 smd: 2(-1,-2.1) 3(-0.6,-2.1) 4(-0.2,-2.1) 5(0.2,-2.1) 6(0.6,-2.1) 7(1,-2.1) 18(1,2.1) 19(0.6,2.1) 20(0.2,2.1) 21(-0.2,2.1) 22(-0.6,2.1) 23(-1,2.1)
  rect 0.991x0.203 smd: 10(2.1,-1) 11(2.1,-0.6) 12(2.1,-0.2) 13(2.1,0.2) 14(2.1,0.6) 15(2.1,1) 26(-2.1,1) 27(-2.1,0.6) 28(-2.1,0.2) 29(-2.1,-0.2) 30(-2.1,-0.6) 31(-2.1,-1)
  rect 2.692x2.692 smd: 33(0,0)
QFN32-5X5-5-33P-0_85H
  rect 0.305x0.991 smd: 1(-1.75,-2.6) 2(-1.25,-2.6) 3(-0.75,-2.6) 4(-0.25,-2.6) 5(0.25,-2.6) 6(0.75,-2.6) 7(1.25,-2.6) 8(1.75,-2.6) 17(1.75,2.6) 18(1.25,2.6) 19(0.75,2.6) 20(0.25,2.6) 21(-0.25,2.6) 22(-0.75,2.6) 23(-1.25,2.6) 24(-1.75,2.6)
  rect 0.991x0.305 smd: 9(2.6,-1.75) 10(2.6,-1.25) 11(2.6,-0.75) 12(2.6,-0.25) 13(2.6,0.25) 14(2.6,0.75) 15(2.6,1.25) 16(2.6,1.75) 25(-2.6,1.75) 26(-2.6,1.25) 27(-2.6,0.75) 28(-2.6,0.25) 29(-2.6,-0.25) 30(-2.6,-0.75) 31(-2.6,-1.25) 32(-2.6,-1.75)
  rect 3.505x3.505 smd: 33(0,0)
QFN40-5X5-4-41P-RT3662AC
  rect 0.203x0.838 smd: 1(-1.8,-2.475) 2(-1.4,-2.475) 3(-1,-2.475) 4(-0.6,-2.475) 5(-0.2,-2.475) 6(0.2,-2.475) 7(0.6,-2.475) 8(1,-2.475) 9(1.4,-2.475) 10(1.8,-2.475) 21(1.8,2.475) 22(1.4,2.475) 23(1,2.475) 24(0.6,2.475) 25(0.2,2.475) 26(-0.2,2.475) 27(-0.6,2.475) 28(-1,2.475) 29(-1.4,2.475) 30(-1.8,2.475)
  rect 0.838x0.203 smd: 11(2.475,-1.8) 12(2.475,-1.4) 13(2.475,-1) 14(2.475,-0.6) 15(2.475,-0.2) 16(2.475,0.2) 17(2.475,0.6) 18(2.475,1) 19(2.475,1.4) 20(2.475,1.8) 31(-2.475,1.8) 32(-2.475,1.4) 33(-2.475,1) 34(-2.475,0.6) 35(-2.475,0.2) 36(-2.475,-0.2) 37(-2.475,-0.6) 38(-2.475,-1) 39(-2.475,-1.4) 40(-2.475,-1.8)
  rect 3.404x3.404 smd: 41(0,0)
QFN48-6X6-4-49P-ALC280
  rect 0.203x0.991 smd: 1(-2.2,-3.1) 2(-1.8,-3.1) 3(-1.4,-3.1) 4(-1,-3.1) 5(-0.6,-3.1) 6(-0.2,-3.1) 7(0.2,-3.1) 8(0.6,-3.1) 9(1,-3.1) 10(1.4,-3.1) 11(1.8,-3.1) 12(2.2,-3.1) 25(2.2,3.1) 26(1.8,3.1) 27(1.4,3.1) 28(1,3.1) 29(0.6,3.1) 30(0.2,3.1) 31(-0.2,3.1) 32(-0.6,3.1) 33(-1,3.1) 34(-1.4,3.1) 35(-1.8,3.1) 36(-2.2,3.1)
  rect 0.991x0.203 smd: 13(3.1,-2.2) 14(3.1,-1.8) 15(3.1,-1.4) 16(3.1,-1) 17(3.1,-0.6) 18(3.1,-0.2) 19(3.1,0.2) 20(3.1,0.6) 21(3.1,1) 22(3.1,1.4) 23(3.1,1.8) 24(3.1,2.2) 37(-3.1,2.2) 38(-3.1,1.8) 39(-3.1,1.4) 40(-3.1,1) 41(-3.1,0.6) 42(-3.1,0.2) 43(-3.1,-0.2) 44(-3.1,-0.6) 45(-3.1,-1) 46(-3.1,-1.4) 47(-3.1,-1.8) 48(-3.1,-2.2)
  rect 4.394x4.394 smd: 49(0,0)
R0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
R0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
R0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
R0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
R1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
RC3216
  rect 3.2x0.94 smd: 1(0,0.825) 2(0,-0.825)
RJ45-2RJ1622-001111F-8P
  round 1.295 hole 0.889: 1(3.57,2.3) 2(2.55,3.4) 3(1.53,2.3) 4(0.51,3.4) 5(-0.51,2.3) 6(-1.53,3.4) 7(-2.55,2.3) 8(-3.57,3.4)
  oval 1.803x2.616 hole 0.787x1.6: 9(8.4,-7.8) 10(8.4,0) 11(-8.4,-7.8) 12(-8.4,0)
S0201
  rect 0.343x0.381 smd: 1(-0.225,0) 2(0.225,0)
S0402
  custom 0.125x0.125 smd: 1(0.39,0) 2(-0.39,0)
S0603
  rect 1.041x0.813 smd: 1(0.6,0) 2(-0.6,0)
S0805
  rect 1.346x1.372 smd: 1(0.88,0) 2(-0.88,0)
S1206
  rect 2.032x1.626 smd: 1(1.4,0) 2(-1.4,0)
SC70-2_1-65-6P-0_95H
  rect 0.508x0.406 smd: 1(0.95,-0.65) 2(0.95,0) 3(0.95,0.65) 4(-0.95,0.65) 5(-0.95,0) 6(-0.95,-0.65)
SHORT3720
  rect 3.759x1.537 smd: 1(0,1.008) 2(0,-1.008)
SOIC8-6-1_27-PM25LV010A
  rect 0.533x1.727 smd: 1(-1.905,-2.733) 2(-0.635,-2.733) 3(0.635,-2.733) 4(1.905,-2.733) 5(1.905,2.733) 6(0.635,2.733) 7(-0.635,2.733) 8(-1.905,2.733)
SOIC8-7_9-1_27-2_16H
  rect 0.533x1.549 smd: 1(-1.905,-3.775) 2(-0.635,-3.775) 3(0.635,-3.775) 4(1.905,-3.775) 5(1.905,3.775) 6(0.635,3.775) 7(-0.635,3.775) 8(-1.905,3.775)
SON10-2_5X1-5-0_55H
  rect 0.305x0.559 smd: 1(-1,-0.385) 2(-0.5,-0.385) 4(0.5,-0.385) 5(1,-0.385) 6(1,0.385) 7(0.5,0.385) 9(-0.5,0.385) 10(-1,0.385)
  rect 0.33x0.559 smd: 3(0,-0.385) 8(0,0.385)
SOP8-6-1_27-9P-G5795F11U
  rect 0.406x1.981 smd: 1(-1.905,-3.15) 2(-0.635,-3.15) 3(0.635,-3.15) 4(1.905,-3.15) 5(1.905,3.15) 6(0.635,3.15) 7(-0.635,3.15) 8(-1.905,3.15)
  rect 3.607x2.438 smd: 9(0,0)
SOT23-1_7-65-3P
  rect 0.711x0.432 smd: 1(0.85,0.65) 2(0.85,-0.65) 3(-0.85,0)
SOT23-1_38-5-3P
  rect 0.533x0.381 smd: 1(0.69,0.5) 2(0.69,-0.5) 3(-0.69,0)
SOT23-2-95-3P
  rect 0.711x0.559 smd: 1(1,0.95) 2(1,-0.95) 3(-1,0)
SOT23-2_8-95-5P-G518A1TO1U
  rect 1.194x0.508 smd: 1(1.45,-0.95) 2(1.45,0) 3(1.45,0.95) 4(-1.45,0.95) 5(-1.45,-0.95)
SOT23-2_8-95-5P-LP2985-50DBVT
  rect 1.041x0.61 smd: 1(1.35,-0.95) 2(1.35,0) 3(1.35,0.95) 4(-1.35,0.95) 5(-1.35,-0.95)
SOT23-2_8-95-6P-1_1H
  rect 1.092x0.61 smd: 1(1.35,-0.95) 2(1.35,0) 3(1.35,0.95) 4(-1.35,0.95) 5(-1.35,0) 6(-1.35,-0.95)
SOT23-2_38-95-3P
  rect 0.787x0.533 smd: 1(1.19,0.95) 2(1.19,-0.95) 3(-1.19,0)
SOT23-5-2_8-95-5P-G708
  rect 1.194x0.533 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
SOT353-1-2_125-65-5P
  rect 1.245x0.279 smd: 1(1.045,-0.65) 2(1.045,0) 3(1.045,0.65) 4(-1.045,0.65) 5(-1.045,-0.65)
SOT363-2_1-65-6P
  rect 0.889x0.356 smd: 1(0.8,-0.65) 2(0.8,0) 3(0.8,0.65) 4(-0.8,0.65) 5(-0.8,0) 6(-0.8,-0.65)
SOT363-2_1-65-6P-DMC2004DWK-7
  rect 0.61x0.432 smd: 1(0.95,-0.65) 2(0.95,0) 3(0.95,0.65) 4(-0.95,0.65) 5(-0.95,0) 6(-0.95,-0.65)
SPAD-A3A5-EDADOC-1
  custom 1.275x1.275 smd: 1(0,0)
SPAD-C354NP
  round 8.992 smd: 1(0,0)
SPAD-RE3_5X5_0
  rect 3.5x5 smd: 1(0,0)
SPAD-RE5_98X2_0
  rect 5.98x2 smd: 1(0,0)
SPAD-RE209X315NP
  rect 5.309x8.001 smd: 1(0,0)
SW-NDT016-G1A-KKKT-4P
  round 1.041 hole 1.041 unplated: (0,-1.5)
  oval 0.838x0.94 hole 0.838x0.94 unplated: (0,1)
  rect 0.787x1.194 smd: 1(-2.15,-1.2) 2(-2.15,1.2) 3(2.15,-1.2) 4(2.15,1.2)
SW-T3AL-23-Q-TR-4P
  rect 0.66x0.711 smd: 1(-1.475,0.95) 2(1.475,0.95) 3(-1.475,-0.95) 4(1.475,-0.95)
SW-TME-532-V-6P
  rect 1.803x1.092 smd: 1(-3.1,1.85) 2(3.1,1.85) 3(-3.1,-1.85) 4(3.1,-1.85)
  rect 0.991x0.61 smd: 5(0,2.5) 6(0,-2.5)
TP2050
  round 0.508 smd: 1(0,0)
TP2075
  round 0.508 smd: 1(0,0)
TP2650
  round 0.66 smd: 1(0,0)
TQFN32-3X6-4-41P-0_8H
  custom 0.05x0.05 smd: 1(-2,-1.5) 2(-1.6,-1.5) 3(-1.2,-1.5) 4(-0.8,-1.5) 5(-0.4,-1.5) 6(0,-1.5) 7(0.4,-1.5) 8(0.8,-1.5) 9(1.2,-1.5) 10(1.6,-1.5) 11(2,-1.5) 12(3,-0.8) 13(3,-0.4) 14(3,0) 15(3,0.4) 16(3,0.8) 17(2,1.5) 18(1.6,1.5) 19(1.2,1.5) 20(0.8,1.5) 21(0.4,1.5) 22(0,1.5) 23(-0.4,1.5) 24(-0.8,1.5) 25(-1.2,1.5) 26(-1.6,1.5) 27(-2,1.5) 28(-3,0.8) 29(-3,0.4) 30(-3,0) 31(-3,-0.4) 32(-3,-0.8)
  rect 4.597x1.803 smd: 33(0,0)
  round 0.61 hole 0.305: 34(-1.5,-0.5) 35(-0.5,-0.5) 36(0.5,-0.5) 37(1.5,-0.5) 38(1.5,0.5) 39(0.5,0.5) 40(-0.5,0.5) 41(-1.5,0.5)
TRF-N1010G-25P
  rect 0.635x1.778 smd: 1(-5.5,-4.54) 2(-4.5,-4.54) 3(-3.5,-4.54) 4(-2.5,-4.54) 5(-1.5,-4.54) 6(-0.5,-4.54) 7(0.5,-4.54) 8(1.5,-4.54) 9(2.5,-4.54) 10(3.5,-4.54) 11(4.5,-4.54) 12(5.5,-4.54) 13(5.5,4.45) 14(4.5,4.45) 15(3.5,4.45) 16(2.5,4.45) 17(1.5,4.45) 18(0.5,4.45) 19(-0.5,4.45) 20(-1.5,4.45) 21(-2.5,4.45) 22(-3.5,4.45) 23(-4.5,4.45) 24(-5.5,4.45)
  rect 0.889x0.787 smd: 25(-6.82,0)
TSOT23-2_8-95-5P-G916-475TOUF
  rect 1.194x0.533 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
UB3-USB-097-1R09HG-9P
  round 1.295 hole 0.813: 1(3.5,7.2) 2(1,7.2) 3(-1,7.2) 4(-3.5,7.2) 5(-4,5.7) 6(-2,5.7) 7(0,5.7) 8(2,5.7) 9(4,5.7)
  oval 1.295x2.896 hole 0.711x2.311: 10(6.4,6.45) 11(-6.4,6.45)
  oval 1.295x2.108 hole 0.711x1.499: 12(-7.85,0) 13(7.85,-3)
UB31-UCF3M-01N01-0P53-24P
  round 0.813 hole 0.813 unplated: (-3.45,0)
  oval 0.813x0.762 hole 0.813x0.762 unplated: (3.45,0)
  oval 0.991x1.6 hole 0.508x1.092: 5(-4.475,0.4) 6(4.475,0.4)
  oval 0.991x2.007 hole 0.508x1.499: 7(-6.075,-1.935) 8(6.075,-1.935) 9(-6.075,-5.8) 10(6.075,-5.8)
  custom 0.064x0.064 smd: A1(-2.75,-0.06) A12(2.75,-0.06)
  rect 0.254x0.61 smd: A2(-2.25,-0.06) A3(-1.75,-0.06) A4(-1.25,-0.06) A5(-0.75,-0.06) A6(-0.25,-0.06) A7(0.25,-0.06) A8(0.75,-0.06) A9(1.25,-0.06) A10(1.75,-0.06) A11(2.25,-0.06)
  oval 1.143x0.66 hole 0.889x0.406: B1(3.2,-1.135) B12(-3.2,-1.135)
  round 0.61 hole 0.457: B2(2.5,-2.035) B3(1.7,-2.035) B4(1.3,-1.135) B5(0.85,-2.035) B6(0.4,-1.135) B7(-0.4,-1.135) B8(-0.85,-2.035) B9(-1.3,-1.135) B10(-1.7,-2.035) B11(-2.5,-2.035)
unnamed#2
  round 1.016 smd: 1(0,0)
WTB-50278-00401-V01-4P-L
  rect 0.787x1.905 smd: 1(-1.875,4.925) 2(-0.625,4.925) 3(0.625,4.925) 4(1.875,4.925)
  rect 1.295x3.353 smd: 5(-4.725,0) 6(4.725,0)
WTB-50458-00801-V02-8P-L
  rect 0.559x1.295 smd: 1(-7,5.025) 2(-5,5.025) 3(-3,5.025) 4(-1,5.025) 5(1,5.025) 6(3,5.025) 7(5,5.025) 8(7,5.025)
  rect 1.295x2.057 smd: 9(-10.1,0) 10(10.1,0)
XTL-2_05X1_65-1_4X1_1-0_6H
  rect 0.889x0.787 smd: 1(-0.7,-0.55) 2(0.7,-0.55) 3(0.7,0.55) 4(-0.7,0.55)
XTL-3_2X1_5-2_5-SMT
  rect 0.991x1.6 smd: 1(-1.25,0) 2(1.25,0)
XTL-3_2X2_5-2_2X1_6-0_9H
  rect 1.397x1.194 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)
XTL-3_2X2_5-2_2X1_8-4P
  rect 1.397x1.194 smd: 1(-1.1,-0.9) 2(1.1,-0.9) 3(1.1,0.9) 4(-1.1,0.9)

## Nets
1.8V_PU9: PC5359.1 PC9181.1 PC9183.1 PR159.2 PR77848.2 PU9.6
3.3V_PU9: PC135.1 PC5357.2 PR156.1 PU9.3
5V_HSMBCK: D5.1 R163.1
5V_HSMBDT: D5.2 R164.1
+0.95V: C2464.1 C2465.1 C2480.1 C2481.1 C2482.1 C2483.1 C2488.1 C2497.1 C2534.1 C2535.1 C2536.1 R2409.2 R2410.2 U2030.AL13 U2030.AM12 U2030.AM13 U2030.AN12 U2030.AN13
+0.95V_SENSE_REMOTE: PR2012.2 PR9295.1
+0.95VS5: C2484.1 C2485.1 C2486.1 C2487.1 R2411.2 U2030.AL14 U2030.AL15 U2030.AM14
+0.95VS5_SENSE_REMOTE: PC2014.2 PR2008.1 PR2010.1 PR9298.1
+1.2V: PQ9056.1(S) PR9311.1
+1.2VSUS: C2349.2 C2350.2 C2352.1 C2375.1 C2376.2 C2377.1 C2378.1 C2379.2 C2380.1 C2381.1 C2384.1 C2385.2 C2386.1 C2387.2 C2388.1 C2389.2 C2390.1 C2391.2 C2392.1 C2393.2 C2394.2 C2395.1 C2396.2 C2405.1 C2406.1 C2410.1 C2412.1 C2418.2 C2431.1 C2434.1 C2491.2 C2492.2 C2493.2 C2494.2 C2495.1 C2496.1 C2500.1 C2501.1 C2502.1 C2523.1 C2524.1 C2525.1 C2526.1 C2527.1 C2528.1 C2529.1 C2530.1 C2545.1 C2678.1 C2679.1 C2680.1 C2681.1 C2682.1 C2683.1 C2684.1 C2685.2 C2686.2 C2687.2 C2688.2 C2695.1 C2696.1 C2697.1 C2698.1 C2699.1 C2700.1 C2701.2 C2702.2 C2703.2 C2704.2 C2709.1 C2710.1 C2711.1 C2712.1 C2713.1 C2714.1 C2715.2 C2716.2 C2717.2 C2718.2 C2731.1 C2732.1 CN2019.111 CN2019.112 CN2019.117 CN2019.118 CN2019.123 CN2019.124 CN2019.129 CN2019.130 CN2019.135 CN2019.136 CN2019.141 CN2019.142 CN2019.147 CN2019.148 CN2019.153 CN2019.154 CN2019.159 CN2019.160 CN2019.163 EC2007.1 EC2008.1 PJ5.2 PQ9056.3 R2276.1 R2284.2 R2290.1 R2683.2 R6644.2 U2013.A1 U2013.A9 U2013.B3 U2013.B9 U2013.C1 U2013.D1 U2013.D9 U2013.F2 U2013.F8 U2013.G1 U2013.G7 U2013.G9 U2013.J1 U2013.J2 U2013.J8 U2013.J9 U2013.L1 U2013.L9 U2013.R1 U2013.T9 U2014.A1 U2014.A9 U2014.B3 U2014.B9 U2014.C1 U2014.D1 U2014.D9 U2014.F2 U2014.F8 U2014.G1 U2014.G7 U2014.G9 U2014.J1 U2014.J2 U2014.J8 U2014.J9 U2014.L1 U2014.L9 U2014.R1 U2014.T9 U2017.A1 U2017.A9 U2017.B3 U2017.B9 U2017.C1 U2017.D1 U2017.D9 U2017.F2 U2017.F8 U2017.G1 U2017.G7 U2017.G9 U2017.J1 U2017.J2 U2017.J8 U2017.J9 U2017.L1 U2017.L9 U2017.R1 U2017.T9 U2018.A1 U2018.A9 U2018.B3 U2018.B9 U2018.C1 U2018.D1 U2018.D9 U2018.F2 U2018.F8 U2018.G1 U2018.G7 U2018.G9 U2018.J1 U2018.J2 U2018.J8 U2018.J9 U2018.L1 U2018.L9 U2018.R1 U2018.T9 U2030.AA20 U2030.AA23 U2030.AA26 U2030.AA28 U2030.AA32 U2030.AC20 U2030.AC22 U2030.AC25 U2030.AC28 U2030.AD23 U2030.AD26 U2030.AD28 U2030.AD32 U2030.AE20 U2030.AE22 U2030.AE25 U2030.AE28 U2030.AF23 U2030.AF26 U2030.AF28 U2030.AF32 U2030.AG20 U2030.AG22 U2030.AG25 U2030.AG28 U2030.AJ20 U2030.AJ23 U2030.AJ26 U2030.AJ28 U2030.AJ32 U2030.AK28 U2030.AL28 U2030.AL32 U2030.T32 U2030.V28 U2030.W28 U2030.W32 U2030.Y22 U2030.Y25 U2030.Y28
+1.5V: PJ7002.1 R373.1 R690.1
+1.05V_LAN: C39.1 C45.1 C58.1 C64.1 C65.1 C93.1 R4.1 U1.3 U1.8 U1.22 U1.30
+1.05V_LAN_REGOUT: C22.1 R4.2 U1.24
+1.5V_RTC: C2499.1 R2397.2 U2021.1(VOUT)
+1.8V: C148.1 C150.1 PQ9014.1(S) PR2033.1 PR6034.1 PR9285.1 Q45.2 Q2032.2 Q2032.5 Q2033.2 Q6565.2 Q6565.5 R313.2 R360.2 R374.2 R420.1 R453.2 R794.1 R818.1 R2306.1 R2392.1 R2394.1 R2412.1 R2511.2 R2512.2 R2513.2 R2519.1 R2520.2 R2538.1 R2543.2 R2544.2 R2545.2 R2549.2 R2551.2 R2714.1 R77869.2 R77880.1 U2031.C6 U2031.M4 U2031.N4 U2031.P3 U2031.P5
+1.8V_GFX: C2276.1 C2277.2 C2283.1 C2285.1 C2660.2 C2669.2 C2670.2 C8115.1 C96272.1 FB104.2 PR9032.1 PR9310.1 PR77848.1 PR77855.1 R2215.1 R2216.1 R2609.1 R2610.1 R2611.1 R2612.1 R2613.1 R2614.1 R2615.1 R2616.1 R2650.2 R2670.1 R2672.1 R8046.1 R8047.1 R77817.1 R77819.1 R77822.1 R77825.1 U2029.AM13 U2029.AM15 U2029.AP15 U2029.AR15
+1.8V_GFX_PG: PR161.1 PR9029.1 PR9105.1
+1.8V_S5: C2790.1 C8165.1 CN2021.1 CN2021.19 PJ7004.1 PQ9014.3 R129.1 R331.1 R432.1 R452.2 R554.1 R568.1 R569.1 R626.1 R773.1 R803.1 R2307.2 R2398.1 R2400.2 R2425.2 R2427.2 R2445.2 R6535.2 R6544.1 R6550.1 R12313.1 R12314.1 R77857.2 R77870.2 U2038.8(VCC) U8022.5
+1.8V_S5_1V8: R2306.2 R2307.1 R2308.1
+1.8V_SW: C690.1 C691.1 C692.1 EC8.1 R773.2 R775.2 R818.2 R824.2 U2032.3(VDD(1V8))
+1.8V_TPM: C391.1 C392.1 C413.1 C432.1 R411.2 R420.2 R432.2 R448.2 R2428.2 R77879.1 U15.8 U15.22
+1.8V_TPM_VSB: C445.2 C446.2 R452.1 R453.1 U15.1(VSB)
+1.35V_GFX: C2195.1 C2196.1 C2197.1 C2198.1 C2199.1 C2207.1 C2208.1 C2209.1 C2210.1 C2211.1 C2212.1 C2213.1 C2214.1 C2215.1 C2217.1 C2218.1 C2219.1 C2221.1 C2223.1 C2224.1 C2225.1 C2227.1 C2228.1 C2229.1 C2231.1 C2232.1 C2233.1 C2234.1 C2235.1 C2240.1 C2241.1 C2242.1 C2243.1 C2244.1 C2245.1 C2246.2 C2252.1 C2253.1 C2255.1 C2259.1 C2260.1 C2263.1 C2266.1 C2267.2 C2268.2 C2269.1 C2270.1 C2273.2 C2280.1 C2291.1 C2298.1 C2304.1 C2305.1 C2306.1 C2307.1 C2308.1 C2312.1 C2313.1 C2317.1 C2320.1 C2321.1 C2340.1 C2341.1 C2342.1 C2343.1 C2344.1 C2345.1 C2346.1 C2347.1 C2661.1 C2665.2 C2667.2 PJ9008.2 PR77851.1 R2237.1 R2238.1 R2239.1 R2254.1 R2257.1 R2641.1 R2655.1 R2666.1 R2671.1 R2674.1 R2677.1 R2681.1 R77827.1 U2029.AC10 U2029.AG10 U2029.K11 U2029.K13 U2029.K19 U2029.K23 U2029.K27 U2029.K31 U2029.L10 U2029.N10 U2029.W10 VRAM2001.B1 VRAM2001.B3 VRAM2001.B12 VRAM2001.B14 VRAM2001.C5 VRAM2001.C10 VRAM2001.D1 VRAM2001.D3 VRAM2001.D11 VRAM2001.D12 VRAM2001.D14 VRAM2001.E5 VRAM2001.E10 VRAM2001.F1 VRAM2001.F3 VRAM2001.F12 VRAM2001.F14 VRAM2001.G1 VRAM2001.G2 VRAM2001.G4 VRAM2001.G11 VRAM2001.G13 VRAM2001.G14 VRAM2001.H3 VRAM2001.H12 VRAM2001.K3 VRAM2001.K12 VRAM2001.L1 VRAM2001.L2 VRAM2001.L4 VRAM2001.L11 VRAM2001.L13 VRAM2001.L14 VRAM2001.M1 VRAM2001.M3 VRAM2001.M12 VRAM2001.M14 VRAM2001.N5 VRAM2001.N10 VRAM2001.P1 VRAM2001.P3 VRAM2001.P11 VRAM2001.P12 VRAM2001.P14 VRAM2001.R5 VRAM2001.R10 VRAM2001.T1 VRAM2001.T3 VRAM2001.T12 VRAM2001.T14 VRAM2002.B1 VRAM2002.B3 VRAM2002.B12 VRAM2002.B14 VRAM2002.C5 VRAM2002.C10 VRAM2002.D1 VRAM2002.D3 VRAM2002.D11 VRAM2002.D12 VRAM2002.D14 VRAM2002.E5 VRAM2002.E10 VRAM2002.F1 VRAM2002.F3 VRAM2002.F12 VRAM2002.F14 VRAM2002.G1 VRAM2002.G2 VRAM2002.G4 VRAM2002.G11 VRAM2002.G13 VRAM2002.G14 VRAM2002.H3 VRAM2002.H12 VRAM2002.K3 VRAM2002.K12 VRAM2002.L1 VRAM2002.L2 VRAM2002.L4 VRAM2002.L11 VRAM2002.L13 VRAM2002.L14 VRAM2002.M1 VRAM2002.M3 VRAM2002.M12 VRAM2002.M14 VRAM2002.N5 VRAM2002.N10 VRAM2002.P1 VRAM2002.P3 VRAM2002.P11 VRAM2002.P12 VRAM2002.P14 VRAM2002.R5 VRAM2002.R10 VRAM2002.T1 VRAM2002.T3 VRAM2002.T12 VRAM2002.T14
+1V_S5_ON: TP9087.1 U13.95
+2.5V_SUS: C2295.2 C2296.1 C2297.2 C2315.2 C2316.1 C2351.2 C2403.2 C2416.2 C2448.2 C2691.2 C2692.2 C2705.2 C2706.2 CN2019.257 CN2019.259 PR127.2 U2013.B1 U2013.R9 U2014.B1 U2014.R9 U2017.B1 U2017.R9 U2018.B1 U2018.R9
+3V: C147.1 C149.1 C180.1 C181.1 C182.1 C205.2 C210.1 C212.1 C222.1 C542.2 C545.2 C558.1 C560.1 C2322.2 C2323.2 C2744.2 C2745.2 CN2019.255 EC4.1 EC5.1 PC9091.2 PQ9003.1(S) PR102.1 PR107.2 PR131.1 PR2000.1 PR6048.1 PR6416.1 PR9132.1 PR9133.1 PR9283.1 Q6.2 Q2031.2 Q2031.5 R12.1 R13.2 R18.2 R21.1 R31.2 R39.1 R52.2 R55.2 R106.2 R107.2 R128.1 R264.1 R325.2 R365.2 R369.2 R371.1 R431.1 R463.2 R488.2 R500.1 R514.2 R518.1 R734.2 R738.1 R752.2 R756.2 R772.2 R780.1 R791.2 R806.2 R2349.2 R2351.2 R2354.2 R2391.1 R2406.1 R2447.2 R2448.2 R2449.2 R2450.2 R2451.2 R2463.2 R2464.2 R2465.2 R2499.1 R2522.1 R2523.2 R2524.1 R2526.1 R2527.1 R2546.1 R2547.1 R2708.2 R2709.2 R2710.2 R2711.2 R2723.1 R6647.2 R67855.1 R77833.2 R77862.2 R77866.1 R77868.2 R77876.2 R77881.1 U23.5 U26.11 U26.30(VDDIO) U2031.E6 U2031.F5 U2031.J10 U2031.K9
+3V_CCD_PWR1_C: CN2.32 CN2.33 R518.2
+3V_DMIC: CN1.4 R514.1
+3V_EC: C679.1 R794.2 R803.2 R77881.2 U13.11
+3V_GFX: C2236.1 C2655.1 C2663.1 C96271.1 PC9092.1 PQ9003.3 PR9043.1 PR9103.1 PR9122.1 PR9129.1 PR77847.2 PR77864.1 PR77866.1 R2217.1 R2218.1 R2219.1 R2220.1 R2221.1 R2227.1 R2599.2 R2600.2 R2603.1 R2604.1 R2605.1 R2606.1 R2607.1 R2608.1 R2629.2 R2630.2 R2660.1 R2667.1 R8069.1 R8107.1 R8122.1 R8527.1 R12293.1 R77853.1 R77855.1 U2028.3(WP#) U2028.7 U2028.8 U2029.AM31 U8001.5(VCC) U8023.5(VCC)
+3V_LAN: C23.1 C24.2 C25.2 C29.2 C30.1 C31.1 C42.1 C51.1 Q2.3 R7.1 U1.11 U1.23(VDDREG) U1.32
+3V_LDO_EC: D13.1(CATHODE) PR68.1 R333.2 R362.2 R399.2 R401.1 R805.2 R811.2
+3V_S5: C682.1 CN12.1 PC9190.1 PC9191.1 PJ7005.2 PR110.1 PR9282.1 PU9007.3(VIN) Q21.2 Q21.5 Q43.2 R7.2 R314.2 R315.2 R344.1 R358.1 R389.1 R392.1 R429.2 R469.2 R731.1 R763.1 R769.2 R784.1 R787.1 R795.2 R797.2 R2309.1 R2358.2 R2360.2 R2362.2 R2364.2 R2376.2 R2393.1 R2438.2 R2439.2 R2440.2 R2453.2 R2454.2 R2455.2 R2510.1 R2724.1 R6650.1 R77872.2 R77882.2
+3V_SSD: C489.2 C490.2 C491.2 CN18.2 CN18.4 CN18.12 CN18.14 CN18.16 CN18.18 CN18.70 CN18.72 CN18.74 EC3.2 R492.2 R500.2 R77878.2
+3V_USB: C2757.2 C2758.2 C2759.2 C2760.2 C2761.2 C2762.2 C2763.2 C2764.2 R552.2 R556.2 R563.2 R566.2 R2723.2 R2724.2 R6507.2 R6530.2 U2033.5 U2033.9 U2033.14 U2033.28
+3V_USB_D: R6530.1 U2033.21
+3V_WLAN_P: C644.1 C645.1 C646.1 C707.1 C715.1 C716.1 C717.1 C718.1 C719.2 CN9.2 CN9.4 CN9.72 CN9.74 Q18.2 Q46.2 R738.2 R769.1 R816.2 R825.2 R828.2 R833.2 R77877.2
+3VLCD_CON: C549.1 C550.1 C551.1 R38.1 U23.1
+3VLCD_CON_R: C539.2 C540.1 CN2.34 CN2.35 CN2.36 R34.1 R38.2
+3VLCD_CON_R_C: CN2.37 R34.2
+3VPCU: C28.2 CN6.23 D2021.1 PC88.1 PC90.1 PC242.1 PJ2.1 PR90.2 PR98.2 PR156.2 PR234.1 PR252.2 PR264.2 PR265.2 PU7.1 PU7.6 Q2.1(S) R5.1 R23.1 R24.2 R309.2 R407.1 R422.1 R507.1 R697.2 U2039.5
+3VPCU_EC: C364.1 C365.1 C386.1 C442.1 C443.1 C477.1 C478.1 L6.2 L10.1 R401.2 U13.26 U13.50 U13.92 U13.114 U13.121
+3VPCU_ECPLL: C372.1 L6.1 U13.127
+3VPCU_HALL: C508.1 D22.2 HE1.2(VCC) HE2.2(VCC) R507.2
+3VRTC: C2498.1 C2517.1 D2021.3(COMMON ANODE) R37.1 U2021.3
+5V: C106.1 C113.1 C378.1 C379.2 C454.1 C461.1 C465.1 C705.2 CN17.6 FAN1.1 HD1.2 HD1.3 HD1.4 L7.1 L14.1 PR87.2 PR216.1 Q33.3 Q47.1(S) R41.1 R370.1 R573.1 R810.1 R827.1
+5V_HDMIC: C559.1 CN4.18 D5.3(COMMON ANODE) D24.2 Q33.1(VOUT)
+5V_KB: C713.2 C714.2 CN16.2 CN16.4 Q47.3
+5V_PVDD: C637.1 C641.1 C647.1 C650.1 L14.2 U30.41 U30.46
+5V_S5: C441.1 C458.1 C459.1 C610.1 C698.1 C704.1 C708.1 C710.1 C2784.1 C2785.1 C2786.2 C2787.2 PR2.1 PR111.1 PR6001.1 PR6002.2 PR9001.1 PR9002.2 PR9100.1 PR9101.1 R244.2 R6523.2 R6646.1 U28.5 U35.5 U2034.19 U2035.5
+5VA: C366.1 C375.2 C623.1 C627.1 L7.2 U30.26
+5VODD: C683.1 C685.1 C686.2 C687.2 C688.2 C689.2 CN15.9 CN15.10 CN15.11 CN15.12 CN15.13 CN15.14 CN15.15 R810.2
+5VPCU: C328.1 PC82.1 PC101.1 PC9179.1 PJ4.1 PR93.2 PR260.2 PR2002.1 PR2005.2 PR9121.1 PR9124.2 PU6.1 PU6.6 PU9.4(VPP) R222.2 R225.2 R694.1 U7.1
+A3VPCU: C433.1 C434.2 L10.2 U13.74
+V3A_LX: PC229.2 PL10.1 PR258.1 PU11.2 PU11.3
+V3A_LX_R: PC247.1 PR258.2
+V3A_OUT: PC66.1 PC67.1 PC69.1 PC72.1 PC224.1 PC225.1 PC226.1 PJ2.2 PL10.2 PR236.2
+V5P5A_LX: PC116.2 PL13.1 PR114.1 PU15.2 PU15.3
+V5P5A_LX_R: PC115.1 PR114.2
+V5P5A_OUT: PC113.1 PC114.1 PC119.1 PC120.1 PC121.1 PC268.1 PC269.1 PJ4.2 PL13.2 PR277.1
+VCC_CORE: C2489.1 C2490.1 C2503.1 C2504.1 C2505.1 C2506.1 C2507.1 C2508.1 C2522.1 C2546.1 C2547.1 C2548.1 C2549.1 C2550.1 C2551.1 C2552.1 C2553.1 PC6027.1 PC6028.1 PC6029.1 PC6030.1 PC6037.1 PC6038.1 PC6039.1 PC6040.1 PC6041.1 PC6042.1 PC6043.1 PC6044.1 PC6045.1 PC6046.1 PL6001.2 PL6002.2 PR6055.1 PR6069.1 PR6072.1 U2030.AA7 U2030.AA10 U2030.AA14 U2030.AA16 U2030.AA18 U2030.AB13 U2030.AB15 U2030.AB17 U2030.AB19 U2030.AC14 U2030.AC16 U2030.AC18 U2030.AD7 U2030.AD10 U2030.AD13 U2030.AD15 U2030.AD17 U2030.AD19 U2030.AE8 U2030.AE14 U2030.AE16 U2030.AE18 U2030.AF7 U2030.AF10 U2030.AF13 U2030.AF15 U2030.AF17 U2030.AF19 U2030.AG14 U2030.AG16 U2030.AG18 U2030.AH13 U2030.AH15 U2030.AH17 U2030.AH19 U2030.AJ7 U2030.AJ10 U2030.AJ14 U2030.AJ16 U2030.AJ18 U2030.AK13 U2030.AK15 U2030.AK17 U2030.AK19 U2030.G7 U2030.G10 U2030.G12 U2030.G14 U2030.H8 U2030.H11 U2030.H15 U2030.K7 U2030.K12 U2030.K14 U2030.L8 U2030.M7 U2030.M10 U2030.N14 U2030.P7 U2030.P10 U2030.P13 U2030.P15 U2030.R8 U2030.R14 U2030.R16 U2030.T7 U2030.T10 U2030.T13 U2030.T15 U2030.T17 U2030.U14 U2030.U16 U2030.V13 U2030.V15 U2030.V17 U2030.W7 U2030.W10 U2030.W14 U2030.W16 U2030.Y8 U2030.Y13 U2030.Y15 U2030.Y17
+VCC_V3A: PC234.1 PU11.9
+VCC_V5P5A: PC265.1 PU15.11
+VCCRTC_2: D2021.2 R2396.2
+VDD_08: C2237.1 C2238.1 C2286.1 C2287.1 C2288.1 C2289.1 C2290.1 PC9185.1 PC9186.1 PC9187.1 PC9188.1 PL9006.2 PR9108.2 PR77863.1 R2718.1 U2029.AC32 U2029.AG32 U2029.AG35 U2029.AJ32 U2029.AJ34 U2029.AL34 U2029.W32
+VDD_18: C2509.1 C2510.1 C2511.1 R2392.2 R2394.2 U2030.AL20 U2030.AM19
+VDD_18_S5: C2514.1 C2515.1 C2516.1 R2398.2 U2030.AL19 U2030.AM18
+VDDCI: C2239.2 C2254.1 C2258.1 C2272.1 C2281.1 C2282.2 PC9047.1 PC9049.1 PL9002.2 PR9028.1 PR9073.1 R2717.1 R2718.2 U2029.AA11 U2029.AE11 U2029.L13 U2029.L17 U2029.L21 U2029.L25 U2029.L29 U2029.N11 U2029.U11
+VDDCR_SOC: C2471.1 C2472.1 C2473.1 C2474.1 C2475.1 C2476.1 C2477.1 C2478.1 C2479.1 PC6053.1 PC6054.1 PC6055.1 PC6056.1 PC6057.1 PC6058.1 PC6059.1 PC6060.1 PC6061.1 PC6062.1 PC6063.1 PC6064.1 PL6000.2 PR6029.1 PR6075.1 U2030.M15 U2030.M18 U2030.M19 U2030.N16 U2030.N18 U2030.N20 U2030.P17 U2030.P19 U2030.R18 U2030.R20 U2030.T19 U2030.U18 U2030.U20 U2030.V19 U2030.W18 U2030.W20 U2030.Y19
+VDDQ: PR9.2 R2682.1
+VDDQ_BOOT1: PC139.1 PR132.1
+VDDQ_P: PC7.1 PC130.1 PC131.1 PC132.1 PC133.1 PC137.1 PJ5.1 PL2.2 PR6.1 PR9300.1
+VDDQ_SR: PC136.1 PR129.2
+VDDQ_VTT: C2310.1 C2311.2 C2318.2 C2319.2 C2719.1 C2720.1 C2721.1 C2722.1 C2723.1 C2724.1 C2725.1 C2726.1 C2727.1 C2728.1 C2729.1 C2730.1 CN2019.258(VTT) PR130.2 R2302.1 R2303.1 R2304.1 R2313.1 R2314.1 R2315.1 R2316.1 R2317.1 R2318.1 R2319.1 R2320.1 R2321.1 R2322.1 R2328.1 R2329.1 R2330.1 R2332.1 R2334.1 R2335.1 R2336.1 R2337.1 R2342.1 R2343.1 R2344.1 R2347.1
+VIN: C17.1 PC86.1 PC117.1 PC118.1 PC240.1 PC245.1 PC6021.1 PC6022.1 PC6023.1 PC6024.1 PC6025.1 PC6026.1 PC6032.1 PC6033.1 PC6034.1 PC6035.1 PC6036.1 PC6048.1 PC6049.1 PC6050.1 PC6051.1 PC6052.1 PC9026.1 PC9042.1 PC9043.1 PC9044.1 PC9045.1 PC9046.1 PJ1.1 PJ3.2 PJ2001.1 PJ9001.2 PJ9007.2 PJ9010.2 PQ11.5 PQ26.5 PQ6001.3 PQ6001.4 PQ6001.9 PQ6002.3 PQ6002.4 PQ6002.9 PQ6003.5 PQ9002.2 PR12.2 PR19.2 PR6003.1 PR9128.1 PR9284.1 PR9289.1 PR77852.1 PR77857.1 PR77861.1 R515.2
+VIN_BLIGHT: C526.1 C527.1 CN2.39 CN2.40 R515.1
+VIN_GPU: PC9021.1 PC9022.1 PC9023.1 PC9024.1 PC9025.1 PC9032.1 PC9033.1 PC9034.1 PC9035.1 PC9036.1 PJ9001.1 PQ9000.3 PQ9000.4 PQ9000.9 PQ9001.3 PQ9001.4 PQ9001.9 PR9003.1
AVDD2: C619.1 L13.2 U30.40
DVDD_IO: C385.1 C661.1 R373.2 R374.1 U30.9
GND: C17.2 C22.2 C23.2 C24.1 C25.1 C28.1 C29.1 C30.2 C31.2 C32.2 C33.1 C37.1 C39.2 C42.2 C45.2 C51.2 C58.2 C61.2 C62.1 C64.2 C65.2 C67.1 C91.1 C93.2 C97.2 C106.2 C112.2 C113.2 C146.2 C147.2 C148.2 C149.2 C150.2 C180.2 C181.2 C182.2 C183.2 C205.1 C210.2 C212.2 C222.2 C239.2 C249.2 C270.2 C280.2 C287.1 C295.1 C304.1 C310.1 C328.2 C343.2 C345.2 C352.2 C363.1 C364.2 C365.2 C367.1 C368.1 C370.2 C371.2 C372.2 C373.2 C374.1 C377.2 C378.2 C379.1 C381.2 C384.2 C385.2 C386.2 C387.1 C388.2 C389.1 C390.2 C391.2 C392.2 C393.1 C394.2 C395.1 C396.2 C397.2 C398.2 C399.2 C400.2 C401.2 C402.2 C403.2 C404.2 C405.2 C406.2 C407.2 C408.2 C409.2 C410.2 C411.2 C412.2 C413.2 C414.2 C415.2 C416.2 C417.2 C418.2 C419.2 C420.2 C421.2 C422.2 C423.2 C424.2 C425.1 C426.1 C427.2 C432.2 C435.2 C436.2 C437.2 C438.1 C439.2 C440.1 C441.2 C442.2 C443.2 C445.1 C446.1 C447.2 C449.2 C450.2 C451.2 C453.1 C454.2 C455.1 C456.1 C458.2 C459.2 C460.2 C461.2 C462.1 C464.2 C465.2 C466.2 C467.2 C476.2 C477.2 C478.2 C479.2 C480.1 C489.1 C490.1 C491.1 C498.2 C508.2 C525.1 C526.2 C527.2 C528.2 C529.2 C532.1 C539.1 C540.2 C541.1 C542.1 C545.1 C549.2 C550.2 C551.2 C558.2 C559.2 C560.2 C593.1 C599.1 C604.1 C608.1 C609.1 C610.2 C612.1 C622.2 C624.2 C637.2 C641.2 C643.2 C644.2 C645.2 C646.2 C647.2 C648.1 C650.2 C656.2 C659.2 C661.2 C663.1 C666.2 C667.1 C670.2 C671.1 C672.1 C673.1 C674.1 C676.1 C679.2 C680.2 C681.2 C682.2 C683.2 C685.2 C686.1 C687.1 C688.1 C689.1 C690.2 C691.2 C692.2 C698.2 C699.2 C701.2 C703.2 C704.2 C705.1 C707.2 C708.2 C710.2 C711.1 C713.1 C714.1 C715.2 C716.2 C717.2 C718.2 C719.1 C869.2 C926.2 C1104.2 C2185.2 C2195.2 C2196.2 C2197.2 C2198.2 C2199.2 C2207.2 C2208.2 C2209.2 C2210.2 C2211.2 C2212.2 C2213.2 C2214.2 C2215.2 C2216.1 C2217.2 C2218.2 C2219.2 C2221.2 C2223.2 C2224.2 C2225.2 C2227.2 C2228.2 C2229.2 C2231.2 C2232.2 C2233.2 C2234.2 C2235.2 C2236.2 C2237.2 C2238.2 C2239.1 C2240.2 C2241.2 C2242.2 C2243.2 C2244.2 C2245.2 C2246.1 C2247.2 C2248.2 C2249.2 C2250.2 C2251.1 C2252.2 C2253.2 C2254.2 C2255.2 C2256.2 C2257.2 C2258.2 C2259.2 C2260.2 C2261.1 C2262.1 C2263.2 C2264.1 C2265.1 C2266.2 C2267.1 C2268.1 C2269.2 C2270.2 C2271.2 C2272.2 C2273.1 C2274.2 C2275.2 C2276.2 C2277.1 C2278.1 C2279.2 C2280.2 C2281.2 C2282.1 C2283.2 C2285.2 C2286.2 C2287.2 C2288.2 C2289.2 C2290.2 C2291.2 C2295.1 C2296.2 C2297.1 C2298.2 C2304.2 C2305.2 C2306.2 C2307.2 C2308.2 C2310.2 C2311.1 C2312.2 C2313.2 C2315.1 C2316.2 C2317.2 C2318.1 C2319.1 C2320.2 C2321.2 C2322.1 C2323.1 C2340.2 C2341.2 C2342.2 C2343.2 C2344.2 C2345.2 C2346.2 C2347.2 C2349.1 C2350.1 C2351.1 C2352.2 C2368.1 C2369.2 C2375.2 C2376.1 C2377.2 C2378.2 C2379.1 C2380.2 C2381.2 C2384.2 C2385.1 C2386.2 C2387.1 C2388.2 C2389.1 C2390.2 C2391.1 C2392.2 C2393.1 C2394.1 C2395.2 C2396.1 C2403.1 C2405.2 C2406.2 C2410.2 C2412.2 C2416.1 C2418.1 C2431.2 C2434.2 C2448.1 C2464.2 C2465.2 C2466.2 C2467.2 C2469.2 C2470.1 C2471.2 C2472.2 C2473.2 C2474.2 C2475.2 C2476.2 C2477.2 C2478.2 C2479.2 C2480.2 C2481.2 C2482.2 C2483.2 C2484.2 C2485.2 C2486.2 C2487.2 C2488.2 C2489.2 C2490.2 C2491.1 C2492.1 C2493.1 C2494.1 C2495.2 C2496.2 C2497.2 C2498.2 C2499.2 C2500.2 C2501.2 C2502.2 C2503.2 C2504.2 C2505.2 C2506.2 C2507.2 C2508.2 C2509.2 C2510.2 C2511.2 C2512.2 C2513.2 C2514.2 C2515.2 C2516.2 C2517.2 C2522.2 C2523.2 C2524.2 C2525.2 C2526.2 C2527.2 C2528.2 C2529.2 C2530.2 C2531.2 C2532.2 C2533.2 C2534.2 C2535.2 C2536.2 C2537.2 C2538.2 C2539.2 C2545.2 C2546.2 C2547.2 C2548.2 C2549.2 C2550.2 C2551.2 C2552.2 C2553.2 C2567.2 C2568.2 C2569.1 C2573.2 C2574.2 C2575.1 C2576.1 C2577.2 C2578.1 C2579.1 C2580.1 C2593.1 C2594.1 C2596.2 C2655.2 C2656.2 C2657.2 C2658.1 C2660.1 C2661.2 C2662.1 C2663.2 C2665.1 C2666.1 C2667.1 C2668.1 C2669.1 C2670.1 C2671.1 C2672.1 C2673.1 C2674.2 C2678.2 C2679.2 C2680.2 C2681.2 C2682.2 C2683.2 C2684.2 C2685.1 C2686.1 C2687.1 C2688.1 C2689.1 C2690.2 C2691.1 C2692.1 C2693.1 C2694.2 C2695.2 C2696.2 C2697.2 C2698.2 C2699.2 C2700.2 C2701.1 C2702.1 C2703.1 C2704.1 C2705.1 C2706.1 C2707.1 C2708.2 C2709.2 C2710.2 C2711.2 C2712.2 C2713.2 C2714.2 C2715.1 C2716.1 C2717.1 C2718.1 C2719.2 C2720.2 C2721.2 C2722.2 C2723.2 C2724.2 C2725.2 C2726.2 C2727.2 C2728.2 C2729.2 C2730.2 C2731.2 C2732.2 C2733.2 C2744.1 C2745.1 C2757.1 C2758.1 C2759.1 C2760.1 C2761.1 C2762.1 C2763.1 C2764.1 C2765.2 C2766.2 C2767.2 C2768.1 C2769.1 C2782.2 C2783.1 C2784.2 C2785.2 C2786.1 C2787.1 C2788.1 C2789.1 C2790.2 C2792.2 C8115.2 C8155.1 C8164.2 C8165.2 C28052.2 C28053.2 C28054.2 C28055.2 C96269.2 C96271.2 C96272.2 C96274.2 C96275.2 CN1.1 CN1.5 CN1.6 CN2.3 CN2.6 CN2.9 CN2.12 CN2.15 CN2.18 CN2.21 CN2.41 CN2.42 CN3.9 CN3.10 CN3.11 CN3.12(GND#4) CN4.2 CN4.5 CN4.8 CN4.11 CN4.17 CN4.20 CN4.21 CN4.22 CN4.23 CN5.4 CN5.7 CN5.10 CN5.11 CN5.12 CN5.13 CN6.14 CN6.17 CN6.22 CN6.24 CN6.31 CN6.32 CN7.4 CN7.7 CN7.10 CN7.11 CN7.12 CN7.13 CN8.2 CN8.29 CN8.30 CN9.1 CN9.7 CN9.13 CN9.18 CN9.19 CN9.33 CN9.39 CN9.45 CN9.51 CN9.57 CN9.63 CN9.69 CN9.75 CN9.76 CN9.77 CN10.2 CN10.29 CN10.30 CN11.5 CN11.6 CN12.4 CN12.9 CN12.10 CN13.5 CN13.9 CN13.10 CN14.5 CN14.6 CN14.7 CN14.8 CN14.9 CN14.10 CN14.A1 CN14.A12 CN14.B1 CN14.B12 CN15.1 CN15.4 CN15.7 CN15.17 CN15.18 CN15.19 CN15.20 CN16.1 CN16.5 CN16.6 CN17.1 CN17.7 CN17.8 CN18.1 CN18.3 CN18.9 CN18.15 CN18.21 CN18.27 CN18.33 CN18.39 CN18.45 CN18.51 CN18.57 CN18.71 CN18.73 CN18.75 CN18.76 CN18.77 CN2019.1 CN2019.2 CN2019.5 CN2019.6 CN2019.9 CN2019.10 CN2019.14 CN2019.15 CN2019.18 CN2019.19 CN2019.22 CN2019.23 CN2019.26 CN2019.27 CN2019.30 CN2019.31 CN2019.35 CN2019.36 CN2019.39 CN2019.40 CN2019.43 CN2019.44 CN2019.47 CN2019.48 CN2019.51 CN2019.52 CN2019.56 CN2019.57 CN2019.60 CN2019.61 CN2019.64 CN2019.65 CN2019.68 CN2019.69 CN2019.72 CN2019.73 CN2019.77 CN2019.78 CN2019.81 CN2019.82 CN2019.85 CN2019.86 CN2019.89 CN2019.90 CN2019.93 CN2019.94 CN2019.98 CN2019.99 CN2019.102 CN2019.103 CN2019.106 CN2019.107 CN2019.167 CN2019.168 CN2019.171 CN2019.172 CN2019.175 CN2019.176 CN2019.180 CN2019.181 CN2019.184 CN2019.185 CN2019.188 CN2019.189 CN2019.192 CN2019.193 CN2019.196 CN2019.197 CN2019.201 CN2019.202 CN2019.205 CN2019.206 CN2019.209 CN2019.210 CN2019.213 CN2019.214 CN2019.217 CN2019.218 CN2019.222 CN2019.223 CN2019.226 CN2019.227 CN2019.230 CN2019.231 CN2019.234 CN2019.235 CN2019.238 CN2019.239 CN2019.243 CN2019.244 CN2019.247 CN2019.248 CN2019.251 CN2019.252 CN2019.256 CN2019.260 CN2019.261 CN2019.262 CN2020.2 CN2021.3 CN2021.5 CN2021.7 CN2021.17 D3.1 D4.1 D10.2 D16.1 D17.1 D18.2 D19.1 D21.1 D22.1 D24.1 D25.1 D26.1 D27.1 D28.1 D29.1 D30.1 D31.1 D32.1 D38.1 D39.1 D41.1 EC3.1 EC4.2 EC5.2 EC6.1 EC7.2 EC8.2 EC9.2 EC2007.2 EC2008.2 FAN1.4 FAN1.5 FAN1.6 HD1.6 HD1.9 HD1.12 HD1.13 HD1.14 HE1.3 HE2.3 HOLE2.1 HOLE5.1 HOLE6.1 HOLE7.1 HOLE8.1 HOLE10.1 HOLE11.1 HOLE11.2 HOLE11.3 HOLE11.4 HOLE11.5 HOLE11.6 HOLE11.7 HOLE11.8 HOLE11.9 HOLE13.1 HOLE14.1 HOLE15.1 HOLE16.1 HOLE16.2 HOLE16.3 HOLE16.4 HOLE16.5 HOLE16.6 HOLE16.7 HOLE16.8 HOLE16.9 HOLE17.1 HOLE18.1 HOLE18.2 HOLE18.3 HOLE18.4 HOLE18.5 HOLE18.6 HOLE18.7 HOLE18.8 HOLE18.9 HOLE19.1 HOLE21.1 HOLE22.1 HOLE22.2 HOLE22.3 HOLE22.4 HOLE22.5 HOLE22.6 HOLE22.7 HOLE22.8 HOLE22.9 HOLE22.10 HOLE23.1 HOLE23.2 HOLE23.3 HOLE23.4 HOLE23.5 HOLE23.6 HOLE23.7 HOLE23.8 HOLE23.9 HOLE26.1 J1.2 L9.2 PC1.1 PC2.2 PC3.2 PC7.2 PC10.1 PC11.2 PC12.2 PC14.2 PC15.1 PC16.2 PC18.2 PC66.2 PC67.2 PC69.2 PC71.1 PC72.2 PC73.1 PC74.2 PC76.1 PC77.1 PC78.2 PC79.1 PC80.2 PC81.2 PC82.2 PC86.2 PC87.2 PC88.2 PC90.2 PC92.2 PC93.2 PC96.1 PC98.2 PC99.2 PC101.2 PC103.2 PC104.2 PC105.2 PC106.2 PC108.2 PC109.2 PC110.2 PC111.2 PC112.2 PC113.2 PC114.2 PC115.2 PC117.2 PC118.2 PC119.2 PC120.2 PC121.2 PC122.2 PC123.2 PC125.1 PC126.1 PC128.2 PC129.2 PC130.2 PC131.2 PC132.2 PC133.2 PC135.2 PC136.2 PC137.2 PC138.1 PC140.2 PC142.2 PC143.2 PC145.2 PC164.2 PC221.1 PC224.2 PC225.2 PC226.2 PC227.2 PC233.2 PC234.2 PC235.1 PC236.2 PC238.2 PC239.2 PC240.2 PC241.2 PC242.2 PC244.1 PC245.2 PC246.2 PC247.2 PC248.1 PC249.2 PC250.2 PC251.2 PC252.2 PC254.1 PC256.1 PC258.2 PC261.1 PC262.2 PC263.1 PC264.2 PC265.2 PC266.2 PC267.1 PC268.2 PC269.2 PC270.2 PC271.1 PC551.1 PC561.2 PC562.2 PC563.2 PC571.2 PC572.2 PC581.2 PC2000.2 PC2001.2 PC2002.2 PC2003.2 PC2004.2 PC2006.2 PC2007.2 PC2008.2 PC2009.2 PC2010.2 PC2011.2 PC2012.2 PC2013.2 PC2015.2 PC5357.1 PC5359.2 PC6000.2 PC6001.1 PC6002.1 PC6003.2 PC6006.2 PC6010.2 PC6012.1 PC6017.2 PC6019.2 PC6020.2 PC6021.2 PC6022.2 PC6023.2 PC6024.2 PC6025.2 PC6026.2 PC6027.2 PC6028.2 PC6029.2 PC6030.2 PC6031.2 PC6032.2 PC6033.2 PC6034.2 PC6035.2 PC6036.2 PC6037.2 PC6038.2 PC6039.2 PC6040.2 PC6041.2 PC6042.2 PC6043.2 PC6044.2 PC6045.2 PC6046.2 PC6047.2 PC6048.2 PC6049.2 PC6050.2 PC6051.2 PC6052.2 PC6053.2 PC6054.2 PC6055.2 PC6056.2 PC6057.2 PC6058.2 PC6059.2 PC6060.2 PC6061.2 PC6062.2 PC6063.2 PC6064.2 PC6065.2 PC6229.1 PC6230.2 PC6231.2 PC9000.2 PC9001.1 PC9002.1 PC9003.2 PC9006.2 PC9009.2 PC9011.2 PC9013.1 PC9018.2 PC9020.2 PC9021.2 PC9022.2 PC9023.2 PC9024.2 PC9025.2 PC9026.2 PC9027.2 PC9028.2 PC9029.2 PC9031.2 PC9032.2 PC9033.2 PC9034.2 PC9035.2 PC9036.2 PC9037.2 PC9038.2 PC9039.2 PC9040.2 PC9041.2 PC9042.2 PC9043.2 PC9044.2 PC9045.2 PC9046.2 PC9047.2 PC9049.2 PC9050.2 PC9065.2 PC9066.2 PC9067.2 PC9068.2 PC9069.2 PC9070.2 PC9071.2 PC9073.2 PC9074.2 PC9075.2 PC9076.2 PC9078.2 PC9079.2 PC9080.2 PC9092.2 PC9094.1 PC9132.2 PC9163.2 PC9164.2 PC9173.1 PC9174.1 PC9175.1 PC9176.1 PC9177.1 PC9178.1 PC9179.2 PC9181.2 PC9182.2 PC9183.2 PC9185.2 PC9186.2 PC9187.2 PC9188.2 PC9190.2 PC9191.2 PC9192.2 PD2.2 PD5.2 PD6.2 PJ6.2 PJ6.4 PJ6.5(SPRING & SHELL(-) #3) PJ11.1 PJ11.2 PJ11.9 PJ11.10 PQ7.1(S) PQ8.1(EMITTER) PQ9.1(S) PQ10.1(S) PQ12.1(S) PQ13.1(S) PQ27.1 PQ27.2 PQ27.3(S_3) PQ35.1(S) PQ6000.1 PQ6000.2 PQ6000.3(S_3) PQ6001.10(S2) PQ6002.10(S2) PQ9000.10(S2) PQ9001.10(S2) PQ9002.5 PQ9002.6 PQ9002.7(S2#3) PQ9006.1(S) PQ9007.1(S) PQ9008.1(S) PQ9013.1(S) PQ9015.1(S) PQ9057.1(S) PQ9062.1(S) PQ9063.1(S) PQ9065.1(S) PQ9066.1(S) PQ9067.1(S) PQ9068.1(S) PQ9069.1(S) PR69.2 PR74.2 PR76.2 PR82.1 PR84.1 PR85.2 PR86.1 PR97.2 PR112.2 PR118.1 PR160.2 PR194.2 PR230.1 PR246.1 PR275.1 PR283.2 PR567.1 PR2013.2 PR6009.1 PR6016.2 PR6024.1 PR6064.2 PR9007.1 PR9012.2 PR9023.1 PR9062.2 PR9107.2 PR9117.2 PR9135.2 PR9136.2 PR9287.2 PR9288.2 PR9304.2 PR9305.1 PR9306.1 PR77850.2 PR77854.2 PR77859.2 PU1.3 PU1.9 PU1.16 PU6.11 PU6.15 PU7.11 PU7.15 PU9.8 PU9.9 PU11.4 PU11.8 PU12.22 PU12.29 PU12.30 PU12.31 PU12.32 PU12.33 PU12.34 PU12.35 PU12.36 PU12.37 PU12.38 PU15.4 PU15.8 PU2000.12 PU2000.13 PU2000.14 PU2000.15 PU2000.19 PU3003.2 PU3004.4 PU3004.8 PU3004.9 PU6000.41 PU9000.41 PU9005.12 PU9005.13 PU9005.14 PU9005.15 PU9005.19 PU9006.2 PU9006.4 PU9007.4 PU9007.8 PU9007.9 Q3.1(EMITTER) Q4.1(S) Q4.4 Q7.1(S) Q20.1(S) Q33.2 Q44.1(EMITTER) Q2025.1(S) Q2039.1(S) R6.1 R19.2 R22.2 R27.2 R30.1 R93.1 R104.2 R130.1 R223.1 R234.2 R235.1 R275.2 R281.1 R289.2 R345.1 R348.2 R355.2 R375.1 R376.2 R385.2 R421.1 R436.1 R440.1 R446.1 R459.2 R460.1 R462.2 R464.1 R466.1 R471.1 R477.1 R485.1 R501.2 R535.1 R551.2 R559.1 R560.1 R571.1 R575.1 R691.2 R698.2 R700.2 R718.1 R720.2 R730.2 R732.2 R785.1 R817.1 R834.2 R2211.1 R2212.1 R2213.1 R2214.1 R2229.2 R2230.2 R2232.1 R2236.1 R2240.2 R2253.2 R2270.2 R2283.1 R2300.2 R2301.1 R2310.2 R2311.2 R2338.2 R2339.1 R2350.1 R2352.1 R2355.1 R2357.1 R2359.1 R2361.1 R2363.1 R2365.1 R2390.1 R2395.2 R2399.2 R2430.2 R2502.2 R2503.2 R2505.2 R2521.2 R2550.2 R2601.2 R2618.2 R2619.2 R2620.2 R2622.1 R2623.1 R2624.1 R2625.1 R2626.1 R2627.1 R2631.2 R2632.1 R2633.1 R2634.1 R2635.1 R2636.1 R2637.1 R2638.1 R2639.1 R2640.1 R2642.1 R2645.2 R2651.1 R2653.1 R2654.1 R2661.1 R2662.1 R2663.1 R2665.2 R2668.1 R2673.2 R2675.1 R2678.1 R2679.1 R2680.1 R2685.2 R2688.2 R2689.2 R2690.1 R2692.2 R2693.2 R2694.1 R2696.2 R2719.2 R6508.1 R6510.1 R6515.2 R6516.1 R6517.2 R6518.2 R6519.2 R6520.2 R6527.1 R6590.2 R6593.2 R6645.2 R8041.2 R8042.2 R8053.1 R8104.2 R8485.1 R12296.2 R12317.1 R67859.1 R77818.2 R77820.2 R77821.2 R77826.2 R77828.2 R77831.2 R77832.1 R77850.2 R77854.1 R77856.1 R77861.1 R77863.1 R77864.1 R77865.1 R77873.1 R77884.1 RV1.3 RV1.8 RV2.3 RV2.8 RV8.1 RV9.1 SW1.3 SW1.4 SW2.1 SW2.2 SW2.5 SW2.6 U1.33 U5.3 U5.8 U5.9 U5.11 U7.14 U7.17 U11.3 U11.8 U11.9 U11.11 U13.1 U13.27 U13.49 U13.91 U13.104 U15.16 U15.23 U15.33 U16.5 U16.10 U16.12 U16.13 U16.15 U16.16 U17.3 U17.13 U17.18 U17.21 U17.22 U17.23 U17.24 U17.25 U17.26 U21.25 U23.2 U26.14 U26.33 U26.34 U26.35 U26.36 U26.37 U26.38 U26.39 U26.40 U26.41 U28.2 U30.49 U33.4 U35.2 U2013.A2 U2013.A8 U2013.B2 U2013.C9 U2013.D2 U2013.D8 U2013.E1 U2013.E3 U2013.E8 U2013.F1 U2013.G8 U2013.H1 U2013.H9 U2013.K1 U2013.K9 U2013.N1 U2013.N9 U2013.T1 U2013.T7 U2014.A2 U2014.A8 U2014.B2 U2014.C9 U2014.D2 U2014.D8 U2014.E1 U2014.E3 U2014.E8 U2014.F1 U2014.G8 U2014.H1 U2014.H9 U2014.K1 U2014.K9 U2014.N1 U2014.N9 U2014.T1 U2014.T7 U2017.A2 U2017.A8 U2017.B2 U2017.C9 U2017.D2 U2017.D8 U2017.E1 U2017.E3 U2017.E8 U2017.F1 U2017.G8 U2017.H1 U2017.H9 U2017.K1 U2017.K9 U2017.N1 U2017.N9 U2017.T1 U2017.T7 U2018.A2 U2018.A8 U2018.B2 U2018.C9 U2018.D2 U2018.D8 U2018.E1 U2018.E3 U2018.E8 U2018.F1 U2018.G8 U2018.H1 U2018.H9 U2018.K1 U2018.K9 U2018.N1 U2018.N9 U2018.T1 U2018.T7 U2021.2 U2028.4 U2029.A2 U2029.A5 U2029.A9 U2029.A13 U2029.A17 U2029.A21 U2029.A25 U2029.A29 U2029.A33 U2029.A37 U2029.A40 U2029.AA1 U2029.AA3 U2029.AA5 U2029.AA10 U2029.AA17 U2029.AA19 U2029.AA25 U2029.AA27 U2029.AA32 U2029.AA39 U2029.AC3 U2029.AC7 U2029.AC11 U2029.AC17 U2029.AC19 U2029.AC25 U2029.AC27 U2029.AC39 U2029.AE1 U2029.AE3 U2029.AE5 U2029.AE10 U2029.AE17 U2029.AE19 U2029.AE25 U2029.AE27 U2029.AE32 U2029.AE35 U2029.AE39 U2029.AG3 U2029.AG7 U2029.AG11 U2029.AG17 U2029.AG19 U2029.AG25 U2029.AG27 U2029.AG39 U2029.AG40 U2029.AG41 U2029.AJ1 U2029.AJ3 U2029.AJ5 U2029.AJ10 U2029.AJ11 U2029.AJ35 U2029.AJ39 U2029.AL3 U2029.AL7 U2029.AL10 U2029.AL11 U2029.AL32 U2029.AL35 U2029.AL39 U2029.AM17 U2029.AM23 U2029.AN1 U2029.AN3 U2029.AN7 U2029.AN35 U2029.AN39 U2029.AN40 U2029.AN41 U2029.AP13 U2029.AP17 U2029.AR3 U2029.AR7 U2029.AR11 U2029.AR19 U2029.AR21 U2029.AR25 U2029.AR27 U2029.AR31 U2029.AR35 U2029.AR39 U2029.AU1 U2029.AU3 U2029.AU9 U2029.AU23 U2029.AU29 U2029.AW3 U2029.AW5 U2029.AW7 U2029.AW9 U2029.AW11 U2029.AW13 U2029.AW15 U2029.AW17 U2029.AW19 U2029.AW21 U2029.AW23 U2029.AW25 U2029.AW27 U2029.AW29 U2029.AW31 U2029.AW33 U2029.AW35 U2029.AW37 U2029.AW39 U2029.AY1 U2029.AY2 U2029.AY9 U2029.AY12 U2029.AY17 U2029.AY23 U2029.AY29 U2029.AY37 U2029.AY40 U2029.AY41 U2029.B1 U2029.B40 U2029.B41 U2029.BA2 U2029.BA5 U2029.BA9 U2029.BA17 U2029.BA23 U2029.BA29 U2029.BA37 U2029.BA40 U2029.C5 U2029.C7 U2029.C9 U2029.C11 U2029.C13 U2029.C15 U2029.C17 U2029.C19 U2029.C21 U2029.C23 U2029.C25 U2029.C27 U2029.C29 U2029.C31 U2029.C33 U2029.C35 U2029.C37 U2029.C39 U2029.E1 U2029.E3 U2029.E4 U2029.E9 U2029.E13 U2029.E17 U2029.E21 U2029.E25 U2029.E29 U2029.E39 U2029.E41 U2029.G3 U2029.G7 U2029.G11 U2029.G15 U2029.G19 U2029.G23 U2029.G27 U2029.G31 U2029.G35 U2029.G39 U2029.J1 U2029.J3 U2029.J5 U2029.J34 U2029.J37 U2029.J39 U2029.J40 U2029.J41 U2029.K21 U2029.K25 U2029.K29 U2029.K40 U2029.L3 U2029.L7 U2029.L11 U2029.L15 U2029.L19 U2029.L23 U2029.L27 U2029.L31 U2029.L35 U2029.L39 U2029.N1 U2029.N3 U2029.N5 U2029.N17 U2029.N19 U2029.N25 U2029.N27 U2029.N32 U2029.N37 U2029.N39 U2029.R3 U2029.R7 U2029.R11 U2029.R17 U2029.R19 U2029.R25 U2029.R27 U2029.R32 U2029.R35 U2029.R39 U2029.U1 U2029.U3 U2029.U5 U2029.U17 U2029.U19 U2029.U25 U2029.U27 U2029.U32 U2029.U37 U2029.U39 U2029.W3 U2029.W7 U2029.W11 U2029.W17 U2029.W19 U2029.W25 U2029.W27 U2029.W39 U2030.A3 U2030.A5 U2030.A7 U2030.A10 U2030.A12 U2030.A14 U2030.A16 U2030.A19 U2030.A21 U2030.A23 U2030.A26 U2030.A30 U2030.AA1 U2030.AA5 U2030.AA13 U2030.AA15 U2030.AA17 U2030.AA19 U2030.AB14 U2030.AB16 U2030.AB18 U2030.AB20 U2030.AC5 U2030.AC8 U2030.AC11 U2030.AC12 U2030.AC13 U2030.AC15 U2030.AC17 U2030.AC19 U2030.AD1 U2030.AD5 U2030.AD14 U2030.AD16 U2030.AD18 U2030.AD20 U2030.AE5 U2030.AE11 U2030.AE12 U2030.AE13 U2030.AE15 U2030.AE17 U2030.AE19 U2030.AF1 U2030.AF5 U2030.AF14 U2030.AF16 U2030.AF18 U2030.AF20 U2030.AG5 U2030.AG8 U2030.AG11 U2030.AG12 U2030.AG13 U2030.AG15 U2030.AG17 U2030.AG19 U2030.AH14 U2030.AH16 U2030.AH18 U2030.AH20 U2030.AJ1 U2030.AJ5 U2030.AJ13 U2030.AJ15 U2030.AJ17 U2030.AJ19 U2030.AK5 U2030.AK8 U2030.AK11 U2030.AK12 U2030.AK14 U2030.AK16 U2030.AK18 U2030.AK20 U2030.AK22 U2030.AK25 U2030.AL1 U2030.AL5 U2030.AL7 U2030.AL10 U2030.AL12 U2030.AL16 U2030.AL23 U2030.AL26 U2030.AM5 U2030.AM8 U2030.AM15 U2030.AM20 U2030.AM22 U2030.AM25 U2030.AM28 U2030.AN1 U2030.AN5 U2030.AN7 U2030.AN10 U2030.AN15 U2030.AN18 U2030.AN21 U2030.AN23 U2030.AN26 U2030.AN28 U2030.AN32 U2030.AP5 U2030.AP8 U2030.AP13 U2030.AP15 U2030.AP18 U2030.AP20 U2030.AP25 U2030.AP28 U2030.AR1 U2030.AR5 U2030.AR7 U2030.AR12 U2030.AR14 U2030.AR16 U2030.AR19 U2030.AR21 U2030.AR26 U2030.AR28 U2030.AR32 U2030.AU5 U2030.AU8 U2030.AU11 U2030.AU13 U2030.AU15 U2030.AU18 U2030.AU20 U2030.AU22 U2030.AU25 U2030.AU28 U2030.AV1 U2030.AV5 U2030.AV7 U2030.AV10 U2030.AV12 U2030.AV14 U2030.AV16 U2030.AV19 U2030.AV21 U2030.AV23 U2030.AV26 U2030.AV28 U2030.AV32 U2030.AW5 U2030.AW28 U2030.AY6 U2030.AY7 U2030.AY8 U2030.AY10 U2030.AY11 U2030.AY12 U2030.AY13 U2030.AY14 U2030.AY15 U2030.AY16 U2030.AY18 U2030.AY19 U2030.AY20 U2030.AY21 U2030.AY22 U2030.AY23 U2030.AY25 U2030.AY26 U2030.AY27 U2030.BB1 U2030.BB20 U2030.BB32 U2030.BD3 U2030.BD7 U2030.BD10 U2030.BD12 U2030.BD14 U2030.BD16 U2030.BD19 U2030.BD21 U2030.BD23 U2030.BD26 U2030.BD30 U2030.C3 U2030.C32 U2030.D16 U2030.D18 U2030.D20 U2030.E7 U2030.E8 U2030.E10 U2030.E11 U2030.E12 U2030.E13 U2030.E14 U2030.E15 U2030.E16 U2030.E18 U2030.E19 U2030.E20 U2030.E21 U2030.E22 U2030.E23 U2030.E25 U2030.E26 U2030.E27 U2030.F5 U2030.F28 U2030.G1 U2030.G5 U2030.G16 U2030.G19 U2030.G21 U2030.G23 U2030.G26 U2030.G28 U2030.G32 U2030.H5 U2030.H13 U2030.H18 U2030.H20 U2030.H22 U2030.H25 U2030.H28 U2030.K1 U2030.K5 U2030.K16 U2030.K19 U2030.K21 U2030.K22 U2030.K26 U2030.K28 U2030.K32 U2030.L5 U2030.L13 U2030.L15 U2030.L18 U2030.L20 U2030.L25 U2030.L28 U2030.M1 U2030.M5 U2030.M12 U2030.M21 U2030.M23 U2030.M26 U2030.M28 U2030.M32 U2030.N4 U2030.N5 U2030.N8 U2030.N11 U2030.N12 U2030.N13 U2030.N15 U2030.N17 U2030.N19 U2030.N22 U2030.N25 U2030.N28 U2030.P1 U2030.P5 U2030.P14 U2030.P16 U2030.P18 U2030.P20 U2030.P23 U2030.P26 U2030.P28 U2030.P32 U2030.R5 U2030.R11 U2030.R12 U2030.R13 U2030.R15 U2030.R17 U2030.R19 U2030.R22 U2030.R25 U2030.R28 U2030.R30 U2030.T1 U2030.T5 U2030.T14 U2030.T16 U2030.T18 U2030.T20 U2030.T23 U2030.T26 U2030.T28 U2030.U13 U2030.U15 U2030.U17 U2030.U19 U2030.V5 U2030.V8 U2030.V11 U2030.V12 U2030.V14 U2030.V16 U2030.V18 U2030.V20 U2030.V22 U2030.V25 U2030.W1 U2030.W5 U2030.W13 U2030.W15 U2030.W17 U2030.W19 U2030.W23 U2030.W26 U2030.Y5 U2030.Y11 U2030.Y12 U2030.Y14 U2030.Y16 U2030.Y18 U2030.Y20 U2031.A6 U2031.C4 U2031.E7 U2031.G5 U2031.H10 U2031.J5 U2031.K8 U2031.N2 U2031.N5 U2031.P4 U2031.P6 U2032.9 U2033.29 U2034.25 U2035.2 U2038.4 U2039.3 U5400.5 U8001.3 U8021.6 U8022.2 U8023.3 VC1.2 VRAM2001.A1 VRAM2001.A3 VRAM2001.A12 VRAM2001.A14 VRAM2001.B5 VRAM2001.B10 VRAM2001.C1 VRAM2001.C3 VRAM2001.C4 VRAM2001.C11 VRAM2001.C12 VRAM2001.C14 VRAM2001.D10 VRAM2001.E1 VRAM2001.E3 VRAM2001.E12 VRAM2001.E14 VRAM2001.F5 VRAM2001.F10 VRAM2001.G5 VRAM2001.G10 VRAM2001.H1 VRAM2001.H2 VRAM2001.H13 VRAM2001.H14 VRAM2001.K1 VRAM2001.K2 VRAM2001.K13 VRAM2001.K14 VRAM2001.L5 VRAM2001.L10 VRAM2001.M5 VRAM2001.M10 VRAM2001.N1 VRAM2001.N3 VRAM2001.N12 VRAM2001.N14 VRAM2001.P10 VRAM2001.R1 VRAM2001.R3 VRAM2001.R4 VRAM2001.R11 VRAM2001.R12 VRAM2001.R14 VRAM2001.T5 VRAM2001.T10 VRAM2001.U1 VRAM2001.U3 VRAM2001.U12 VRAM2001.U14 VRAM2002.A1 VRAM2002.A3 VRAM2002.A12 VRAM2002.A14 VRAM2002.B5 VRAM2002.B10 VRAM2002.C1 VRAM2002.C3 VRAM2002.C4 VRAM2002.C11 VRAM2002.C12 VRAM2002.C14 VRAM2002.D10 VRAM2002.E1 VRAM2002.E3 VRAM2002.E12 VRAM2002.E14 VRAM2002.F5 VRAM2002.F10 VRAM2002.G5 VRAM2002.G10 VRAM2002.H1 VRAM2002.H2 VRAM2002.H13 VRAM2002.H14 VRAM2002.K1 VRAM2002.K2 VRAM2002.K13 VRAM2002.K14 VRAM2002.L5 VRAM2002.L10 VRAM2002.M5 VRAM2002.M10 VRAM2002.N1 VRAM2002.N3 VRAM2002.N12 VRAM2002.N14 VRAM2002.P10 VRAM2002.R1 VRAM2002.R3 VRAM2002.R4 VRAM2002.R11 VRAM2002.R12 VRAM2002.R14 VRAM2002.T5 VRAM2002.T10 VRAM2002.U1 VRAM2002.U3 VRAM2002.U12 VRAM2002.U14 Y1.2 Y1.4 Y2002.2 Y2002.4 Y2004.2 Y2004.4 Y2005.2 Y2005.4
V3A_BOOT: PR239.2 PU11.1
V3A_BOOT_R: PC229.1 PR239.1
V3A_EN: PC79.2 PR77.1 PR83.2 PU11.6
V3A_PWRGD: PR244.1 PU11.7
V3A_VBYP: PC227.1 PR68.2 PR70.2 PU11.11
V3A_VOUT: PC71.2 PR72.2 PR78.2 PR236.1 PU11.10(VOUT)
V5P5A_BOOT: PR115.2 PU15.1
V5P5A_BOOT_R: PC116.1 PR115.1
V5P5A_EN: PC271.2 PR276.1 PR279.2 PU15.6
V5P5A_PWRGD: PR273.1 PU15.7
V5P5A_VOUT: PC267.2 PR274.2 PR277.2 PR278.2 PU15.10(VOUT)
VBUS_EN: R6510.2 R6528.1 U2034.15
VBUS_EN_EC_R: Q2039.3 R6528.2 U2035.4
VDD08_PG: PR9103.2 PR9104.2 PR77865.1
VDDBT_RTC: C2512.1 C2513.1 J1.1 Q2025.3 R2397.1 R2399.1 U2030.AT11
VDDCI_CORE_SENSE: PR77849.1 U2029.AV13
VDDP: PQ2000.1 PQ2000.2 PQ2000.3(S_3) PR9286.1 PR9295.2 R2409.1 R2410.1 R2509.2
VDDP_S5: PJ2000.1 PQ2000.5 R2411.1
VDDQ_BOOT: PR132.2 PU1.18
VDDQ_PG: PR128.1 PU1.8
VDDQ_PVIN: PC10.2 PC11.1 PC12.1 PC138.2 PC140.1 PJ1.2 PU1.7
VDDQ_SLP_S4: PC125.2 PR124.1 PR126.2 PU1.11
VDDQ_SW: PC139.2 PL2.1 PR129.1 PU1.17
VDDQ_SW_VPP: PL1.1 PU1.15
VDDQ_VCC: PC1.2 PC2.1 PC3.1 PR2.2 PU1.13 PU1.14
VDDQ_VDDQSNS: PR9300.2 PR9301.1 PU1.5
VDDQ_VLDOIN: PC16.1 PR6.2 PU1.1
VDDQ_VTT: PC18.1 PC142.1 PR8.1 PR130.1 PU1.2
VDDQ_VTT_CNTL: PC126.2 PR125.1 PU1.10(VTT_CNTL)
VDDQ_VTTREF: PC15.2 PR9.1 PU1.6
VDDQ_VTTSNS: PR8.2 PU1.4
VSS_GPU_SENSE: PR9059.1 U2029.AU13
2ND_MBCLK: Q2031.3 Q2038.6 R315.1 R746.2 R8128.1 U13.115
2ND_MBDATA: Q2031.6 Q2038.3 R314.1 R754.2 R8118.1 U13.116
32K_X1: C2577.1 R2408.1 U2030.AY1 Y2003.1
