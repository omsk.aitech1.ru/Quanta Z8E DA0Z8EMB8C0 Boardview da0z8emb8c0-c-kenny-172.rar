# Allegro board da0z8emb8c0-c-kenny-172.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ9: length 58
  TOP w0.102: v2(44.77,84.19) 43.73,85.23 U2018.D3
  IN3 w0.089: v2(44.77,84.19) 45.13,83.82 46.99,83.82 47.19,84.02 48.83,84.02 49.32,84.51 51,84.51 51.13,84.64 51.13,84.69 51.45,85.01 57.23,85.01 57.49,84.75 57.49,84.64 57.62,84.51 63.93,84.51 64.22,84.22 64.22,83.24 64.33,83.13 64.47,83.13 64.58,83.24 64.58,83.51 64.68,83.61 64.83,83.61 64.93,83.51 64.93,80.48 65.04,80.38 65.19,80.38 65.29,80.48 65.29,82.8 65.39,82.9 65.54,82.9 65.64,82.8 65.64,80.48 65.75,80.38 65.88,80.38 65.99,80.48 65.99,82.05 66.09,82.16 66.24,82.16 66.34,82.05 66.34,80.48 66.45,80.38 74.13,80.38 75.8,78.71 79.05,78.71 80.81,76.95 v1(81.19,76.95)
  BOTTOM w0.102: v1(81.19,76.95) 81.76,76.95 83.44,75.27 83.44,73.38 U2030.A25
M_B_DQ10: length 57.9
  TOP w0.102: U2018.C8 v2(44.93,80.91)
  IN3 w0.089: v1(80.17,74.84) 80.1,74.84 78.22,76.71 74.98,76.71 73.31,78.38 62.82,78.38 61.03,80.17 60.91,80.17 60.81,80.08 60.69,80.08 60.56,80.2 60.56,80.33 60.65,80.42 60.65,80.55 60.55,80.65 51.6,80.65 51.5,80.75 51.5,80.9 51.6,81.01 53.99,81.01 54.08,81.09 54.08,81.48 53.53,82.03 52.28,82.03 52.03,81.77 51.82,81.77 51.57,82.03 51.24,82.03 51.13,81.92 51.13,80.82 51.03,80.71 50.88,80.71 50.78,80.82 50.78,82.21 50.67,82.31 50.53,82.31 50.42,82.21 50.42,80.82 50.32,80.71 50.17,80.71 50.07,80.82 50.07,81.9 49.94,82.03 48.17,82.03 48.07,81.92 48.07,81.78 48.17,81.67 48.91,81.67 49.01,81.57 49.01,81.42 48.91,81.32 48.01,81.32 47.94,81.39 46.03,81.39 45.92,81.27 45.53,81.27 45.44,81.19 45.26,81.19 45.15,81.31 44.73,81.31 44.64,81.39 44.51,81.39 44.42,81.3 44.42,81.18 44.51,81.09 44.51,81.01 44.62,80.91 v2(44.93,80.91)
  BOTTOM w0.102: U2030.D27 82.01,72.47 81.53,72.95 81.53,73.59 81.21,73.9 81.21,74.03 80.99,74.26 80.99,74.58 80.72,74.84 v1(80.17,74.84)
M_B_DQ11: length 57.7
  TOP w0.102: U2018.D7 v2(44.13,81.71)
  IN3 w0.089: v2(44.13,81.71) 44.06,81.77 43.08,81.77 42.99,81.68 42.99,81.39 42.86,81.27 42.41,81.27 42.3,81.16 42.3,80.47 42.41,80.37 42.56,80.37 42.66,80.47 42.66,80.81 42.76,80.91 42.91,80.91 43.02,80.81 43.02,80.47 43.12,80.37 43.27,80.37 43.37,80.47 43.37,81.29 43.48,81.39 43.62,81.39 43.73,81.29 43.73,80.58 43.83,80.47 46.02,80.47 46.13,80.58 46.13,80.94 46.23,81.04 46.38,81.04 46.48,80.94 46.48,80.47 46.59,80.37 46.73,80.37 46.84,80.47 46.84,80.94 46.94,81.04 47.09,81.04 47.19,80.94 47.19,80.47 47.3,80.37 47.45,80.37 47.55,80.47 47.55,80.94 47.65,81.04 47.8,81.04 47.9,80.94 47.9,80.58 48.01,80.47 49.25,80.47 49.36,80.58 49.36,81.56 49.46,81.66 49.61,81.66 49.71,81.56 49.71,80.47 49.82,80.37 51.16,80.37 51.23,80.31 59.92,80.31 60.8,79.43 61.29,79.43 62.68,78.04 73.16,78.04 74.83,76.37 78.08,76.37 80.33,74.13 80.33,72.33 80.45,72.2 80.71,72.2 80.83,72.32 v1(80.83,73.85)
  BOTTOM w0.102: v1(80.83,73.85) 80.91,73.85 81.32,73.44 81.32,72.7 U2030.C27
M_B_DQ12: length 58.2
  TOP w0.102: U2018.A3 46.53,84.91 v2(46.54,84.91)
  IN3 w0.089: v1(81.77,78.29) 81.77,78.12 81.67,78.01 81.2,78.01 79.48,79.74 76.94,79.74 76.84,79.84 76.84,80.51 76.73,80.61 76.59,80.61 76.48,80.51 76.48,79.84 76.38,79.74 76.23,79.74 76.13,79.84 76.13,81.42 76.02,81.53 75.87,81.53 75.77,81.42 75.77,80.55 75.67,80.45 75.52,80.45 75.41,80.55 75.41,81.3 75.31,81.41 68.49,81.41 64.36,85.54 63.54,85.54 63.43,85.64 63.43,86.47 63.33,86.57 63.18,86.57 63.08,86.47 63.08,85.64 62.97,85.54 62.83,85.54 62.72,85.64 62.72,86.68 62.62,86.78 57.84,86.78 57.09,86.04 54.64,86.04 54.54,86.14 54.54,86.68 54.43,86.78 54.29,86.78 54.18,86.68 54.18,86.14 54.08,86.04 50.83,86.04 50.56,86.3 50.14,86.3 50.04,86.2 50.04,85.69 49.93,85.58 49.79,85.58 49.68,85.69 49.68,86.2 49.58,86.3 49.43,86.3 49.33,86.2 49.33,85.68 49.22,85.57 49.08,85.57 48.97,85.68 48.97,85.93 48.87,86.04 48.28,86.04 48.18,85.93 48.18,85.47 47.75,85.05 46.68,85.05 v2(46.54,84.91)
  BOTTOM w0.089: 84.21,73.62 84.21,73.15 84.4,72.96 84.4,72.62 U2030.C23
  BOTTOM w0.102: 84.21,73.62 84.08,73.74 84.08,76.56 82.35,78.29 v1(81.77,78.29)
M_B_DQ13: length 57.8
  TOP w0.102: U2018.C3 44.53,85.06 v2(44.77,84.82)
  IN3 w0.089: v1(83.55,76.52) 83.55,76.44 83.42,76.31 83.05,76.31 82.96,76.22 82.96,75.94 82.87,75.86 82.69,75.86 82.6,75.94 82.6,76.22 82.52,76.31 82.35,76.31 81.34,77.33 80.92,77.33 79.19,79.05 75.94,79.05 74.28,80.72 67.51,80.72 67.41,80.82 67.41,81.52 67.31,81.62 67.16,81.62 67.05,81.52 67.05,80.82 66.95,80.72 66.8,80.72 66.7,80.82 66.7,82.23 64.07,84.85 60.01,84.85 59.9,84.96 59.9,85.99 59.8,86.1 59.65,86.1 59.55,85.99 59.55,84.96 59.44,84.85 59.29,84.85 59.19,84.96 59.19,85.99 59.09,86.09 58.94,86.09 58.84,85.99 58.84,84.96 58.73,84.85 58.58,84.85 58.48,84.96 58.48,85.99 58.38,86.09 58.23,86.09 58.12,85.99 58.12,84.96 58.02,84.85 57.87,84.85 57.77,84.96 57.77,85.25 57.66,85.35 51.3,85.35 50.83,84.88 49.2,84.88 48.68,84.36 47.05,84.36 46.85,84.16 45.42,84.16 v2(44.77,84.82)
  BOTTOM w0.089: U2030.B24 84.01,73.5
  BOTTOM w0.102: 84.01,73.5 84.01,73.5 84.01,73.52 83.87,73.66 83.87,76.2 v1(83.55,76.52)
M_B_DQ14: length 57.9
  TOP w0.102: U2018.C7 v2(44.93,81.71)
  IN3 w0.089: v2(44.93,81.71) 45.02,81.8 45.02,82.03 44.93,82.11 43.59,82.11 43.49,82.22 43.49,82.37 43.59,82.47 43.78,82.47 43.88,82.57 43.88,82.81 43.99,82.92 44.14,82.92 44.24,82.82 44.24,82.57 44.34,82.47 45.13,82.47 45.53,82.07 47.2,82.07 47.84,82.71 49.68,82.71 50.17,83.2 53.79,83.2 54.18,82.81 55.14,82.81 55.53,83.2 55.96,83.2 56.35,82.81 57.06,82.81 57.45,83.2 58.08,83.2 58.18,83.1 58.18,81.44 58.29,81.34 58.43,81.34 58.54,81.44 58.54,83.1 58.64,83.2 58.79,83.2 58.89,83.1 58.89,81.44 59,81.34 59.15,81.34 59.25,81.44 59.25,83.1 59.35,83.2 59.5,83.2 59.61,83.1 59.61,81.44 59.71,81.34 60.84,81.34 62.23,79.95 62.38,79.95 62.59,80.16 62.73,80.16 62.83,80.06 62.83,79.89 62.62,79.68 62.62,79.56 63.11,79.07 73.59,79.07 75.26,77.4 78.51,77.4 80.35,75.56 80.58,75.56 v1(80.71,75.42)
  BOTTOM w0.102: U2030.C26 82.36,72.66 82.36,73 81.95,73.41 81.95,74.03 81.95,74.88 81.41,75.42 v1(80.71,75.42)
M_B_DQ15: length 57.7
  TOP w0.102: U2018.B8 45.69,81.67 v2(45.73,81.67)
  IN3 w0.089: v2(45.73,81.67) 45.8,81.73 47.34,81.73 47.98,82.37 50.1,82.37 50.21,82.48 50.21,82.76 50.31,82.86 50.89,82.86 51,82.76 51,82.48 51.1,82.37 51.25,82.37 51.35,82.48 51.35,82.76 51.46,82.86 53.65,82.86 53.76,82.76 53.76,82.29 54.02,82.03 54.29,82.03 54.42,81.9 54.42,81.1 54.52,80.99 54.67,80.99 54.78,81.1 54.78,81.92 54.88,82.03 55.03,82.03 55.13,81.92 55.13,81.1 55.24,80.99 55.46,80.99 55.57,81.1 55.57,82.76 55.67,82.86 55.82,82.86 55.92,82.76 55.92,81.1 56.03,80.99 57.38,80.99 57.49,81.1 57.49,82.76 57.59,82.86 57.74,82.86 57.84,82.76 57.84,81.1 57.94,80.99 60.7,80.99 62.96,78.73 73.45,78.73 75.12,77.06 78.37,77.06 80.21,75.21 80.33,75.21 80.95,74.59 80.95,74.29 81.21,74.03 81.21,72.1 81.32,72 81.85,72 81.98,72.12 81.98,73.82 v1(81.47,74.33)
  BOTTOM w0.102: v1(81.47,74.33) 81.6,74.2 81.6,73.9 81.74,73.76 81.74,73.18 U2030.B27
M_B_DQ16: length 57.9
  TOP w0.102: U2017.H3 v2(40.93,73.53)
  IN3 w0.089: v2(40.93,73.53) 41.22,73.53 41.33,73.63 41.33,75.31 41.24,75.4 41.24,75.58 41.33,75.67 41.33,76.33 41.43,76.44 41.68,76.44 41.78,76.54 41.78,76.95 41.68,77.05 41.68,77.23 42.08,77.63 42.08,78.42 42.3,78.64 42.78,78.64 42.88,78.54 42.88,78.08 42.98,77.98 43.13,77.98 43.24,78.08 43.24,78.54 43.34,78.64 43.49,78.64 43.59,78.54 43.59,78.08 43.7,77.98 43.84,77.98 43.95,78.08 43.95,78.54 44.05,78.64 44.2,78.64 44.3,78.54 44.3,78.08 44.41,77.98 44.55,77.98 44.66,78.08 44.66,78.54 44.76,78.64 44.91,78.64 45.01,78.54 45.01,78.08 45.12,77.98 45.27,77.98 45.37,78.08 45.37,78.54 45.47,78.64 46.08,78.64 46.18,78.54 46.18,78.08 46.29,77.98 46.43,77.98 46.54,78.08 46.54,78.54 46.64,78.64 46.79,78.64 46.89,78.54 46.89,78.08 47,77.98 47.14,77.98 47.25,78.08 47.25,78.54 47.35,78.64 47.5,78.64 47.6,78.54 47.6,78.08 47.71,77.98 47.86,77.98 47.96,78.08 47.96,78.54 48.06,78.64 48.21,78.64 48.32,78.54 48.32,78.08 48.42,77.98 50.91,77.98 51.18,77.7 60.37,77.7 60.48,77.6 60.48,76.42 60.58,76.31 72.25,76.31 72.35,76.21 72.35,74.75 72.45,74.64 74.74,74.64 74.83,74.55 74.83,74.39 74.91,74.3 75.09,74.3 75.18,74.39 75.18,74.55 75.27,74.64 75.63,74.64 75.73,74.54 76.03,74.54 76.13,74.64 76.41,74.64 76.5,74.55 76.68,74.55 76.77,74.64 77.04,74.64 77.15,74.54 77.15,74.28 77.05,74.18 v1(76.88,74.18)
  BOTTOM w0.102: v1(76.88,74.18) 76.88,74.15 77.26,73.77 78.67,73.77 80.04,72.41 U2030.C30
M_B_DQ17: length 57.9
  TOP w0.102: U2017.G2 41.33,74.73 v2(41.73,75.13)
  IN3 w0.089: v2(41.73,75.13) 42.13,75.53 42.13,77.13 42.63,77.64 49.34,77.64 49.45,77.53 49.45,76.83 49.55,76.72 49.7,76.72 49.8,76.83 49.8,77.53 49.91,77.64 50.05,77.64 50.16,77.53 50.16,76.83 50.26,76.72 50.41,76.72 50.51,76.83 50.51,77.53 50.62,77.64 50.76,77.64 50.87,77.53 50.87,76.83 50.97,76.72 51.12,76.72 51.22,76.83 51.22,77.26 51.33,77.36 54.04,77.36 54.14,77.26 54.14,76.83 54.25,76.72 54.4,76.72 54.5,76.83 54.5,77.26 54.6,77.36 54.75,77.36 54.86,77.26 54.86,76.83 54.96,76.72 55.11,76.72 55.21,76.83 55.21,77.26 55.32,77.36 55.46,77.36 55.57,77.26 55.57,76.83 55.67,76.72 55.82,76.72 55.92,76.83 55.92,77.26 56.03,77.36 57.38,77.36 57.49,77.26 57.49,76.83 57.59,76.72 57.74,76.72 57.84,76.83 57.84,77.22 57.94,77.33 58.09,77.33 58.2,77.22 58.2,76.42 58.3,76.31 58.45,76.31 58.55,76.42 58.55,77.22 58.66,77.33 58.8,77.33 58.91,77.22 58.91,76.29 59.01,76.19 59.16,76.19 59.26,76.29 59.26,77.25 59.37,77.36 60.03,77.36 60.13,77.26 60.13,76.69 59.96,76.52 59.96,76.15 60.13,75.97 71.58,75.97 72.01,75.55 72.01,74.4 72.11,74.3 74.14,74.3 74.48,73.96 75.38,73.96 v1(75.61,74.18)
  BOTTOM w0.102: v1(75.61,74.18) 75.61,74.15 76.34,73.42 78.64,73.42 80.41,71.65 U2030.E29
M_B_DQ18: length 58.1
  TOP w0.102: U2017.H7 40.9,71.1 v2(40.93,71.1)
  IN3 w0.089: v2(40.93,71.1) 41.16,71.1 41.56,71.5 41.89,71.5 42.13,71.27 42.13,70.04 42.25,69.92 42.57,69.92 42.67,69.81 42.67,69.66 42.57,69.56 42.23,69.56 42.13,69.46 42.13,69.31 42.23,69.2 42.57,69.2 42.67,69.1 42.67,67.98 42.78,67.87 42.92,67.87 43.03,67.98 43.03,71.05 42.59,71.49 42.59,73.33 43.99,74.73 44.28,74.73 45.88,76.33 47.89,76.33 47.99,76.22 47.99,75.52 48.09,75.41 53.85,75.41 53.97,75.3 53.97,74.89 54.07,74.79 54.22,74.79 54.32,74.89 54.32,75.3 54.43,75.41 57.33,75.41 58.09,74.66 65.69,74.66 65.79,74.56 65.79,73.1 65.89,72.99 73.6,72.99 74.55,72.04 74.83,72.04 74.92,72.13 74.92,72.39 75.01,72.48 75.19,72.48 75.27,72.39 75.27,72.13 75.36,72.04 75.55,72.04 75.68,71.91 v1(75.68,71.66)
  BOTTOM w0.089: 78.86,69.71 79.34,69.71 79.48,69.85 79.72,69.85 80.06,69.51 U2030.H29
  BOTTOM w0.102: v1(75.68,71.66) 76.39,70.95 77.94,70.95 78.22,70.68 78.22,69.94 78.45,69.71 78.86,69.71
M_B_DQ19: length 58.1
  TOP w0.102: U2017.F7 42.1,70.73 v2(41.73,71.1)
  IN3 w0.089: v2(41.73,71.1) 41.73,70.87 41.33,70.47 41.33,68.35 41.43,68.24 42.23,68.24 42.33,68.14 42.33,67.99 42.23,67.89 41.38,67.89 41.28,67.78 41.28,67.64 41.38,67.53 43.27,67.53 43.37,67.64 43.37,71.19 42.93,71.63 42.93,73.19 44.13,74.39 44.42,74.39 45.84,75.81 46.1,75.81 46.37,75.53 46.83,75.53 46.94,75.42 46.94,75.18 47.04,75.07 47.19,75.07 47.29,75.18 47.29,75.88 47.4,75.99 47.54,75.99 47.65,75.88 47.65,75.18 47.75,75.07 50.94,75.07 51.49,74.52 52.69,74.52 52.89,74.32 54.69,74.32 54.78,74.41 54.78,74.54 54.87,74.63 55.05,74.63 55.14,74.54 55.14,74.41 55.23,74.32 55.41,74.32 55.49,74.41 55.49,74.52 55.58,74.61 55.76,74.61 55.85,74.52 55.85,74.41 55.94,74.32 56.48,74.32 56.68,74.52 57.23,74.52 57.44,74.32 65.34,74.32 65.45,74.21 65.45,72.75 65.55,72.65 73.46,72.65 74.44,71.66 v1(74.48,71.66)
  BOTTOM w0.089: U2030.H31 79.61,69.51 78.94,69.51
  BOTTOM w0.102: v1(74.48,71.66) 75.55,70.6 77.68,70.6 77.91,70.37 77.91,69.91 78.34,69.48 78.91,69.48 78.94,69.51
M_B_DQ20: length 57.7
  TOP w0.102: U2017.J3 v2(40.93,72.73)
  IN3 w0.089: v1(79.31,74.15) 79.31,73.75 79.21,73.65 78.93,73.65 78.84,73.74 78.84,74.63 77.79,75.67 73.48,75.67 73.38,75.78 73.38,76.84 72.87,77.34 61.61,77.34 61.5,77.45 61.5,78.23 61,78.73 60.05,78.73 59.96,78.82 59.96,79.15 59.87,79.23 59.69,79.23 59.6,79.15 59.6,78.82 59.51,78.73 59.35,78.73 59.25,78.84 59.25,79.38 59.15,79.49 59,79.49 58.89,79.38 58.89,78.84 58.79,78.73 58.64,78.73 58.54,78.84 58.54,79.38 58.43,79.49 58.29,79.49 58.18,79.38 58.18,78.84 58.08,78.73 57.93,78.73 57.83,78.84 57.83,79.36 57.72,79.46 51.08,79.46 50.87,79.67 41.87,79.67 39.84,77.64 39.84,73.56 40.68,72.73 v2(40.93,72.73)
  BOTTOM w0.102: v1(79.31,74.15) 79.84,74.15 80.69,73.31 U2030.A28
M_B_DQ21: length 57.9
  TOP w0.102: U2017.H2 v2(40.93,74.33)
  IN3 w0.089: v1(78.12,74.2) 78.12,74.37 77.51,74.99 72.8,74.99 72.69,75.09 72.69,76.55 72.59,76.66 60.92,76.66 60.82,76.76 60.82,77.94 60.71,78.05 56.07,78.05 55.98,78.13 55.98,78.47 55.9,78.56 55.72,78.56 55.63,78.47 55.63,78.13 55.54,78.05 53.83,78.05 53.72,78.15 53.72,78.67 53.62,78.78 53.47,78.78 53.37,78.67 53.37,78.15 53.26,78.05 53.12,78.05 53.01,78.15 53.01,78.67 52.91,78.78 52.76,78.78 52.66,78.67 52.66,78.15 52.55,78.05 51.32,78.05 51.05,78.32 50.9,78.32 50.79,78.43 50.79,78.75 50.69,78.85 50.54,78.85 50.44,78.75 50.44,78.43 50.33,78.32 50.19,78.32 50.08,78.43 50.08,78.88 49.98,78.98 49.83,78.98 49.73,78.88 49.73,78.43 49.62,78.32 49.47,78.32 49.37,78.43 49.37,78.88 49.27,78.98 49.12,78.98 49.01,78.88 49.01,78.43 48.91,78.32 48.76,78.32 48.66,78.43 48.66,78.88 48.55,78.99 42.16,78.99 41.74,78.57 41.74,77.77 41.63,77.67 41.08,77.67 40.97,77.55 40.97,77.09 40.91,77.03 40.63,77.03 40.53,76.92 40.53,76.78 40.63,76.67 40.83,76.67 40.94,76.57 40.94,76.42 40.83,76.32 40.63,76.32 40.53,76.21 40.53,74.02 40.63,73.92 40.83,73.92 40.93,74.01 v2(40.93,74.33)
  BOTTOM w0.102: v1(78.12,74.2) 78.63,74.2 80.07,72.76 80.36,72.76 U2030.D28
M_B_DQ22: length 57.8
  TOP w0.102: U2017.J7 40.93,71.93 v2(40.93,72.01)
  IN3 w0.089: v1(78.04,71.66) 78.04,72.28 77.94,72.38 77.71,72.38 77.62,72.29 77.62,72.21 77.53,72.12 77.35,72.12 77.26,72.21 77.26,72.29 77.17,72.38 77,72.38 76.91,72.29 76.91,72.21 76.82,72.12 76.64,72.12 76.55,72.21 76.55,72.29 76.46,72.38 76.13,72.38 75.52,72.99 74.08,72.99 73.74,73.33 66.24,73.33 66.13,73.44 66.13,74.9 66.03,75 58.23,75 57.48,75.76 48.44,75.76 48.33,75.86 48.33,76.57 48.23,76.67 44.62,76.67 44.51,76.57 44.51,75.76 44.28,75.53 43.95,75.53 43.71,75.29 43.71,74.94 42.25,73.47 42.25,71.95 42.14,71.85 41.42,71.85 41.08,71.5 40.19,71.5 40.08,71.4 40.08,68.54 39.98,68.44 39.83,68.44 39.73,68.54 39.73,71.91 39.83,72.01 v2(40.93,72.01)
  BOTTOM w0.102: v1(78.04,71.66) 78.92,70.79 79.18,70.79 79.46,70.51 U2030.F31
M_B_DQ23: length 57.9
  TOP w0.102: U2017.H8 40.9,70.3 v2(40.93,70.3)
  IN3 w0.089: v1(76.87,71.66) 76.76,71.66 76.64,71.55 76.64,71.36 76.76,71.25 78.06,71.25 78.17,71.14 78.17,70.99 78.06,70.89 74.73,70.89 73.31,72.31 65.21,72.31 65.11,72.41 65.11,73.87 65,73.98 57.3,73.98 57.09,74.18 56.82,74.18 56.62,73.98 52.75,73.98 52.55,74.18 51.35,74.18 50.8,74.73 45.25,74.73 44.56,74.04 44.27,74.04 43.93,73.7 43.27,73.04 43.27,71.77 43.71,71.33 43.71,67.29 43.61,67.19 40.3,67.19 40.19,67.3 40.19,67.68 40.44,67.92 40.44,70.2 40.54,70.3 v2(40.93,70.3)
  BOTTOM w0.102: U2030.G30 79.82,70.2 79.48,70.2 79.21,70.47 78.9,70.47 78.12,71.26 77.28,71.26 v1(76.87,71.66)
M_B_DQ24: length 58.1
  TOP w0.102: v2(45.74,73.53) 45.26,73.53 44.93,73.86 44.93,74.33 U2017.C2
  IN3 w0.089: v2(45.74,73.53) 45.74,73.81 45.86,73.93 46.04,73.93 46.14,73.82 46.14,73.36 46.37,73.13 47.73,73.13 47.83,73.02 47.83,72.55 47.94,72.45 50.44,72.45 50.93,72.93 61.11,72.93 61.22,72.83 61.22,71.37 61.32,71.26 70.89,71.26 70.99,71.16 70.99,69.38 71.1,69.27 71.24,69.27 71.35,69.38 71.35,71.16 71.45,71.26 71.6,71.26 71.7,71.16 71.7,68.74 71.81,68.64 71.95,68.64 72.06,68.74 72.06,71.16 72.16,71.26 72.31,71.26 72.41,71.16 72.41,68.34 72.52,68.24 72.67,68.24 72.77,68.34 72.77,71.02 72.87,71.12 73.02,71.12 73.13,71.02 73.13,69.92 73.23,69.82 73.38,69.82 73.48,69.92 73.48,70.31 73.58,70.41 73.73,70.41 73.84,70.31 73.84,69.92 73.94,69.82 76.23,69.82 76.34,69.92 v1(76.34,70.19)
  BOTTOM w0.089: 79.08,68.71 79.37,68.71 79.49,68.83 79.74,68.83 80.06,68.51 U2030.J29
  BOTTOM w0.102: v1(76.34,70.19) 76.34,69.33 76.69,68.97 77.51,68.97 77.66,68.82 78.97,68.82 79.08,68.71
M_B_DQ25: length 58.1
  TOP w0.102: U2017.A3 46.53,73.53 v2(46.54,73.53)
  IN3 w0.089: v2(46.54,73.53) 46.6,73.47 47,73.47 47.11,73.57 47.11,73.93 47.21,74.03 47.36,74.03 47.46,73.93 47.46,73.57 47.57,73.47 47.72,73.47 47.82,73.57 47.82,73.93 47.92,74.03 48.07,74.03 48.18,73.93 48.18,72.89 48.28,72.79 48.43,72.79 48.53,72.89 48.53,73.93 48.64,74.03 48.78,74.03 48.89,73.93 48.89,72.89 48.99,72.79 49.14,72.79 49.24,72.89 49.24,73.93 49.35,74.03 49.49,74.03 49.6,73.93 49.6,72.89 49.7,72.79 49.85,72.79 49.95,72.89 49.95,73.93 50.06,74.03 50.21,74.03 50.31,73.93 50.31,73.31 50.42,73.19 50.67,73.19 50.76,73.28 50.76,73.47 50.85,73.56 51.03,73.56 51.12,73.47 51.12,73.37 51.21,73.28 61.46,73.28 61.56,73.17 61.56,71.71 61.67,71.61 61.81,71.61 61.92,71.71 61.92,73.17 62.02,73.28 62.17,73.28 62.27,73.17 62.27,71.71 62.38,71.61 62.52,71.61 62.63,71.71 62.63,73.17 62.73,73.28 62.88,73.28 62.98,73.17 62.98,71.71 63.09,71.61 63.24,71.61 63.34,71.71 63.34,73.17 63.44,73.28 63.59,73.28 63.7,73.17 63.7,71.71 63.8,71.61 63.95,71.61 64.05,71.71 64.05,73.17 64.16,73.28 64.3,73.28 64.41,73.17 64.41,71.71 64.51,71.61 73.02,71.61 74.44,70.19 v1(74.94,70.19)
  BOTTOM w0.089: 78.97,68.51 79.61,68.51 U2030.J31
  BOTTOM w0.102: 78.97,68.51 78.89,68.59 76.54,68.59 v1(74.94,70.19)
M_B_DQ26: length 57.9
  TOP w0.102: U2017.D7 v2(44.13,71.13)
  IN3 w0.089: v2(44.13,71.13) 44.42,71.13 44.53,71.02 44.53,68.44 44.63,68.33 44.78,68.33 44.88,68.44 44.88,68.97 44.99,69.07 45.13,69.07 45.24,68.97 45.24,67.58 45.34,67.47 49.01,67.47 49.27,67.21 50.91,67.21 51.17,67.47 54.8,67.47 54.91,67.58 54.91,68.14 55.01,68.24 55.16,68.24 55.26,68.14 55.26,67.58 55.37,67.47 55.87,67.47 56.07,67.68 56.53,67.68 56.63,67.57 56.63,67.34 56.74,67.24 56.89,67.24 56.99,67.34 56.99,67.57 57.09,67.68 57.24,67.68 57.35,67.57 57.35,67.34 57.45,67.24 57.6,67.24 57.7,67.34 57.7,68.14 57.81,68.24 57.95,68.24 58.06,68.14 58.06,67.22 58.16,67.11 58.31,67.11 58.41,67.22 58.41,68.14 58.52,68.24 58.66,68.24 58.77,68.14 58.77,67.01 58.87,66.91 59.02,66.91 59.12,67.01 59.12,68.14 59.23,68.24 59.37,68.24 59.48,68.14 59.48,67.6 61.28,65.79 70.38,65.79 71.74,64.43 76.95,64.43 77.06,64.54 77.06,64.78 77.16,64.88 77.31,64.88 77.41,64.78 77.41,63.97 77.52,63.87 77.66,63.87 77.77,63.97 77.77,64.78 77.87,64.88 78.57,64.88 78.67,64.99 78.67,65.13 78.57,65.24 77.21,65.24 77.11,65.34 77.11,65.49 v1(77.27,65.65)
  BOTTOM w0.102: U2030.L29 80.06,66.51 79.6,66.05 79.6,65.96 78.88,65.24 77.68,65.24 v1(77.27,65.65)
M_B_DQ27: length 57.8
  TOP w0.102: U2017.C8 v2(44.93,69.53)
  IN3 w0.089: v1(76.69,65.65) 76.73,65.61 76.73,64.88 76.62,64.78 71.88,64.78 70.52,66.13 61.43,66.13 60.28,67.28 60.28,68.48 60.17,68.59 53.36,68.59 53.2,68.42 53.2,68.24 53.26,68.19 53.26,67.92 53.15,67.82 51.03,67.82 50.77,67.56 50.59,67.56 50.48,67.66 50.48,69.66 50.38,69.77 50.23,69.77 50.13,69.66 50.13,67.66 50.02,67.56 49.41,67.56 49.31,67.66 49.31,67.81 49.41,67.91 49.67,67.91 49.77,68.02 49.77,69.66 49.67,69.77 49.52,69.77 49.42,69.66 49.42,68.42 49.31,68.31 49.16,68.31 49.06,68.42 49.06,69.66 48.96,69.77 48.81,69.77 48.7,69.66 48.7,68.42 48.6,68.31 48.45,68.31 48.35,68.42 48.35,69.66 48.24,69.77 48.1,69.77 47.99,69.66 47.99,68.41 47.89,68.31 47.74,68.31 47.64,68.41 47.64,69.66 47.53,69.77 47.39,69.77 47.28,69.66 47.28,67.92 47.18,67.82 47.03,67.82 46.93,67.92 46.93,69.02 46.82,69.13 45.56,69.13 45.16,69.53 v2(44.93,69.53)
  BOTTOM w0.102: v1(76.69,65.65) 77.09,66.06 77.61,66.06 77.89,66.34 79.44,66.34 U2030.L31
M_B_DQ28: length 57.8
  TOP w0.102: U2017.D3 44.91,72.74 v2(44.91,72.73)
  IN3 w0.089: v2(44.91,72.73) 44.91,72.5 44.81,72.4 44.42,72.4 44.32,72.5 44.32,73.1 44.48,73.27 44.77,73.27 45.03,73.52 45.24,73.52 45.36,73.41 45.36,73.25 45.48,73.13 45.89,73.13 46.23,72.78 47.36,72.78 47.49,72.66 47.49,72.35 47.74,72.1 50.58,72.1 51.04,72.56 52.39,72.56 52.53,72.41 53,72.41 53.15,72.56 60.77,72.56 60.88,72.46 60.88,71.03 60.98,70.92 70.54,70.92 70.65,70.82 70.65,69.05 70.78,68.93 71.23,68.93 71.36,68.8 71.36,68.6 71.66,68.3 71.79,68.3 71.92,68.17 71.92,68.04 72.07,67.89 73.01,67.89 73.11,68 73.11,69.37 73.22,69.47 73.36,69.47 73.47,69.37 73.47,68 73.57,67.89 73.72,67.89 73.82,68 73.82,69.37 73.93,69.47 74.08,69.47 74.18,69.37 74.18,68 74.28,67.89 74.43,67.89 74.53,68 74.53,69.37 74.64,69.47 74.79,69.47 74.89,69.37 74.89,68.08 74.99,67.97 75.14,67.97 75.25,68.08 75.25,69.37 75.35,69.47 75.5,69.47 75.6,69.37 75.6,68.28 75.71,68.18 75.85,68.18 75.96,68.28 75.96,69.37 76.06,69.47 76.39,69.47 76.73,69.82 77.11,69.82 77.15,69.77 77.37,69.77 77.53,69.94 77.53,70.16 v1(77.5,70.19)
  BOTTOM w0.089: 78.88,69.26 79.04,69.26 79.09,69.31 79.37,69.31 79.5,69.17 79.85,69.17 U2030.H30
  BOTTOM w0.102: v1(77.5,70.19) 77.5,69.96 78.21,69.26 78.88,69.26
M_B_DQ29: length 57.8
  TOP w0.102: U2017.C3 44.53,73.92 v2(45.71,72.73)
  IN3 w0.089: v2(45.71,72.73) 45.71,72.55 45.82,72.44 47.02,72.44 47.15,72.31 47.15,72.19 47.22,72.11 47.22,71.93 47.4,71.76 50.97,71.76 51.1,71.89 51.1,72.14 51.18,72.22 52.13,72.22 52.28,72.07 52.45,72.07 52.54,71.98 52.54,71.85 52.63,71.76 52.81,71.76 52.9,71.85 52.9,71.98 52.99,72.07 53.25,72.07 53.4,72.22 60.43,72.22 60.53,72.11 60.53,70.68 60.64,70.58 70.2,70.58 70.31,70.47 70.31,68.69 70.41,68.59 70.89,68.59 71.92,67.55 75.21,67.55 75.4,67.74 75.91,67.74 76.3,68.14 76.3,68.97 76.4,69.07 76.55,69.07 76.66,68.97 76.66,68.19 76.76,68.09 76.91,68.09 77.01,68.19 77.01,68.97 77.12,69.07 77.26,69.07 77.37,68.97 77.37,68.19 77.47,68.09 77.62,68.09 77.72,68.19 77.72,69.1 77.83,69.2 77.97,69.2 78.08,69.1 78.08,68.16 78.18,68.06 78.33,68.06 78.43,68.16 78.43,69.1 78.54,69.2 78.69,69.2 78.79,69.1 78.79,67.19 78.69,67.08 77.89,67.08 77.79,66.98 77.79,66.83 77.89,66.73 79.04,66.73 79.14,66.83 79.14,69.45 79.04,69.56 77.64,69.56 v1(77.48,69.4)
  BOTTOM w0.102: v1(77.48,69.4) 77.59,69.4 77.94,69.04 79.18,69.04 U2030.H32
M_B_DQ30: length 58
  TOP w0.102: U2017.B8 v2(45.73,69.53)
  IN3 w0.089: v2(45.73,69.53) 45.96,69.53 46.54,70.11 50.72,70.11 50.83,70 50.83,68.26 50.93,68.16 51.08,68.16 51.18,68.26 51.18,68.61 51.28,68.71 53,68.71 53.22,68.93 60.52,68.93 60.62,68.82 60.62,67.42 60.73,67.32 60.87,67.32 60.98,67.42 60.98,68.82 61.08,68.93 61.23,68.93 61.33,68.82 61.33,66.99 61.44,66.88 61.58,66.88 61.69,66.99 61.69,68.82 61.79,68.93 61.94,68.93 62.04,68.82 62.04,66.84 62.15,66.74 62.3,66.74 62.4,66.84 62.4,68.82 62.5,68.93 62.65,68.93 62.76,68.82 62.76,66.58 62.86,66.48 63.57,66.48 64.03,66.93 64.63,66.93 64.71,66.85 64.71,66.62 64.8,66.53 64.98,66.53 65.07,66.62 65.07,66.85 65.16,66.93 67.5,66.93 67.59,66.85 67.59,66.75 67.68,66.66 67.86,66.66 67.95,66.75 67.95,66.85 68.04,66.93 70.2,66.93 72.02,65.12 72.48,65.12 72.59,65.22 72.59,65.79 72.69,65.9 72.84,65.9 72.94,65.79 72.94,65.22 73.05,65.12 73.19,65.12 73.3,65.22 73.3,65.79 73.4,65.9 73.55,65.9 73.65,65.79 73.65,65.22 73.76,65.12 73.9,65.12 74.01,65.22 74.01,65.79 74.11,65.9 74.26,65.9 74.36,65.79 74.36,65.22 74.47,65.12 75.6,65.12 75.71,65.22 75.71,65.55 75.6,65.65 v1(75.48,65.65)
  BOTTOM w0.102: v1(75.48,65.65) 76.14,66.31 77.43,66.31 77.69,66.57 79.22,66.57 79.51,66.86 79.86,66.86 U2030.L30
M_B_DQ31: length 57.7
  TOP w0.102: U2017.C7 v2(44.93,70.33)
  IN3 w0.089: v1(77.16,66.73) 77.06,66.64 77.06,66.49 77.17,66.38 78.95,66.38 79.06,66.28 79.06,66.13 78.95,66.03 76.77,66.03 76.57,66.23 76.29,66.23 76.08,66.03 74.77,66.03 74.55,66.24 72.27,66.24 72.19,66.15 72.19,65.79 72.1,65.71 71.92,65.71 71.83,65.79 71.83,66.15 71.74,66.24 71.38,66.24 70.35,67.28 65.34,67.28 65.23,67.38 65.23,69.17 65.13,69.27 64.98,69.27 64.88,69.17 64.88,67.38 64.77,67.28 64.62,67.28 64.52,67.38 64.52,69.17 64.42,69.27 64.27,69.27 64.17,69.17 64.17,67.38 64.06,67.28 63.91,67.28 63.81,67.38 63.81,69.17 63.71,69.27 63.56,69.27 63.45,69.17 63.45,66.92 63.35,66.82 63.2,66.82 63.1,66.92 63.1,69.17 62.99,69.27 53.08,69.27 52.86,69.05 51.27,69.05 51.17,69.16 51.17,70.35 51.06,70.45 46.4,70.45 45.91,69.96 45.78,69.96 45.71,70.04 45.71,70.35 45.6,70.45 45.46,70.45 45.35,70.35 45.35,70.02 45.25,69.92 45.02,69.92 44.89,70.05 44.89,70.29 v2(44.93,70.33)
  BOTTOM w0.102: U2030.L32 79.04,66.83 77.26,66.83 v1(77.16,66.73)
M_B_DQ32: length 58
  TOP w0.102: U2014.A3 v2(46.53,50.73)
  IN3 w0.089: v2(46.53,50.73) 46.47,50.67 46.23,50.67 46.13,50.77 46.13,51.8 46,51.93 45.79,51.93 45.66,52.06 45.66,52.24 45.79,52.36 46.48,52.36 46.61,52.24 46.61,51.99 46.72,51.88 46.88,51.88 46.97,51.96 46.97,52.27 47.06,52.36 47.23,52.36 47.32,52.27 47.32,51.8 47.41,51.71 47.58,51.71 47.68,51.81 47.68,52.27 47.77,52.36 48.02,52.36 48.14,52.25 48.14,52.08 48.05,52 48.05,51.82 48.16,51.71 48.32,51.71 48.37,51.76 48.62,51.76 48.67,51.71 50.06,51.71 51.09,50.68 51.27,50.68 51.37,50.79 54,50.79 54.09,50.7 54.09,50.2 54.17,50.11 54.35,50.11 54.44,50.2 54.44,50.7 54.53,50.79 57.24,50.79 57.36,50.67 57.36,50.23 57.45,50.14 57.62,50.14 57.72,50.24 57.72,51.14 57.83,51.24 57.97,51.24 58.08,51.14 58.08,50.27 58.18,50.16 58.33,50.16 58.43,50.27 58.43,51.19 58.54,51.3 58.69,51.3 58.79,51.19 58.79,50.23 58.89,50.13 59.04,50.13 59.15,50.24 59.15,50.64 59.25,50.74 59.4,50.74 59.5,50.64 59.5,50.27 59.6,50.18 59.78,50.18 59.87,50.27 59.87,50.64 59.97,50.75 60.15,50.75 60.23,50.66 60.23,50.25 60.31,50.18 60.49,50.18 60.59,50.28 60.59,50.7 60.64,50.75 60.77,50.75 61,50.51 61,50.3 61.15,50.15 62.31,50.15 62.4,50.24 62.4,50.66 62.49,50.75 62.66,50.75 62.76,50.65 62.76,50.24 62.84,50.15 63.02,50.15 63.11,50.24 63.11,50.66 63.2,50.75 63.37,50.75 63.47,50.65 63.47,50.24 63.56,50.15 63.73,50.15 63.82,50.24 63.82,50.66 63.91,50.75 64.08,50.75 64.18,50.65 64.18,50.24 64.27,50.15 64.46,50.15 64.56,50.26 64.56,50.4 64.66,50.5 64.81,50.5 64.96,50.35 64.96,50.24 65.05,50.15 72.91,50.15 73.66,49.4 76.25,49.4 76.35,49.3 76.35,49.12 76.25,49.02 75.02,49.02 74.92,48.92 74.92,48.54 75.04,48.41 75.31,48.41 75.5,48.6 76.1,48.6 76.21,48.5 76.21,48.32 75.9,48.01 v2(75.86,48.01)
  BOTTOM w0.102: U2030.AP29 80.07,47.51 79.74,47.18 79.49,47.18 79.26,47.4 79.1,47.4 79,47.31 76.57,47.31 v2(75.86,48.01)
M_B_DQ33: length 57.8
  TOP w0.102: U2014.D3 v2(44.13,50.73)
  IN3 w0.089: v2(44.13,50.73) 44.38,50.73 44.51,50.6 44.51,50.11 44.64,49.99 45,49.99 45.09,50.08 45.09,50.2 45.22,50.33 46.69,50.33 46.93,50.56 46.93,51.27 47.03,51.37 49.92,51.37 51.42,49.87 52.36,49.87 52.42,49.93 52.73,49.93 52.9,49.77 53.15,49.77 53.33,49.95 53.6,49.95 53.78,49.77 54.49,49.77 54.69,49.96 57.14,49.96 57.33,49.77 72.81,49.77 73.51,49.06 74.46,49.06 74.57,48.95 74.57,47.29 74.64,47.23 74.86,47.23 74.97,47.33 74.97,47.5 75.07,47.61 75.29,47.61 75.38,47.52 75.38,47.34 75.47,47.25 75.64,47.25 75.73,47.34 75.73,47.52 75.82,47.61 76,47.61 76.09,47.52 76.09,47.34 76.18,47.25 76.35,47.25 76.44,47.34 76.44,47.52 76.53,47.61 76.71,47.61 76.8,47.52 76.8,47.34 76.89,47.25 77.07,47.25 77.15,47.34 77.15,47.5 77.26,47.61 77.43,47.61 77.54,47.5 77.54,47.37 77.64,47.27 80.4,47.27 80.5,47.16 80.5,44.44 80.78,44.16 81.11,44.16 81.21,44.05 81.21,43.91 81.11,43.8 80.63,43.8 80.12,44.31 80.12,46.74 80.02,46.85 v2(76.46,46.85)
  BOTTOM w0.102: v2(76.46,46.85) 76.66,47.05 79.18,47.05 U2030.AP32
M_B_DQ34: length 58.9
  TOP w0.102: v2(46.7,47.82) 46.42,46.97 46.34,46.87 U2014.B8
  IN3 w0.089: v2(75.79,43.67) 75.79,43.96 75.95,44.12 77.83,44.12 77.93,44.23 77.93,44.37 77.83,44.48 75.7,44.48 75.29,44.07 67.89,44.07 66.29,45.67 66.29,46.05 66.17,46.17 65.79,46.17 65.63,46.33 65.63,46.78 65.51,46.91 65.24,46.91 65.09,46.76 64.77,46.76 64.62,46.91 58.59,46.91 58.48,47.01 58.48,47.18 58.59,47.28 60.65,47.28 60.78,47.41 60.78,47.59 60.7,47.66 58.15,47.66 58,47.51 58,47.03 57.87,46.91 57.44,46.91 57.36,46.99 57.36,47.08 57.23,47.21 51.05,47.21 49.64,48.62 47.94,48.62 47.14,47.82 v2(46.7,47.82)
  BOTTOM w0.089: U2030.AT29 80.04,45.51 79.68,45.14 79.53,45.14 79.36,45.31 78.86,45.31 78.73,45.19
  BOTTOM w0.102: v2(75.79,43.67) 76.09,43.97 76.09,44.14 75.97,44.26 74.17,44.26 74.05,44.38 74.05,45.9 74.17,46.02 74.78,46.02 74.9,45.9 74.9,45.73 74.78,45.61 74.58,45.61 74.46,45.49 74.46,44.81 74.58,44.69 76.4,44.69 76.52,44.57 76.52,44.21 76.64,44.1 76.8,44.1 76.92,44.21 76.92,44.57 77.04,44.69 77.57,44.69 77.72,44.83 78.37,44.83 78.73,45.19
M_B_DQ35: length 57.9
  TOP w0.102: U2014.D7 v2(44.64,49.01)
  IN3 w0.089: v2(77.06,43.67) 77.13,43.59 77.42,43.59 77.61,43.78 77.94,43.78 78.13,43.59 78.32,43.59 78.44,43.72 78.44,43.9 78.28,44.06 78.28,44.69 78.15,44.82 75.56,44.82 75.15,44.41 68.03,44.41 67.22,45.22 67.22,45.58 67.12,45.68 66.76,45.68 66.64,45.81 66.64,45.99 66.76,46.11 67.09,46.11 67.22,46.24 67.22,46.38 67.09,46.51 66.07,46.51 65.98,46.6 65.98,46.75 66.1,46.88 67.13,46.88 67.22,46.97 67.22,47.14 67.12,47.25 61.26,47.25 61.2,47.31 61.2,47.53 61.28,47.61 64.98,47.61 65.11,47.74 65.11,47.91 65,48.02 57.81,48.02 57.34,47.55 54.63,47.55 54.41,47.77 54.23,47.77 54.02,47.55 51.19,47.55 49.79,48.96 48.31,48.96 48.18,49.08 47.93,49.08 47.11,48.27 46.3,48.27 46.21,48.18 46.21,47.87 46.1,47.76 45.95,47.76 45.86,47.85 45.86,48.18 45.77,48.27 44.84,48.27 44.64,48.46 v2(44.64,49.01)
  BOTTOM w0.102: U2030.AU32 78.85,45.01 78.45,44.61 78,44.61 v2(77.06,43.67)
M_B_DQ36: length 57.6
  TOP w0.102: U2014.C2 v2(44.93,51.53)
  IN3 w0.089: v2(77.77,48.01) 78.17,47.61 80.43,47.61 80.54,47.71 80.54,48.9 80.62,48.99 81,48.99 81.09,49.08 81.09,49.26 81,49.34 80.62,49.34 80.54,49.43 80.54,49.61 80.62,49.7 81,49.7 81.09,49.79 81.09,50.1 80.91,50.28 80.1,50.28 79.13,49.31 78.76,49.31 78.59,49.14 77.49,49.14 76.54,50.09 73.94,50.09 73.16,50.87 73.16,51.33 73.05,51.43 60.66,51.43 60.11,51.98 54.61,51.98 54.52,52.07 54.52,52.45 54.43,52.54 54.25,52.54 54.16,52.45 54.16,52.07 54.07,51.98 53.87,51.98 53.78,52.07 53.78,52.73 53.69,52.82 53.51,52.82 53.42,52.73 53.42,52.07 53.34,51.98 53.16,51.98 53.07,52.07 53.07,52.73 52.98,52.82 52.8,52.82 52.71,52.73 52.71,52.07 52.62,51.98 52.45,51.98 52.36,52.07 52.36,52.73 52.27,52.82 52.09,52.82 52,52.73 52,52.07 51.91,51.98 51.74,51.98 51.65,52.07 51.65,52.73 51.56,52.82 51.38,52.82 51.29,52.73 51.29,52.07 51.2,51.98 51.02,51.98 50.89,52.11 50.89,52.78 50.77,52.9 48.81,52.9 48.67,53.05 45.51,53.05 45.37,52.91 44.86,52.91 44.55,52.6 44.55,51.65 44.68,51.53 v2(44.93,51.53)
  BOTTOM w0.102: v2(77.77,48.01) 78.26,48.5 79.16,48.5 79.53,48.13 79.89,48.13 U2030.AN30
M_B_DQ37: length 57.8
  TOP w0.102: U2014.C3 v2(44.93,50.73)
  IN3 w0.089: v2(76.5,48.01) 76.9,48.41 78.75,48.41 78.85,48.3 78.85,48.07 78.96,47.97 79.19,47.97 79.3,48.07 79.3,48.45 79.4,48.55 79.59,48.55 79.69,48.45 79.69,48.2 79.82,48.07 80.04,48.07 80.15,48.17 80.15,49.31 80.07,49.39 79.69,49.39 79.24,48.93 78.87,48.93 78.73,48.79 76.9,48.79 76.7,48.99 76.7,49.44 76.39,49.74 73.8,49.74 73.05,50.49 69.73,50.49 69.62,50.61 69.62,51 69.53,51.09 69.35,51.09 69.26,51 69.26,50.58 69.17,50.49 68.19,50.49 68.1,50.58 68.1,51 68.01,51.09 67.83,51.09 67.74,51 67.74,50.58 67.65,50.49 66.63,50.49 66.54,50.58 66.54,51 66.45,51.09 66.28,51.09 66.19,51 66.19,50.58 66.1,50.49 65.3,50.49 65.19,50.6 65.19,50.99 65.09,51.09 62.16,51.09 62.06,50.99 62.06,50.6 61.95,50.49 61.51,50.49 60.91,51.09 59.33,51.09 59.24,51.18 59.24,51.49 59.09,51.64 57.73,51.64 57.22,51.13 55.44,51.13 55.35,51.22 55.35,51.54 55.25,51.64 55.08,51.64 55,51.55 55,51.22 54.91,51.13 53.15,51.13 53.06,51.22 53.06,51.55 52.97,51.64 52.79,51.64 52.7,51.55 52.7,51.22 52.61,51.13 51.13,51.13 50.5,51.76 50.5,52.41 50.38,52.53 50.22,52.53 50.11,52.41 50.11,52.18 49.98,52.06 49.8,52.06 49.71,52.14 49.71,52.47 49.62,52.56 49.45,52.56 49.36,52.47 49.36,52.14 49.27,52.06 48.79,52.06 48.56,52.29 48.56,52.62 48.47,52.71 45.65,52.71 45.51,52.57 45.07,52.57 44.94,52.44 44.94,52.08 45.33,51.69 45.33,50.9 45.16,50.73 v2(44.93,50.73)
  BOTTOM w0.102: U2030.AP31 79.44,47.68 78.97,47.68 78.82,47.52 76.98,47.52 v2(76.5,48.01)
M_B_DQ38: length 57.8
  TOP w0.102: U2014.C7 44.53,47.67 v2(45.27,49.01)
  IN3 w0.089: v2(78.22,45.56) 78.3,45.64 78.3,45.96 78.2,46.06 77.47,46.06 77.34,46.19 77.34,46.38 77.47,46.5 79.66,46.5 79.78,46.38 79.78,46.06 79.68,45.96 78.92,45.96 78.81,45.86 78.81,45.64 78.93,45.53 79.65,45.53 79.78,45.4 79.78,44.24 79.68,44.13 79.56,44.13 79.54,44.14 79.41,44.27 79.41,45.04 79.28,45.16 79.1,45.16 78.97,45.04 78.97,44.15 78.88,44.07 78.76,44.07 78.62,44.21 78.62,45.04 78.49,45.16 75.42,45.16 75.01,44.75 68.18,44.75 68.05,44.88 68.05,45.15 67.92,45.28 67.65,45.28 67.56,45.37 67.56,45.54 67.65,45.63 67.91,45.63 67.99,45.72 67.99,45.9 67.91,45.99 67.65,45.99 67.56,46.08 67.56,46.26 67.65,46.34 67.91,46.34 67.99,46.43 67.99,46.61 67.91,46.7 67.65,46.7 67.56,46.79 67.56,46.97 67.65,47.06 67.91,47.06 67.99,47.14 67.99,47.49 67.89,47.59 65.57,47.59 65.45,47.71 65.45,48.26 65.34,48.36 57.66,48.36 57.2,47.9 54.77,47.9 54.42,48.25 54.22,48.25 53.87,47.9 51.47,47.9 51.34,48.02 51.34,48.22 51.22,48.35 50.88,48.35 49.93,49.3 49.68,49.3 49.56,49.43 49.56,49.68 49.43,49.8 49.25,49.8 49.12,49.68 49.12,49.43 48.99,49.3 48.45,49.3 48.32,49.43 48.32,49.52 48.19,49.64 48,49.64 46.96,48.61 45.26,48.61 45.16,48.71 45.16,48.89 v2(45.27,49.01)
  BOTTOM w0.089: v2(78.22,45.56) 78.37,45.7 79.35,45.7 79.54,45.9 79.9,45.9 U2030.AR30
M_B_DQ39: length 59.6
  TOP w0.102: U2014.C8 44.89,46.69 44.89,47.52 v2(45.24,47.87)
  IN3 w0.089: v2(74.52,43.67) 67.81,43.67 65.41,46.06 64.68,46.06 64.58,46.17 64.58,46.46 64.47,46.56 64.33,46.56 64.22,46.46 64.22,46.17 64.12,46.06 63.97,46.06 63.87,46.17 63.87,46.46 63.76,46.56 63.62,46.56 63.51,46.46 63.51,46.17 63.41,46.06 63.26,46.06 63.16,46.17 63.16,46.46 63.05,46.56 62.9,46.56 62.8,46.46 62.8,46.17 62.7,46.06 62.55,46.06 62.44,46.17 62.44,46.46 62.34,46.56 62.19,46.56 62.09,46.46 62.09,46.17 61.98,46.06 61.84,46.06 61.73,46.17 61.73,46.46 61.63,46.56 61.42,46.56 61.33,46.47 61.33,46.15 61.24,46.06 61.06,46.06 60.97,46.15 60.97,46.47 60.89,46.56 57.3,46.56 57,46.87 55.02,46.87 54.91,46.76 54.91,46.63 54.84,46.56 54.32,46.56 54.24,46.65 54.24,46.8 54.17,46.87 50.91,46.87 49.53,48.25 48.06,48.25 47.23,47.42 45.69,47.42 v2(45.24,47.87)
  BOTTOM w0.089: U2030.AT31 78.75,45.51 78.64,45.4
  BOTTOM w0.102: 78.64,45.4 78.28,45.04 75.37,45.04 75.25,45.16 75.25,46.26 75.13,46.38 73,46.38 72.88,46.26 72.88,42.21 73,42.09 73.17,42.09 73.29,42.21 73.29,45.71 73.41,45.83 73.58,45.83 73.7,45.71 73.7,42.67 73.82,42.55 73.98,42.55 74.1,42.67 74.1,43.55 74.22,43.67 v2(74.52,43.67)
M_B_DQ40: length 58
  TOP w0.102: U2014.G2 v2(41.73,50.73)
  IN3 w0.089: v2(76.01,42.12) 75.6,42.12 75.5,42.23 75.5,42.43 75.6,42.53 80.52,42.53 80.66,42.68 80.66,42.9 80.54,43.03 80.42,43.03 80.15,43.29 79.98,43.29 79.89,43.2 79.89,42.99 79.79,42.89 79.64,42.89 79.53,42.99 79.53,43.34 79.43,43.45 79.28,43.45 79.18,43.34 79.18,42.99 79.07,42.89 76.69,42.89 76.52,43.06 76.34,43.06 76.16,42.89 74.86,42.89 74.78,42.97 67.52,42.97 65.12,45.36 60.67,45.36 60.17,45.86 53.3,45.86 53.11,46.06 51.74,46.06 51.55,45.86 50.92,45.86 49.51,47.28 48.08,47.28 47.52,46.72 45.4,46.72 43.94,48.17 43.94,49.2 42.93,50.21 42.93,50.93 42.73,51.13 42.13,51.13 v2(41.73,50.73)
  BOTTOM w0.089: 78.96,44.22 79.06,44.31 79.38,44.31 79.54,44.15 79.7,44.15 80.06,44.51 U2030.AU29
  BOTTOM w0.102: 78.96,44.22 76.87,42.12 v2(76.01,42.12)
M_B_DQ41: length 58
  TOP w0.102: U2014.H3 v2(40.93,49.93)
  IN3 w0.089: v2(40.93,49.93) 42.24,49.93 43.25,48.91 43.25,47.89 44.53,46.62 44.53,45.76 44.74,45.55 47.32,45.55 47.87,46.1 48.17,46.1 48.29,46.23 48.29,46.47 48.42,46.6 49.22,46.6 49.33,46.49 49.33,46.23 49.46,46.1 49.72,46.1 51.14,44.68 64.84,44.68 67.24,42.27 67.63,42.27 67.7,42.2 67.7,42 67.83,41.88 74.12,41.88 74.28,41.72 74.79,41.72 74.88,41.63 74.88,41.27 74.96,41.18 75.14,41.18 75.23,41.27 75.23,41.63 75.32,41.72 76.29,41.72 76.76,42.19 80.64,42.19 80.77,42.06 80.77,41.95 80.64,41.82 80.06,41.82 79.97,41.73 79.97,41.3 79.88,41.21 79.71,41.21 79.62,41.3 79.62,41.73 79.53,41.82 77.2,41.82 v2(76.54,41.16)
  BOTTOM w0.102: U2030.AV30 80.01,43.47 79.38,42.84 78.6,42.84 76.92,41.16 v2(76.54,41.16)
M_B_DQ42: length 57.9
  TOP w0.102: U2014.H8 40.96,45.89 40.96,44.6 v2(40.97,44.59)
  IN3 w0.089: v2(79.18,40.12) 79.01,39.94 78.59,39.94 78.46,39.82 78.46,39.34 78.59,39.22 79.26,39.22 79.35,39.3 79.35,39.65 79.44,39.74 79.62,39.74 79.7,39.65 79.7,39.3 79.79,39.22 79.97,39.22 80.06,39.3 80.06,39.88 80.15,39.97 80.3,39.97 80.42,39.85 80.42,39.3 80.5,39.22 80.68,39.22 80.77,39.3 80.77,39.65 80.86,39.74 81.04,39.74 81.13,39.65 81.13,39.3 81.22,39.22 81.38,39.22 81.47,39.13 81.47,38.92 81.38,38.84 75.13,38.84 75.01,38.71 75.01,38.4 73.49,36.88 70.25,36.88 69.81,37.32 69.81,38.42 69.68,38.55 64.04,38.55 63.59,38.99 63.59,40.85 62.71,41.73 50.78,41.73 49.3,43.21 42.26,43.21 40.97,44.5 v2(40.97,44.59)
  BOTTOM w0.102: v2(79.18,40.12) 79.18,40.24 80.11,41.17 U2030.BB30
M_B_DQ43: length 57.6
  TOP w0.102: v2(40.35,48.35) 40.35,47.75 U2014.J7
  IN3 w0.089: v2(40.35,48.35) 40.61,48.08 40.61,47.23 40.72,47.13 41.05,47.13 41.29,46.89 41.29,46.56 40.53,45.79 40.53,44.46 42.11,42.87 49.15,42.87 50.64,41.39 62.57,41.39 63.25,40.71 63.25,38.85 63.9,38.2 69.16,38.2 69.47,37.9 69.47,37.08 70.02,36.53 73.62,36.53 75.59,38.49 81.52,38.49 81.81,38.78 81.81,39.5 81.29,40.02 81.29,40.25 81.37,40.33 81.37,40.47 81.27,40.57 81.1,40.57 81.06,40.52 80.78,40.52 80.55,40.75 v2(80.55,41.08)
  BOTTOM w0.102: v2(80.55,41.08) 80.55,41.45 U2030.BA28
M_B_DQ44: length 58.1
  TOP w0.102: U2014.H2 v2(40.93,50.73)
  IN3 w0.089: v2(40.93,50.73) 40.93,50.88 41.04,51 41.22,51 41.33,50.9 41.33,50.45 41.45,50.33 42.33,50.33 43.6,49.06 43.6,48.03 44.92,46.71 44.92,46.5 45.05,46.37 45.87,46.37 46,46.24 46.21,46.24 46.34,46.37 46.78,46.37 46.91,46.25 46.91,46.08 47.03,45.96 47.24,45.96 48.22,46.94 49.36,46.94 51.03,45.27 51.21,45.27 51.46,45.52 51.69,45.52 51.88,45.71 52.13,45.71 52.33,45.51 52.57,45.51 52.77,45.71 52.96,45.71 53.15,45.52 53.93,45.52 54.02,45.43 54.02,45.11 54.11,45.02 54.28,45.02 54.37,45.11 54.37,45.43 54.46,45.52 54.64,45.52 54.73,45.43 54.73,45.11 54.82,45.02 55,45.02 55.08,45.11 55.08,45.43 55.17,45.52 55.35,45.52 55.44,45.43 55.44,45.11 55.53,45.02 55.71,45.02 55.8,45.11 55.8,45.43 55.88,45.52 57.49,45.52 57.57,45.43 57.57,45.11 57.66,45.02 57.84,45.02 57.93,45.11 57.93,45.43 58.02,45.52 58.2,45.52 58.29,45.43 58.29,45.11 58.37,45.02 58.55,45.02 58.64,45.11 58.64,45.43 58.73,45.52 58.91,45.52 59,45.43 59,45.11 59.09,45.02 59.26,45.02 59.35,45.11 59.35,45.39 59.48,45.52 60.02,45.52 60.15,45.39 60.15,45.1 60.23,45.02 64.98,45.02 67.37,42.63 67.94,42.63 68.03,42.54 68.03,42.31 68.11,42.22 68.29,42.22 68.38,42.31 68.38,42.54 68.47,42.63 68.65,42.63 68.74,42.54 68.74,42.31 68.83,42.22 69,42.22 69.09,42.31 69.09,42.54 69.18,42.63 69.36,42.63 69.45,42.54 69.45,42.31 69.54,42.22 69.71,42.22 69.8,42.31 69.8,42.54 69.89,42.63 70.07,42.63 70.16,42.54 70.16,42.31 70.25,42.22 70.43,42.22 70.51,42.31 70.51,42.54 70.6,42.63 70.78,42.63 70.87,42.54 70.87,42.31 70.96,42.22 71.14,42.22 71.23,42.31 71.23,42.54 71.31,42.63 71.49,42.63 71.58,42.54 71.58,42.31 71.67,42.22 71.85,42.22 71.94,42.31 71.94,42.54 72.03,42.63 72.2,42.63 72.29,42.54 72.29,42.31 72.38,42.22 72.56,42.22 72.65,42.31 72.65,42.54 72.74,42.63 72.91,42.63 73,42.54 73,42.31 73.09,42.22 73.27,42.22 73.36,42.31 73.36,42.54 73.45,42.63 73.63,42.63 73.71,42.54 73.71,42.31 73.8,42.22 73.98,42.22 74.07,42.31 74.07,42.5 74.2,42.63 74.63,42.63 74.76,42.5 74.76,42.32 v1(74.56,42.12)
  BOTTOM w0.089: U2030.AU30 79.83,44.83 79.48,44.83 79.36,44.71 78.86,44.71
  BOTTOM w0.102: 78.86,44.71 78.38,44.23 78.24,44.23 77.23,43.22 75.65,43.22 v1(74.56,42.12)
M_B_DQ45: length 58.2
  TOP w0.102: U2014.J3 40.81,49.24 v2(40.81,48.97)
  IN3 w0.089: v2(40.81,48.97) 40.77,49.01 40.77,49.34 40.96,49.53 41.17,49.53 41.26,49.44 41.44,49.44 41.58,49.58 42.1,49.58 42.56,49.13 42.56,48.89 42.68,48.76 42.82,48.76 42.91,48.67 42.91,48.4 42.68,48.16 42.68,47.98 44.18,46.48 44.18,45.62 44.59,45.21 47.46,45.21 48.01,45.76 49.58,45.76 51,44.33 64.7,44.33 66.91,42.11 66.91,40.68 67.04,40.55 67.22,40.55 67.31,40.64 67.31,41.58 67.4,41.67 67.55,41.67 67.67,41.55 67.67,40.64 67.76,40.55 67.93,40.55 68.02,40.64 68.02,41.45 68.11,41.53 68.29,41.53 68.38,41.45 68.38,40.64 68.47,40.55 68.64,40.55 68.73,40.64 68.73,41.45 68.82,41.53 69,41.53 69.09,41.45 69.09,40.64 69.18,40.55 69.36,40.55 69.44,40.64 69.44,41.45 69.53,41.53 69.71,41.53 69.8,41.45 69.8,40.64 69.89,40.55 70.07,40.55 70.16,40.64 70.16,41.45 70.24,41.53 70.42,41.53 70.51,41.45 70.51,41.17 70.6,41.08 70.75,41.08 70.9,41.23 70.9,41.41 71.03,41.53 73.96,41.53 v2(74.36,41.13)
  BOTTOM w0.089: U2030.AU31 79.61,44.51 78.96,44.51
  BOTTOM w0.102: v2(74.36,41.13) 74.75,41.13 75.55,41.93 75.55,42.33 76.08,42.86 77.32,42.86 78.96,44.51
M_B_DQ46: length 58.1
  TOP w0.102: v2(41.01,47.61) 41.01,47.61 U2014.H7
  IN3 w0.089: v2(41.01,47.61) 41.08,47.61 41.58,47.1 42.1,47.1 42.35,46.85 42.35,45.02 42.71,44.67 42.71,44.05 42.86,43.9 49.58,43.9 50.89,42.6 51.07,42.6 51.19,42.72 51.19,42.9 51.32,43.03 53.57,43.03 53.66,42.94 53.66,42.51 53.75,42.42 53.93,42.42 54.02,42.51 54.02,42.94 54.11,43.03 55.31,43.03 55.37,42.96 55.88,42.96 55.94,43.03 56.3,43.03 56.45,42.87 56.83,42.87 56.98,43.03 57.4,43.03 57.49,42.94 57.49,42.53 57.6,42.42 57.75,42.42 57.84,42.51 57.84,42.94 57.93,43.03 58.11,43.03 58.2,42.94 58.2,42.53 58.31,42.42 58.47,42.42 58.55,42.51 58.55,42.94 58.64,43.03 58.82,43.03 58.91,42.94 58.91,42.53 59.02,42.42 59.18,42.42 59.27,42.51 59.27,42.94 59.35,43.03 60.02,43.03 60.16,42.89 60.16,42.54 60.28,42.42 60.46,42.42 60.55,42.51 60.55,42.94 60.64,43.03 60.82,43.03 60.91,42.94 60.91,42.51 61,42.42 61.17,42.42 61.26,42.51 61.26,42.94 61.35,43.03 61.53,43.03 61.62,42.94 61.62,42.51 61.71,42.42 61.89,42.42 61.97,42.51 61.97,42.94 62.06,43.03 62.24,43.03 62.33,42.94 62.33,42.51 62.42,42.42 62.58,42.42 62.7,42.53 62.7,42.76 62.83,42.89 62.98,42.89 63.08,42.79 63.08,42.33 63.21,42.21 63.33,42.21 63.43,42.31 63.56,42.31 63.68,42.18 63.68,42.06 63.58,41.96 63.58,41.83 63.7,41.71 63.82,41.71 63.91,41.8 64.04,41.8 64.16,41.68 64.16,41.55 64.08,41.46 64.08,41.34 64.28,41.13 64.28,40.06 65.11,39.23 70.47,39.23 70.61,39.09 70.61,37.69 70.74,37.57 73.2,37.57 74.26,38.63 v2(74.26,39.66)
  BOTTOM w0.102: U2030.AY32 78.78,42.51 77,40.72 75.72,40.72 75.12,40.12 74.72,40.12 v2(74.26,39.66)
M_B_DQ47: length 57.8
  TOP w0.102: v2(41.72,46.69) 42.13,47.1 U2014.F7
  IN3 w0.089: v2(41.72,46.69) 41.72,46.49 41.33,46.09 41.33,45.6 41.23,45.5 40.93,45.5 40.87,45.44 40.87,45.25 41,45.12 41.16,45.12 41.44,44.84 41.44,44.52 41.55,44.4 41.68,44.4 41.85,44.57 42,44.57 42.11,44.47 42.11,44.33 41.93,44.15 41.93,44.03 42.4,43.56 49.44,43.56 50.92,42.07 62.85,42.07 63.94,40.99 63.94,39.79 64.06,39.66 64.2,39.66 64.34,39.52 64.34,39.39 64.09,39.14 64.09,39.02 64.22,38.89 64.34,38.89 64.59,39.14 64.72,39.14 64.97,38.89 69.92,38.89 70.22,38.59 70.22,37.4 70.39,37.22 73.34,37.22 74.66,38.54 74.66,39.05 74.86,39.25 77.25,39.25 77.34,39.34 77.34,40.14 77.21,40.27 76.73,40.27 76.64,40.36 76.64,40.5 76.77,40.62 77.21,40.62 77.34,40.75 77.34,41.35 77.46,41.48 77.9,41.48 78.03,41.35 78.03,41.17 77.69,40.84 77.69,39.27 77.78,39.18 77.99,39.18 78.12,39.31 78.12,40.33 78.21,40.43 78.79,40.43 v2(79.2,40.84)
  BOTTOM w0.102: U2030.AY29 79.67,41.77 79.67,41.32 v2(79.2,40.84)
M_B_DQ48: length 62.6
  TOP w0.102: v2(40.88,39.35) 41.28,39.75 U2013.G2
  IN3 w0.089: v2(61.89,39.08) 61.49,39.48 61.11,39.48 60.58,40 57.93,40 57.75,39.83 50.24,39.83 48.68,41.38 44.83,41.38 44.72,41.49 41.69,41.49 41.33,41.12 41.33,39.95 40.88,39.51 v2(40.88,39.35)
  BOTTOM w0.102: U2030.BA27 82.01,41.56 81.54,41.08 81.54,40.49 81.07,40.02 81.07,39.82 79.77,38.52 76.67,38.52 76.3,38.37 73.84,38.37 71.46,40.75 71.46,43.14 70.39,44.21 69.95,44.21 69.85,44.31 69.85,44.59 69.74,44.69 69.54,44.69 69.44,44.59 69.44,44.31 69.34,44.21 69.13,44.21 69.03,44.31 69.03,44.59 68.93,44.69 68.73,44.69 68.63,44.59 68.63,44.31 68.53,44.21 68.32,44.21 68.22,44.31 68.22,44.59 68.12,44.69 67.92,44.69 67.81,44.59 67.81,44.31 67.71,44.21 67.51,44.21 67.41,44.31 67.41,44.59 67.31,44.69 67.1,44.69 67,44.59 67,44.31 66.9,44.21 66.7,44.21 66.59,44.31 66.59,44.59 66.49,44.69 66.29,44.69 66.19,44.59 66.19,44.31 66.09,44.21 65.88,44.21 65.78,44.31 65.78,44.59 65.68,44.69 65.48,44.69 65.38,44.59 65.38,44.31 65.27,44.21 65.07,44.21 64.97,44.31 64.97,44.59 64.87,44.69 64.66,44.69 64.56,44.59 64.56,44.31 64.46,44.21 64.26,44.21 64.16,44.31 64.16,44.59 64.05,44.69 63.85,44.69 63.75,44.59 63.75,44.31 63.65,44.21 63.28,44.21 63.18,44.31 63.18,44.46 63.08,44.56 62.77,44.56 62.65,44.44 62.65,41.08 63.28,40.45 63.28,39.94 63.03,39.69 62.01,39.69 61.89,39.56 v2(61.89,39.08)
M_B_DQ49: length 61.9
  TOP w0.102: U2013.H3 v2(40.93,38.55)
  IN3 w0.089: v2(60.59,39.05) 60.59,39.51 60.44,39.66 59.55,39.66 59.46,39.57 59.46,39 59.38,38.91 59.2,38.91 59.11,39 59.11,39.57 59.02,39.66 58.84,39.66 58.75,39.57 58.75,39 58.66,38.91 58.49,38.91 58.4,39 58.4,39.57 58.31,39.66 58.08,39.66 57.97,39.56 57.97,38.97 57.91,38.91 57.69,38.91 57.57,39.04 57.57,39.33 57.42,39.48 50.1,39.48 48.54,41.04 44.68,41.04 44.58,41.14 42.31,41.14 42.15,40.98 42.15,39.91 42.02,39.79 41.49,39.79 41.28,39.58 41.28,38.91 v2(40.93,38.55)
  BOTTOM w0.102: U2030.BC27 81.75,40.85 81.75,40.4 81.36,40.01 81.36,39.6 79.92,38.16 76.74,38.16 76.37,38.01 73.69,38.01 71.11,40.59 71.11,42.99 70.24,43.85 63.77,43.85 63.64,43.72 63.64,43.31 63.54,43.21 63.1,43.21 63,43.11 63,42.91 63.1,42.81 63.54,42.81 63.64,42.71 63.64,42.5 63.54,42.4 63.1,42.4 63,42.3 63,42.1 63.1,41.99 63.54,41.99 63.64,41.89 63.64,41.69 63.54,41.59 63.1,41.59 63,41.49 63,41.28 63.1,41.18 63.54,41.18 63.64,41.08 63.64,39.79 63.03,39.18 62.6,39.18 62.07,38.64 61,38.64 v2(60.59,39.05)
M_B_DQ50: length 60.8
  TOP w0.102: U2013.H8 v2(40.13,35.35)
  IN3 w0.089: v2(40.13,35.35) 40.53,35.75 42.23,35.75 43.27,36.79 43.27,37.63 44.01,38.37 45.15,38.37 45.28,38.24 47.99,38.24 51.1,35.13 55.2,35.13 55.93,35.86 60.2,35.86 60.59,36.24 66.24,36.24 66.94,36.94 68.33,36.94 v2(69.02,37.63)
  BOTTOM w0.089: 83.85,39.77 84.21,40.12 84.21,40.84 84.37,41 84.37,41.2 84.01,41.56 U2030.BA24
  BOTTOM w0.102: 83.85,39.77 83.85,38.61 80.96,35.72 77.81,35.72 76.77,35.29 72.58,35.29 70.54,37.33 70.34,37.33 70.01,37.65 70.01,37.86 68.9,38.98 66.74,38.98 66.61,38.85 66.61,38.66 66.74,38.53 68.62,38.53 69.02,38.13 v2(69.02,37.63)
M_B_DQ51: length 61.3
  TOP w0.102: U2013.F7 v2(41.73,36.15)
  IN3 w0.089: v2(67.68,37.65) 67.3,37.28 66.79,37.28 66.1,36.59 60.45,36.59 60.06,36.2 55.79,36.2 55.06,35.48 51.26,35.48 48.15,38.59 45.42,38.59 45.29,38.71 43.87,38.71 42.93,37.77 42.93,36.94 42.15,36.15 v2(41.73,36.15)
  BOTTOM w0.089: 83.92,40.17 84.01,40.26 U2030.BC24
  BOTTOM w0.102: v2(67.68,37.65) 67.68,38.05 67.55,38.18 66.33,38.18 65.9,38.61 65.9,39.2 66.03,39.33 67.91,39.33 68.01,39.43 68.01,39.61 67.88,39.74 66.03,39.74 65.9,39.86 65.9,40.04 66.03,40.17 68.21,40.17 72.66,35.72 76.85,35.72 77.71,36.08 80.81,36.08 83.63,38.9 83.63,39.88 83.92,40.17
M_B_DQ52: length 62.3
  TOP w0.102: U2013.J3 39.75,38.95 v2(40.14,39.34)
  IN3 w0.089: v2(40.14,39.34) 40.54,39.74 40.54,40.29 40.87,40.62 40.87,41.32 41.38,41.83 44.87,41.83 44.97,41.73 48.83,41.73 50.38,40.17 57.61,40.17 57.79,40.35 61.05,40.35 61.15,40.25 61.15,39.92 61.25,39.82 61.48,39.82 61.58,39.92 v2(61.58,40.12)
  BOTTOM w0.102: U2030.BD28 80.87,40.71 79.39,39.23 76.52,39.23 76.21,39.1 74.11,39.1 72.17,41.04 72.17,46.11 72.07,46.21 69.25,46.21 69.15,46.11 69.15,45.91 69.25,45.81 71.59,45.81 71.69,45.71 71.69,45.5 71.59,45.4 61.53,45.4 61.4,45.27 v2(61.4,40.75) 61.4,40.3 v2(61.58,40.12)
M_B_DQ53: length 62.1
  TOP w0.102: U2013.H2 v2(40.14,40.14)
  IN3 w0.089: v2(62.85,40.12) 62.28,40.69 57.64,40.69 57.47,40.51 50.53,40.51 48.97,42.07 45.11,42.07 45.01,42.17 41.23,42.17 40.53,41.47 40.53,40.78 40.14,40.39 v2(40.14,40.14)
  BOTTOM w0.102: v2(62.85,40.12) 62.85,40.37 62.34,40.88 62.06,40.88 61.94,41.01 61.94,41.21 62.04,41.31 62.16,41.31 62.29,41.44 62.29,41.67 62.19,41.77 61.86,41.77 61.76,41.87 61.76,42.07 61.86,42.17 62.19,42.17 62.29,42.27 62.29,42.48 62.19,42.58 61.86,42.58 61.76,42.68 61.76,42.88 61.86,42.99 62.19,42.99 62.29,43.09 62.29,43.29 62.19,43.39 61.86,43.39 61.76,43.49 61.76,43.7 61.86,43.8 62.19,43.8 62.29,43.9 62.29,44.1 62.19,44.21 61.86,44.21 61.76,44.31 61.76,44.51 61.86,44.61 62.19,44.61 62.29,44.71 62.29,44.92 62.42,45.05 71.69,45.05 71.82,44.92 71.82,44.74 71.69,44.61 70.87,44.61 70.77,44.51 70.77,44.33 70.9,44.21 71.69,44.21 71.82,44.08 71.82,40.9 73.99,38.72 76.23,38.72 76.6,38.87 79.53,38.87 80.38,39.72 80.47,39.72 81.32,40.58 81.32,41.32 U2030.BB27
M_B_DQ54: length 60.5
  TOP w0.102: U2013.H7 v2(40.93,36.15)
  IN3 w0.089: v2(66.31,37.7) 66.31,37.28 65.96,36.93 65.78,36.93 65.69,37.02 65.69,37.42 65.6,37.51 65.42,37.51 65.34,37.42 65.34,37.02 65.25,36.93 65.04,36.93 64.77,37.2 64.55,37.2 64.29,36.93 60.31,36.93 59.92,36.54 59.44,36.54 59.35,36.63 59.35,37.02 59.26,37.11 59.09,37.11 59,37.02 59,36.63 58.91,36.54 58.73,36.54 58.64,36.63 58.64,37.02 58.55,37.11 58.37,37.11 58.29,37.02 58.29,36.63 58.2,36.54 57.97,36.54 57.9,36.62 57.9,37.03 57.82,37.11 57.64,37.11 57.52,36.98 57.52,36.62 57.44,36.54 53.17,36.54 52.93,36.78 52.63,36.78 52.39,36.54 51.22,36.54 51.09,36.67 51.09,36.94 50.98,37.05 50.84,37.05 50.6,36.8 50.44,36.8 48.32,38.93 45.56,38.93 45.43,39.06 43.73,39.06 42.59,37.92 42.59,37.08 42.14,36.63 41.4,36.63 v2(40.93,36.15)
  BOTTOM w0.089: 83.73,40.31 83.82,40.4 83.82,40.84 83.7,40.96 83.7,41.32 U2030.BB25
  BOTTOM w0.102: v2(66.31,37.7) 65.54,38.46 65.54,40.4 65.67,40.53 68.59,40.53 73.02,36.09 76.49,36.09 77.32,36.44 80.67,36.44 83.42,39.19 83.42,40 83.73,40.31
M_B_DQ55: length 60.6
  TOP w0.102: U2013.J7 v2(40.13,36.15)
  IN3 w0.089: v2(64.48,37.68) 64.07,37.27 60.35,37.27 60.17,37.45 55.16,37.45 55.07,37.36 55.07,36.97 54.98,36.89 54.81,36.89 54.72,36.97 54.72,37.36 54.63,37.45 54.45,37.45 54.36,37.36 54.36,36.97 54.27,36.89 54.09,36.89 54.01,36.97 54.01,37.36 53.92,37.45 53.74,37.45 53.65,37.36 53.65,36.97 53.56,36.89 53.38,36.89 53.29,36.97 53.29,37.36 53.21,37.45 52.94,37.45 52.79,37.3 52.47,37.3 52.32,37.45 50.28,37.45 48,39.73 47.62,39.73 47.53,39.64 47.53,39.36 47.44,39.27 47.26,39.27 47.17,39.36 47.17,39.64 47.09,39.73 44.76,39.73 44.43,39.4 43.59,39.4 42.25,38.06 42.25,37.22 42,36.97 41.51,36.97 41.42,37.06 41.42,37.99 41.31,38.1 41.16,38.1 41.03,37.98 41.03,37.78 40.32,37.07 40.32,36.35 v2(40.13,36.15)
  BOTTOM w0.102: v2(64.48,37.68) 64.63,37.53 65.47,37.53 65.57,37.63 65.57,37.94 65.19,38.32 65.19,40.76 65.31,40.88 68.82,40.88 73.16,36.54 76.59,36.54 77.2,36.79 80.52,36.79 83.2,39.47 83.2,40.16 83.51,40.47 U2030.BD25
